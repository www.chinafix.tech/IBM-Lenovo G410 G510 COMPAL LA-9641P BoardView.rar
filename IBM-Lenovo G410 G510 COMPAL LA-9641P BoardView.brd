# Allegro board IBM-Lenovo G410 G510 COMPAL LA-9641P BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MDA22: length 34.5
  TOP w0.127: UV5.F2 112.03,130.04 v2(112.42,129.65)
  IN2 w0.102: v2(112.42,129.65) 112.42,129.33 112.53,129.22 112.71,129.22 112.82,129.33 112.82,132.57 112.92,132.68 113.27,132.68 113.39,132.79 113.39,132.96 113.27,133.08 112.92,133.08 112.82,133.18 112.82,133.63
  IN2 w0.157: 112.82,133.63 112.82,133.69 112.95,133.81 116.26,133.81 116.37,133.7 116.37,133.26 116.24,133.13 115.69,133.13 115.56,133 115.56,132.64 115.69,132.51 116.98,132.51 117.11,132.64 117.11,133.64 117.24,133.76 119.67,133.76 119.79,133.89 119.79,134.26 119.67,134.39 116.75,134.39 116.62,134.52 116.62,134.93 116.75,135.06 119.48,135.06 119.62,135.21 119.62,135.54 119.47,135.7 117.11,135.7 116.99,135.82 116.99,136.2 117.11,136.33 119.34,136.33 120.3,137.29 121.2,137.29 v2(121.42,137.51)
  BOTTOM w0.102: v2(121.42,137.51) 121.42,137.79 121.7,138.07 UV1.A24
MDA23: length 35.2
  TOP w0.127: v2(111.62,128.85) 111.23,129.24 UV5.E3
  IN2 w0.102: v2(111.62,128.85) 111.58,128.89 111.37,128.89 111.22,128.74 111.22,128.19 111.51,127.9 111.75,127.9 111.88,128.03 111.88,128.35 112.01,128.48 112.26,128.48 112.39,128.35 112.39,127.98 112.5,127.86 112.67,127.86 112.79,127.98 112.79,128.32 112.89,128.42 113.76,128.42
  IN2 w0.157: 113.76,128.42 113.88,128.53 113.88,129.49 114,129.61 114.82,129.61 114.94,129.74 114.94,130.16 114.82,130.29 113.76,130.29 113.64,130.41 113.64,130.82 113.76,130.94 113.86,130.94 113.99,131.07 113.99,131.41 113.65,131.75 113.65,133.22 113.77,133.35 114.98,133.35 115.1,133.22 115.1,132.18 115.23,132.05 120.18,132.05 120.31,132.17 120.31,132.55 120.18,132.67 117.7,132.67 117.57,132.8 117.57,133.17 117.7,133.3 120.15,133.3 120.31,133.46 120.31,135.52 120.09,135.73 120.09,136.42 120.49,136.83 121.43,136.83 121.67,137.06 123.34,137.06 123.63,137.35 v2(123.63,137.77)
  BOTTOM w0.102: UV1.E24 123.75,137.77 v2(123.63,137.77)
MDA24: length 34.4
  IN1 w0.102: v2(108.61,128.43) 108.61,127.98 109.53,127.06 112.03,127.06 112.18,126.91 114.07,126.91 ; 122.38,137.41 122.38,138.99 122.48,139.09 122.48,139.64 122.63,139.79 123.52,139.79 123.64,139.67 v2(123.64,139.37)
  IN1 w0.157: 114.07,126.91 115.23,126.91 118.18,129.87 118.46,129.87 118.69,129.63 118.92,129.63 120,130.71 120,131.36 120.14,131.5 121.54,131.5 122.38,132.34 122.38,133.97 122.22,134.13 121.7,134.13 121.55,134.28 121.55,134.6 121.7,134.76 122.22,134.76 122.38,134.91 122.38,137.41
  BOTTOM w0.102: UV6.E3 108.15,129.12 108.76,129.12 109.24,128.63 109.38,128.63 109.75,129 109.89,129 110.04,128.86 110.04,128.71 109.67,128.35 109.67,128.2 110.14,127.73 110.14,127.56 109.94,127.36 109.68,127.36 v2(108.61,128.43) ; v2(123.64,139.37) 123.34,139.67 UV1.C22
MDA25: length 33.8
  IN1 w0.102: 114.07,126 110.18,126 108.01,128.16 108.01,131.68 v2(108.38,132.05) ; v2(122.89,139.35) 123.23,139.02 123.23,137.61 122.94,137.32
  IN1 w0.157: 114.07,126 114.97,126 117.12,128.15 117.34,128.15 117.57,127.92 117.75,127.92 118.02,128.19 118.02,128.37 117.79,128.6 117.79,128.82 118,129.02 118.32,129.02 119.01,128.33 119.19,128.33 119.43,128.58 119.43,128.76 119.19,129 119.19,129.22 119.41,129.45 119.64,129.45 120,129.08 120.22,129.08 120.53,129.08 121.85,130.4 121.85,131.21 122.94,132.3 122.94,137.32
  BOTTOM w0.102: UV1.A22 122.57,139.67 v2(122.89,139.35) ; UV6.H3 108.03,131.69 v2(108.38,132.05)
MDA26: length 35
  IN1 w0.102: 123.72,137.24 124.02,137.54 124.02,138.95 v2(124.38,139.3) ; 110.6,125.1 107.21,128.49 107.21,130.83 v2(106.82,131.22)
  IN1 w0.157: 110.6,125.1 114.89,125.1 117.18,127.39 117.4,127.39 118.31,126.49 118.49,126.49 118.77,126.77 118.77,126.95 118.23,127.5 118.23,127.72 118.45,127.94 118.67,127.94 119.09,127.52 119.32,127.52 120.42,128.62 120.73,128.62 123.24,131.13 123.24,136.75 123.72,137.24
  BOTTOM w0.102: UV1.F22 124.55,139.47 v2(124.38,139.3) ; v2(106.82,131.22) 107.19,130.85 UV6.G2
MDA27: length 34.5
  IN1 w0.102: v2(124.08,140.17) 124.8,139.46 124.8,134.33 124.15,133.68 124.15,131.58 120.85,128.28 120.85,127.75 120.81,127.71 ; 109.44,124.79 106.44,127.8 106.44,129.25 v2(106.83,129.65)
  IN1 w0.157: 109.44,124.79 109.65,124.58 117.69,124.58 120.81,127.71
  BOTTOM w0.102: v2(106.83,129.65) 107.23,130.04 UV6.F2 ; v2(124.08,140.17) 123.78,140.47 UV1.D21
MDA28: length 33.9
  IN1 w0.102: v2(113.25,131.16) 113.25,131.36 113.34,131.45 113.62,131.45 113.9,131.17
  IN1 w0.157: 113.9,131.17 113.9,131 114.18,130.73 114.83,130.73 115.47,131.37 115.47,133.63 115.78,133.94 116.44,133.94 117.03,134.52 117.03,135.13 117.88,135.99 117.88,139.65 119.73,141.5 119.73,142.22 119.85,142.35 120.49,142.35 120.62,142.22 v2(120.62,141.94)
  BOTTOM w0.102: v2(113.25,131.16) 113.2,131.2 112.21,131.2 112.03,131.39 UV6.H8
  BOTTOM w0.127: v2(120.62,141.94) 119.43,141.94 118.92,141.42 117.83,141.42 117.42,141.02 115.97,141.02 115.84,140.89 115.84,140.48 115.97,140.36 117.27,140.36 117.4,140.23 117.4,139.25 117.53,139.13 v1(118.69,139.13) 120.74,139.13 120.86,139.25 120.86,140.41 121.72,141.27 UV1.A20
MDA29: length 35.1
  IN1 w0.102: 114.07,130.27 113.77,130.27 113.55,130.04 112.57,130.04 112.43,130.18 v2(112.43,130.36)
  IN1 w0.157: v2(121.23,141.92) 121.27,141.88 121.27,141.6 121.14,141.47 120.36,141.47 118.35,139.46 118.35,135.8 117.49,134.94 117.49,134.33 116.64,133.47 116.14,133.47 115.93,133.27 115.93,131.17 115.02,130.27 114.07,130.27
  BOTTOM w0.102: UV1.F20 124.85,141.54 124.79,141.6 123.11,141.6 123.04,141.54 122.63,141.54 122.58,141.58 122.18,141.58 122.08,141.49 121.63,141.49 121.01,140.87 120.81,140.87 ; v2(112.43,130.36) 112.33,130.36 112.03,130.06 UV6.F8 ; 120.81,141.51 v2(121.23,141.92)
  BOTTOM w0.127: 120.81,141.51 120.76,141.46 119.42,141.46 119.05,141.09 117.96,141.09 117.76,140.89 v1(117.76,140.66) 117.76,139.65 117.9,139.51 118.23,139.51 118.36,139.63 118.36,140.13 118.48,140.26 118.78,140.26 118.9,140.13 118.9,139.63 119.03,139.51 120.41,139.51 120.53,139.63 120.53,140.04 120.41,140.17 119.92,140.17 119.79,140.29 119.79,140.74 119.92,140.87 120.81,140.87
MDA30: length 34.4
  IN1 w0.102: 113.41,129.23 111.75,129.23 111.65,129.34 v2(111.65,129.65)
  IN1 w0.157: v2(121.8,141.92) 121.93,142.05 121.93,142.35 121.77,142.5 120.94,142.5 120.81,142.63 120.81,143.08 120.94,143.21 123.12,143.21 123.25,143.08 123.25,142.2 123.38,142.08 124.72,142.08 124.85,141.95 124.85,141.01 124.72,140.88 124.3,140.88 124.18,141.01 124.18,141.31 124.05,141.44 123.64,141.44 123.51,141.31 123.51,140.97 123.39,140.84 122.95,140.84 122.82,140.97 122.82,141.32 122.67,141.48 122.35,141.48 122.19,141.32 122.19,141.17 122.04,141.01 120.55,141.01 118.81,139.27 118.81,135.61 117.95,134.75 117.95,134.14 116.39,132.58 116.39,130.98 115.07,129.66 113.84,129.66 113.41,129.23
  BOTTOM w0.102: v2(121.8,141.92) 121.93,141.79 122.71,141.79 122.76,141.74 122.96,141.74 123.02,141.81 123.39,141.81 UV1.D19 ; v2(111.65,129.65) 111.25,130.05 UV6.F7
MDA31: length 34.7
  IN1 w0.102: 114.07,131.7 113.87,131.7 113.67,131.9 113.67,132.85 113.55,132.98 112.95,132.98 112.83,132.85 112.83,132.5 112.76,132.43 111.78,132.43 111.62,132.27 v2(111.62,132.02)
  IN1 w0.157: 114.07,131.7 114.81,131.7 115.01,131.9 115.01,133.82 115.59,134.4 116.25,134.4 116.56,134.71 116.56,135.33 117.42,136.18 117.42,139.84 119.26,141.69 119.26,142.18 118.97,142.48 117.84,142.48 117.66,142.66 117.66,142.98 117.84,143.17 118.64,143.17 118.77,143.29 118.77,144.68 118.89,144.81 119.41,144.81 119.54,144.68 119.54,142.94 119.67,142.81 120.19,142.81 120.31,142.94 120.31,143.62 120.44,143.75 120.9,143.75 120.99,143.66 124.87,143.66 125,143.54 125,143.14 124.87,143.01 123.79,143.01 123.66,142.88 v2(123.66,142.58)
  BOTTOM w0.102: UV1.E18 123.95,142.87 v2(123.66,142.58) ; UV6.H7 111.25,131.65 v2(111.62,132.02)
MDA32: length 31.4
  TOP w0.102: v2(110.79,153.13) 111.18,152.74 UV7.H7
  IN1 w0.102: 112.91,152.22 113.08,152.38 113.08,152.64 112.97,152.74 111.18,152.74 v2(110.79,153.13)
  IN1 w0.157: v2(116.56,148.1) 116.56,148.84 115.7,149.71 115.7,151.3 115,152 113.77,152 113.1,151.33 112.92,151.33 112.56,151.69 112.56,151.87 112.91,152.22
  BOTTOM w0.102: 120.81,142.76 121.9,142.76 122.35,143.21 122.55,143.21 122.89,142.87 UV1.C18
  BOTTOM w0.127: 120.81,142.76 117.75,142.76 117.62,142.88 117.62,143.04 117.5,143.16 117.23,143.16 117.1,143.04 117.1,142.9 116.98,142.77 116.61,142.77 116.48,142.9 116.48,143.1 116.35,143.23 115.41,143.23 115.28,143.1 115.28,142.49 115.14,142.35 114.31,142.35 114.18,142.48 114.18,144.05 114.31,144.18 114.94,144.18 115.32,144.56 117.16,144.56 117.43,144.83 117.43,147.23 v1(116.99,147.67) v2(116.56,148.1)
MDA33: length 31.1
  TOP w0.102: UV7.H8 112.02,152.72 v2(112.39,152.35)
  IN1 w0.157: v2(115.9,147.95) 115.89,147.96 115.89,148.86 115.23,149.51 115.23,151.11 114.81,151.54 113.98,151.54 113.45,151.01 112.74,151.01 112.46,151.29 112.05,151.29 111.94,151.41 111.94,152.08 112.2,152.35 v2(112.39,152.35)
  BOTTOM w0.127: v2(115.9,147.95) 116.59,147.25 116.89,147.25 117.1,147.04 117.1,145.22 116.99,145.11 113.24,145.11 112.99,144.85 112.99,143.23 112.82,143.07 v1(112.82,142.16) 112.96,142.02 115.5,142.02 115.63,142.15 115.63,142.75 115.75,142.87 116.01,142.87 116.14,142.75 116.14,142.14 116.26,142.01 116.54,142.01 116.67,142.14 116.67,142.33 116.77,142.43 122.01,142.43 122.45,142.87 UV1.A18
MDA34: length 32.2
  TOP w0.102: v2(111.59,153.95) 111.59,154.24 111.67,154.32 UV7.F8
  IN1 w0.102: 113.81,153.54 111.89,153.54 111.59,153.85 v2(111.59,153.95)
  IN1 w0.157: v2(121.62,144.07) 121.48,144.21 120.66,144.21 119.6,145.27 118.83,145.27 117.02,147.07 117.02,149.04 116.16,149.9 116.16,152.24 116.03,152.37 115.27,152.37 115.14,152.5 115.14,152.84 115.27,152.96 115.67,152.96 115.79,153.09 115.79,153.41 115.67,153.54 113.81,153.54
  BOTTOM w0.102: 122.24,143.43 122.65,143.43 122.84,143.24 124.67,143.24 124.84,143.07 UV1.F18
  BOTTOM w0.127: 122.24,143.43 121.95,143.14 v1(119.22,143.14) 118.73,143.14 118.6,143.27 118.6,144.12 118.47,144.24 118.16,144.24 118.03,144.37 118.03,144.76 118.16,144.89 119.17,144.89 119.3,144.76 119.3,144.03 119.43,143.9 121.49,143.9 121.62,144.03 v2(121.62,144.07)
MDA35: length 31.6
  TOP w0.102: v2(108.4,153.19) 107.98,152.77 UV7.H3
  IN1 w0.102: v2(108.4,153.19) 108,153.59 108,155.69 109.27,156.97 112.22,156.97 112.54,157.29 113.58,157.29 ; 122.62,147.46 122.62,145.21 v2(123.66,144.17)
  IN1 w0.157: 113.58,157.29 114.2,157.91 116.8,157.91 118.74,155.97 118.74,155.75 118.3,155.3 118.3,155.08 120.14,153.23 120.37,153.23 120.66,153.53 120.84,153.53 121.11,153.27 121.11,153.09 120.81,152.79 120.81,152.57 121.35,152.03 121.35,151.53 122.62,150.26 122.62,147.46
  BOTTOM w0.102: v2(123.66,144.17) 123.66,144.17 123.66,143.68 UV1.D17
MDA36: length 30.9
  TOP w0.102: v2(111.59,154.75) 111.18,154.34 UV7.F7
  IN1 w0.102: 113.81,154.67 113.64,154.67 113.29,154.33 112.01,154.33 v2(111.59,154.75)
  IN1 w0.157: 113.81,154.67 114.07,154.67 114.3,154.44 114.83,154.44 115.18,154.79 115.5,154.79 115.58,154.71 115.58,154.26 115.9,153.94 116.15,153.94 116.27,154.05 116.44,154.05 116.67,153.83 116.67,153.65 116.53,153.51 116.53,153.33 116.74,153.12 116.92,153.12 117.04,153.24 117.27,153.24 117.68,152.83 117.68,152.65 117.52,152.49 116.79,152.49 116.63,152.33 116.63,152.02 116.79,151.86 117.52,151.86 117.68,151.7 117.68,151.39 117.52,151.23 116.79,151.23 116.63,151.07 116.63,150.76 116.79,150.6 117.52,150.6 117.68,150.44 117.68,150.14 117.55,150.01 117.32,150.01 117.19,149.88 117.19,149.54 117.32,149.41 117.55,149.41 117.68,149.29 117.68,147.76 117.48,147.56 117.48,147.26 118.05,146.7 118.31,146.7 118.61,147 118.61,148.53 118.73,148.66 119.17,148.66 119.29,148.53 119.29,146.56 118.8,146.07 118.8,145.94 119.02,145.73 119.41,145.73 119.59,145.91 119.76,145.91 120.58,145.08 121.77,145.08 121.92,144.94 122.23,144.94 122.36,144.81 122.36,144.2 122.23,144.07 v2(122.18,144.07)
  BOTTOM w0.102: v2(122.18,144.07) 122.18,144.2 UV1.A16
MDA37: length 32.2
  TOP w0.102: UV7.G2 107.18,153.7 107.43,153.95 v2(107.59,153.95)
  IN1 w0.102: 113.74,158.83 112.92,158.83 112.49,158.4 108.31,158.4 107.2,157.29 107.2,154.34 v2(107.59,153.95) ; v2(124.37,145.51) 123.67,146.21 123.67,147.22
  IN1 w0.14: 123.67,150.41 123.67,147.22
  IN1 w0.157: 123.67,150.41 123.67,151.4 122.55,152.52 122.55,153.47 117.19,158.83 113.74,158.83
  BOTTOM w0.102: v2(124.37,145.51) 124.85,145.03 UV1.F16
MDA38: length 31.5
  TOP w0.102: v2(107.59,155.55) 107.98,155.15 UV7.E3
  IN1 w0.102: 123.23,147.43 123.23,147.12 122.85,146.73 122.85,145.98 v2(123.26,145.57) ; 113.81,158.29 113.59,158.07 112.02,158.07 112,158.09 108.39,158.09 107.59,157.29 v2(107.59,155.55)
  IN1 w0.157: 113.81,158.29 113.89,158.37 117,158.37 119.49,155.88 119.49,155.65 119.03,155.19 119.03,155.01 119.29,154.74 119.47,154.74 119.94,155.21 120.16,155.21 120.36,155.01 120.36,154.78 119.92,154.34 119.92,154.16 120.19,153.9 120.37,153.9 120.81,154.34 121.03,154.34 122.05,153.31 122.05,152.47 123.23,151.29 123.23,147.43
  BOTTOM w0.102: UV1.D15 123.56,145.27 v2(123.26,145.57)
MDA39: length 31.4
  TOP w0.102: v2(106.79,154.75) 107.18,154.35 UV7.F2
  IN1 w0.102: v2(106.79,154.75) 106.38,155.16 106.38,157.31 108.38,159.31 113.81,159.31
  IN1 w0.14: 123.96,150.75 123.96,146.9 v2(124.35,146.5)
  IN1 w0.157: 123.96,150.75 123.96,151.68 123.1,152.54 123.1,153.58 117.36,159.31 113.81,159.31
  BOTTOM w0.102: v2(124.35,146.5) 124.35,146.37 UV1.E14
MDA40: length 29.7
  TOP w0.102: v2(125.72,146.62) 125.19,146.09 121.61,146.09 121.52,146.17 ; 113.56,157.26 113.19,157.26 113.08,157.15 112.04,157.15 111.98,157.09 UV7.C8
  TOP w0.127: 121.52,146.17 118.84,146.17 118.64,146.38 117.66,146.38 117,147.04 117,148.29 116.77,148.52 116.01,148.52 115.82,148.71 115.82,151.11 115.68,151.25 115.55,151.25 115.42,151.38 115.42,151.7 115.55,151.83 116.17,151.83 116.3,151.95 116.3,152.21 116.17,152.34 116.05,152.34 115.92,152.46 115.92,152.69 116.05,152.82 116.85,152.82 116.97,152.95 116.97,153.2 116.85,153.33 116.17,153.33 116.05,153.46 116.05,153.76 116.17,153.88 v1(116.38,153.88) 116.82,153.88 117,154.06 117,155.63 115.37,157.26 113.56,157.26
  BOTTOM w0.102: UV1.F14 125.33,146.27 125.67,146.62 v2(125.72,146.62)
MDA41: length 29.2
  TOP w0.102: 120.81,146.5 121.08,146.5 121.19,146.39 123.05,146.39 v2(123.23,146.58) ; UV7.B8 112.15,157.52 112.58,157.95 112.95,157.95 113.05,158.05 113.55,158.05 113.6,157.99 113.81,157.99
  TOP w0.127: 120.81,146.5 118.98,146.5 118.78,146.71 117.8,146.71 117.33,147.18 117.33,148.82 117.2,148.95 116.29,148.95 116.16,149.07 116.16,149.33 116.29,149.46 117.2,149.46 117.33,149.58 117.33,149.84 117.2,149.96 116.29,149.96 116.16,150.09 116.16,150.34 116.29,150.47 117.2,150.47 117.33,150.6 117.33,150.85 117.2,150.98 116.29,150.98 116.16,151.11 116.16,151.36 116.29,151.49 v1(116.66,151.49) 117.2,151.49 117.33,151.61 117.33,151.83 117.2,151.96 116.76,151.96 116.63,152.08 116.63,152.34 116.76,152.46 117.2,152.46 117.33,152.59 117.33,155.77 115.11,157.99 113.81,157.99
  BOTTOM w0.102: UV1.D13 123.53,146.87 v2(123.23,146.58)
MDA42: length 29.4
  TOP w0.102: 120.81,146.83 120.85,146.83 120.9,146.78 121.32,146.78 121.43,146.67 122.5,146.67 122.8,146.97 124.09,146.97 124.51,147.39 v2(124.51,147.53) ; UV7.D7 111.58,156.32 111.58,157.68 111.78,157.88 112.2,157.88 112.4,158.09 112.4,158.49 112.75,158.84 113.48,158.84 113.62,158.7 113.81,158.7
  TOP w0.127: 120.81,146.83 120.5,146.83 120.38,146.96 120.38,147.67 120.25,147.79 120,147.79 119.87,147.67 119.87,146.96 119.74,146.83 119.46,146.83 v1(119.34,146.96) 119.23,147.06 118.63,147.06 118.5,147.19 118.5,147.44 118.63,147.57 119.24,147.57 119.37,147.7 119.37,148.02 119.26,148.13 118.38,148.13 117.66,148.85 117.66,155.9 114.86,158.7 113.81,158.7
  BOTTOM w0.102: UV1.F12 124.82,147.87 124.51,147.57 v2(124.51,147.53)
MDA43: length 28.3
  TOP w0.102: 113.81,159.03 113.74,159.03 113.55,159.22 111.91,159.22 111.48,158.79 111.3,158.79 111.18,158.67 UV7.A7
  TOP w0.127: 113.81,159.03 115,159.03 117.99,156.04 117.99,149.4 v1(118.39,149) 118.92,148.47 119.39,148.47 119.6,148.26 120.24,148.26 120.43,148.08 121.44,148.08 121.57,147.95 121.57,147.72 121.44,147.6 121.17,147.6 121.04,147.47 121.04,147.17 v2(121.04,147.16)
  BOTTOM w0.102: UV1.A12 122.38,147.6 121.46,147.6 121.35,147.71 120.81,147.71
  BOTTOM w0.127: 120.81,147.71 120.62,147.71 120.33,147.42 118.62,147.42 118.5,147.29 118.5,146.85 118.62,146.72 120.92,146.72 121.04,146.85 v2(121.04,147.16)
MDA44: length 28.7
  TOP w0.102: 108.94,158.31 108.94,157.52 108.13,156.72 UV7.C3
  TOP w0.127: v2(119.64,150.01) 119.5,150.15 119.5,156.71 117.81,158.4 117.81,158.58 118.19,158.96 118.19,159.14 118.01,159.32 117.83,159.32 117.45,158.94 117.27,158.94 117.09,159.12 117.09,159.3 v1(117.29,159.51) 117.29,159.68 117.11,159.86 116.93,159.86 116.73,159.66 116.55,159.66 115.68,160.53 111.16,160.53 108.94,158.31
  BOTTOM w0.102: 120.81,148.97 121.96,148.97 122.17,148.75 122.7,148.75 122.72,148.78 123.35,148.78 UV1.D11
  BOTTOM w0.127: v2(119.64,150.01) 120.68,148.97 120.81,148.97
MDA45: length 29
  TOP w0.102: 108.81,159.59 108.52,159.29 108.06,159.29 107.18,158.42 UV7.A2
  TOP w0.127: 108.81,159.59 110.75,161.52 117.21,161.52 120.72,158.02 v1(120.72,155.62) 120.72,152.99 120.85,152.86 121.01,152.86 121.14,152.73 121.14,152.48 121.01,152.35 120.85,152.35 120.72,152.23 120.72,151.98 120.85,151.85 121.06,151.85 121.18,151.72 121.18,150.29 121.47,150.01 v2(121.47,149.99)
  BOTTOM w0.102: v2(121.47,149.99) 121.83,149.63 123.33,149.63 123.4,149.55 123.87,149.55 123.93,149.61 124.19,149.61 124.33,149.47 UV1.F10
MDA46: length 28.1
  TOP w0.102: 109.28,159.59 108.54,158.85 107.97,158.85 107.58,158.46 107.58,157.12 UV7.C2
  TOP w0.127: 109.28,159.59 110.89,161.19 117.08,161.19 120.35,157.92 v1(120.35,152.61) 120.35,151.57 120.48,151.44 120.76,151.44 120.89,151.32 120.89,151.06 120.76,150.94 120.48,150.94 120.35,150.81 120.35,150.58 120.48,150.45 120.75,150.45 120.87,150.33 v2(120.87,150.05)
  BOTTOM w0.102: v2(120.87,150.05) 120.87,150.05 121.49,149.42 122.3,149.42 UV1.A10
MDA47: length 28.5
  TOP w0.102: 109.75,159.59 108.48,158.32 UV7.A3
  TOP w0.127: 109.75,159.59 111.02,160.86 115.81,160.86 116.55,160.13 116.73,160.13 117.08,160.47 117.33,160.47 118.66,159.14 118.66,158.9 118.3,158.53 118.3,158.38 118.49,158.19 118.67,158.19 119.03,158.55 119.21,158.55 119.39,158.37 v1(119.39,158.2) 119.03,157.83 119.03,157.65 119.23,157.44 119.41,157.44 119.64,157.68 119.82,157.68 120,157.5 120,157.32 119.77,157.08 119.77,156.9 119.96,156.72 119.96,150.28 v2(120.23,150.01)
  BOTTOM w0.102: UV1.C10 122.96,148.98 122.64,148.98 122.61,148.96 122.26,148.96 121.99,149.22 121.11,149.22 120.81,149.52
  BOTTOM w0.127: v2(120.23,150.01) 120.24,150.01 120.73,149.52 120.81,149.52
MDA48: length 32.1
  IN2 w0.102: v2(126.04,147.84) 126.04,147.52 126,147.48 125.05,147.48 124.92,147.61 124.92,147.91 124.8,148.04 124.02,148.04 123.88,148.18 123.74,148.18 123.65,148.09 123.5,148.09 123.36,148.24 123.36,148.38 123.39,148.41 123.39,148.58 123.27,148.7 123.1,148.7 123.01,148.61 122.87,148.61 122.72,148.76 122.72,148.9 122.87,149.04 122.87,149.41 122.77,149.51 122.55,149.51 122.44,149.63 122.44,149.8 122.55,149.92 122.77,149.92 122.87,150.02 122.87,150.68 122.44,151.11 121.92,151.11 121.87,151.06 ; v2(112.39,154.75) 112.39,154.38 112.35,154.34 111.32,154.34 111.2,154.21 111.2,153.68 111.32,153.55 112.63,153.55 112.77,153.41 112.77,151.66 112.9,151.53 113.23,151.53
  IN2 w0.157: 113.23,151.53 113.3,151.61 113.3,152.55 113.43,152.68 113.85,152.68 113.98,152.55 113.98,151.7 114.1,151.57 114.41,151.57 114.54,151.7 114.54,151.85 114.66,151.98 115.01,151.98 115.13,151.85 115.13,150.92 115.42,150.63 117.58,150.63 117.86,150.91 118.36,150.91 118.49,150.78 118.49,149.79 118.61,149.67 119.08,149.67 119.21,149.79 119.21,150.81 119.35,150.95 119.77,150.95 119.93,150.79 119.93,150.62 120.08,150.47 120.4,150.47 120.56,150.62 120.56,150.79 120.71,150.95 121.03,150.95 121.19,150.79 121.19,150.53 121.31,150.4 121.69,150.4 121.82,150.53 121.82,151.01 121.87,151.06
  BOTTOM w0.102: v2(126.04,147.84) 126.04,147.4 125.91,147.27 UV1.G13 ; v2(112.39,154.75) 112.39,154.45 112.26,154.32 UV8.F2
MDA49: length 32.7
  IN2 w0.102: 113.81,153.68 113.81,154.37 113.69,154.49 113.47,154.49 113.32,154.34 112.9,154.34 112.77,154.47 112.77,155.8 112.64,155.93 112.14,155.93 112.01,155.8 112.01,155.28 111.88,155.15 111.32,155.15 111.2,155.28 111.2,155.8 111.07,155.93 110.37,155.93 110.24,155.8 v2(110.24,154.95) ; 120.81,151.41 122.43,151.41 123.07,150.77 123.07,149.3 124.13,148.24 126.6,148.24 126.73,148.12 126.73,147.92 v2(126.66,147.85)
  IN2 w0.157: 113.81,153.68 113.94,153.55 114.88,153.55 115.01,153.68 115.01,154 115.14,154.13 115.61,154.13 115.74,154 115.74,153.43 115.07,152.77 115.07,152.59 115.34,152.32 115.52,152.32 116.16,152.95 116.34,152.95 116.6,152.69 116.6,152.51 115.98,151.89 115.98,151.67 116.57,151.09 117.05,151.09 117.2,151.25 117.2,151.38 116.91,151.68 116.91,151.86 117.16,152.12 117.34,152.12 118.09,151.37 118.87,151.37 119.11,151.6 119.48,151.6 119.67,151.41 120.81,151.41
  BOTTOM w0.102: UV1.H13 126.75,147.27 126.88,147.4 126.88,147.72 126.75,147.85 v2(126.66,147.85) ; UV8.E3 110.41,155.12 v2(110.24,154.95)
MDA50: length 32.9
  IN2 w0.089: 113.81,150 113.8,150.01
  IN2 w0.102: 113.8,150.01 113.63,150.18 113.09,150.18 112.88,150.38 112.88,150.92 112.62,151.18 112.15,151.18 112.02,151.05 112.02,150.71 111.89,150.58 111.03,150.58 110.9,150.71 110.9,152.68 111.17,152.94 111.17,153.29 110.95,153.51 110.58,153.51 v2(110.15,153.94) ; 120.81,148.95 121.89,148.95 123.36,147.48 123.72,147.48 124.25,146.94 124.83,146.94 124.96,147.08 126.52,147.08 v2(126.95,146.64)
  IN2 w0.157: 113.81,150 113.89,149.92 114.82,149.92 115.04,149.7 116.97,149.7 117.94,148.73 120.23,148.73 120.45,148.95 120.81,148.95
  BOTTOM w0.102: v2(126.95,146.64) 126.95,147.14 127.08,147.27 UV1.J13 ; v2(110.15,153.94) 110.15,154.3 109.85,154.59 109.85,155.44 109.95,155.54 110.28,155.54 110.38,155.65 110.38,155.85 110.28,155.95 109.89,155.95 109.76,156.08 109.76,156.27 109.63,156.4 109.42,156.4 109.29,156.27 109.29,154.44 109.54,154.19 109.54,153.89 110.1,153.33 110.1,153.13 110.84,152.39 111.03,152.39 111.18,152.55 UV8.H3
MDA51: length 32.1
  IN2 w0.102: v2(126.04,149.06) 125.65,149.45 124.35,149.45 123.91,149.89 123.91,151.16 121.63,153.44 120.81,153.44 ; v2(108.87,155.41) 108.53,155.41 108.36,155.57 108.36,156.95 108.94,157.53 109.25,157.53 109.38,157.66 109.38,158 109.51,158.12 109.71,158.12 109.81,158.02 109.81,157.63 109.91,157.53 110.12,157.53 110.22,157.63 110.22,158.02 110.32,158.12 111.06,158.12 111.22,157.96 111.22,157.64 111.32,157.54 111.53,157.54 111.63,157.64 111.63,158.02 111.75,158.14 111.91,158.14 112.03,158.02 112.03,157.64 112.14,157.54 112.34,157.54 112.44,157.64 112.44,158.32 112.57,158.44 112.75,158.44 112.87,158.32 112.87,158.12 112.94,158.06 113.55,158.06 113.81,157.8
  IN2 w0.157: 120.81,153.44 120.53,153.44 115.91,158.06 115.6,158.06 115.44,158.22 115.44,158.53 115.32,158.65 114.99,158.65 114.86,158.53 114.86,157.9 114.71,157.75 113.86,157.75 113.81,157.8
  BOTTOM w0.102: UV1.H11 126.45,148.65 v2(126.04,149.06) ; v2(108.87,155.41) 109,155.28 109,154.72 108.8,154.52 108.18,154.52 UV8.F7
MDA52: length 31.8
  IN2 w0.102: v2(125.2,149.86) 125.2,150.15 124.82,150.53 124.68,150.53 124.47,150.32 124.33,150.32 124.19,150.47 124.19,150.61 124.39,150.82 124.39,150.96 121.45,153.9 120.81,153.9
  IN2 w0.157: 120.81,153.9 120.72,153.9 115.43,159.19 114.58,159.19 114.42,159.04 114.42,158.69 114.27,158.53 113.95,158.53 113.79,158.69 113.79,159.07 113.6,159.27 111.77,159.27 111.66,159.16 111.66,158.62 111.53,158.49 111.16,158.49 111.03,158.62 111.03,159.17 110.9,159.29 110.53,159.29 110.4,159.17 110.4,158.59 110.27,158.47 109.9,158.47 109.77,158.59 109.77,158.94 109.64,159.06 109.28,159.06 109.15,158.94 109.15,158.37 108.94,158.15 108.27,158.15 107.94,157.82 107.94,156.66 107.82,156.54 107.58,156.54 107.45,156.41 107.45,156.08 107.58,155.96 107.87,155.96 108,155.83 108,154.85 107.87,154.72 v2(107.58,154.72)
  BOTTOM w0.102: v2(125.2,149.86) 125.48,149.86 125.65,149.69 UV1.G10 ; v2(107.58,154.72) 107.18,154.33 UV8.F8
MDA53: length 31.4
  IN2 w0.102: v2(107.59,153.15) 106.41,154.33 106.41,157.66 108.33,159.59 ; 120.81,155.19 123.64,152.37 125.45,152.37 125.61,152.21 125.61,151.14 v2(126.04,150.7)
  IN2 w0.157: 108.33,159.59 108.87,160.12 115.89,160.12 120.81,155.19
  BOTTOM w0.102: UV8.H8 107.16,152.72 v2(107.59,153.15) ; v2(126.04,150.7) 125.67,151.07 UV1.G8
MDA54: length 32.4
  IN2 w0.102: 109.34,159.59 107.2,157.44 107.2,154.56 107.42,154.34 107.78,154.34 107.98,154.14 107.98,152.76 v2(107.55,152.33) ; 120.81,154.46 120.91,154.36 121.28,154.36 125.34,150.3 127.28,150.3 v2(127.65,150.67)
  IN2 w0.157: 109.34,159.59 109.41,159.66 115.62,159.66 120.81,154.46
  BOTTOM w0.102: v2(107.55,152.33) 107.55,152.33 107.95,152.72 UV8.H7 ; v2(127.65,150.67) UV1.K9
MDA55: length 32.5
  IN2 w0.102: 120.81,149.41 121.72,149.41 123.45,147.69 123.8,147.69 124.34,147.15 124.75,147.15 124.88,147.28 126.6,147.28 126.82,147.06 127.09,147.06 127.19,147.16 127.19,147.25 127.31,147.37 127.48,147.37 127.6,147.25 127.6,147.16 127.7,147.06 127.91,147.06 128.04,147.18 128.04,147.41 128.16,147.53 128.34,147.53 128.47,147.41 128.47,146.95 128.59,146.82 128.79,146.82 128.91,146.95 128.91,148.6 128.79,148.73 128.16,148.73 128.09,148.65 128.09,148.33 127.96,148.21 127.38,148.21 127.25,148.08 v2(127.25,147.85) ; 113.81,150.58 113.19,150.58 113.09,150.68 113.09,151.03 112.47,151.65 112.47,151.86 112.36,151.97 111.82,151.97 111.69,151.84 111.69,150.95 111.56,150.82 111.27,150.82 111.15,150.95 111.15,152.56 111.35,152.77 112.01,152.77 v2(112.39,153.15)
  IN2 w0.157: 113.81,150.58 114.81,150.58 115.23,150.16 117.16,150.16 118.13,149.2 120.04,149.2 120.26,149.41 120.81,149.41
  BOTTOM w0.102: UV1.K10 127.99,149.47 127.66,149.15 127.66,148.29 127.25,147.88 v2(127.25,147.85) ; v2(112.39,153.15) 112.02,153.52 UV8.G2
MDA56: length 28.6
  BOTTOM w0.102: UV1.G9 125.65,150.49 125.41,150.73 124.76,150.73 123.78,149.76 123.49,149.76 123.22,150.02 123.22,150.2 123.06,150.36 123.04,150.36 122.99,150.42 122.72,150.42 122.66,150.36 122.24,150.36 122.04,150.57 120.81,150.57 ; 113.34,156.3 112.12,156.3 111.98,156.44 UV8.C2
  BOTTOM w0.127: 120.81,150.57 119.51,150.57 119.15,150.2 119.15,149.44 119.27,149.31 119.87,149.31 120.18,149 120.18,147.86 120.09,147.76 117.49,147.76 116.73,148.52 116.28,148.52 116.17,148.63 116.17,153.79 116.06,153.91 v1(116.06,154.49) 116.53,154.97 116.53,155.28 115.54,156.27 114.23,156.27 114.1,156.14 114.1,155.75 113.98,155.62 113.72,155.62 113.59,155.75 113.59,156.17 113.47,156.3 113.34,156.3
MDA57: length 27.3
  BOTTOM w0.102: 120.81,151.23 121.06,151.23 121.32,150.97 122.35,150.97 UV1.A8 ; UV8.C3 111.48,156.72 111.58,156.82 111.58,158.73 112.08,159.24 113.24,159.24 113.8,158.68 113.81,158.68
  BOTTOM w0.127: 113.81,158.68 114.05,158.44 114.05,157.06 114.18,156.93 115.81,156.93 117.19,155.55 117.19,154.46 116.83,154.1 116.83,149.41 117.13,149.12 117.66,149.12 117.79,149.25 117.79,149.51 117.66,149.64 117.48,149.64 117.38,149.74 117.38,150.05 117.48,150.15 v1(117.69,150.15) 118.35,150.15 118.47,150.28 118.47,150.57 118.35,150.7 117.48,150.7 117.38,150.8 117.38,151.13 117.48,151.23 120.81,151.23
MDA58: length 27.8
  BOTTOM w0.102: UV8.A3 111.25,158.25 111.25,158.08 111.13,157.96 110.96,157.96 110.73,158.19 110.73,158.44 111.13,158.84 111.29,158.84 111.92,159.47 113.71,159.47 113.81,159.37 ; UV1.C8 122.88,150.87 122.54,151.22 121.39,151.22 121.05,151.56 120.81,151.56
  BOTTOM w0.127: 113.81,159.37 114.14,159.37 114.4,159.12 114.4,157.39 114.52,157.26 115.95,157.26 117.52,155.69 117.52,154.32 117.21,154.01 117.21,153.71 117.31,153.61 117.39,153.61 117.52,153.48 117.52,153.23 117.39,153.1 117.31,153.1 117.21,153 117.21,152.66 117.31,152.56 120.16,152.56 120.26,152.46 120.26,152.15 120.16,152.05 117.27,152.05 117.16,151.95 117.16,151.66 v1(117.27,151.56) 120.81,151.56
MDA59: length 28
  BOTTOM w0.102: UV8.A2 112.41,157.9 112.94,157.9 113.1,158.06 113.6,158.06 113.72,157.93 113.72,156.77 113.81,156.68 ; UV1.E8 123.75,150.57 123.13,150.57 123.07,150.62 122.63,150.62 122.58,150.57 122.33,150.57 122.12,150.77 121.18,150.77 121.05,150.9 120.81,150.9
  BOTTOM w0.127: 120.81,150.9 118.99,150.9 118.82,150.72 118.82,149.5 118.59,149.27 118.23,149.27 118.1,149.15 118.1,148.78 118.23,148.65 v1(118.88,148.65) 119.21,148.98 119.7,148.98 119.83,148.85 119.83,148.22 119.7,148.09 117.63,148.09 117.5,148.23 117.5,148.55 117.37,148.67 117.05,148.67 116.5,149.22 116.5,154.24 116.86,154.6 116.86,155.41 115.68,156.6 113.89,156.6 113.81,156.68
MDA60: length 27.1
  BOTTOM w0.102: UV1.A6 122.31,152.61 122.08,152.61 121.14,153.56 121.14,154.82 120.81,155.15 ; UV8.D7 107.71,155.92 107.56,156.07 107.56,157.64 107.8,157.88 108.14,157.88 108.34,158.09 108.73,158.09 108.92,157.9 108.92,157.45 109.05,157.32 109.41,157.32 109.53,157.45 109.53,158.97 110.15,159.59
  BOTTOM w0.127: 120.81,155.15 120.28,155.68 120.1,155.68 119.94,155.52 119.76,155.52 119.58,155.7 119.58,155.88 119.74,156.04 119.74,156.22 119.56,156.4 119.38,156.4 119.22,156.24 119.04,156.24 118.86,156.42 118.86,156.59 119.03,156.76 119.03,156.94 118.85,157.12 118.67,157.12 v1(118.5,156.95) 118.32,156.95 118.14,157.13 118.14,157.31 118.31,157.48 118.31,157.66 118.13,157.84 117.95,157.84 117.78,157.67 117.66,157.67 116.62,158.71 116.02,158.71 115.83,158.9 115.83,160.13 115.15,160.81 111.37,160.81 110.15,159.59
MDA61: length 27.2
  BOTTOM w0.076: UV1.C6 122.91,152.81 122.18,152.81 122.17,152.83
  BOTTOM w0.102: 122.17,152.83 121.34,153.66 121.34,155.09 120.81,155.62
  BOTTOM w0.127: UV8.A7 107.98,158.47 108.05,158.53 108.3,158.53 108.51,158.32 108.66,158.32 108.88,158.54 108.88,158.68 108.2,159.36 108.2,159.54 108.25,159.59 108.38,159.72 108.56,159.72 109.09,159.2 109.27,159.2 109.45,159.38 109.45,159.55 108.92,160.08 108.92,160.26 109.1,160.44 109.28,160.44 109.81,159.91 109.99,159.91 110.17,160.09 110.17,160.27 109.87,160.57 109.87,160.75 110.12,161 110.3,161 v1(110.44,160.87) 110.63,160.68 110.78,160.68 111.23,161.14 115.29,161.14 116.78,159.65 116.78,159.47 116.62,159.32 116.62,159.14 116.8,158.96 116.98,158.96 117.14,159.11 117.31,159.11 117.49,158.93 117.49,158.76 117.34,158.6 117.34,158.42 117.52,158.24 117.7,158.24 117.85,158.4 118.03,158.4 120.81,155.62
MDA62: length 27.5
  BOTTOM w0.076: UV1.E6 123.76,152.47 123.24,152.99 122.33,152.99 arc(122.31,153) 122.3,153.01 122.28,153.02
  BOTTOM w0.102: 121.13,155.77 121.54,155.35 121.54,153.76 122.28,153.02
  BOTTOM w0.127: 121.13,155.77 115.43,161.47 109.66,161.47 109.22,161.02 109.04,161.02 108.81,161.25 108.63,161.25 108.45,161.07 108.45,160.89 108.68,160.66 108.68,160.48 108.49,160.29 108.31,160.29 108.02,160.58 107.84,160.58 v1(107.66,160.4) 107.66,160.22 107.95,159.93 107.95,159.75 107.74,159.55 107.56,159.55 107.19,159.92 107.01,159.92 106.78,159.69 106.78,159.51 107.58,158.72 107.58,158.1 107.18,157.71 UV8.B8
MDA63: length 26.7
  BOTTOM w0.102: UV1.A5 122.34,153.37 121.75,153.96 121.75,155.62 121.59,155.77 ; UV8.C8 106.74,157.16 105.89,157.16 105.51,157.53 105.51,157.95
  BOTTOM w0.127: 121.59,155.77 115.57,161.8 v1(108.4,161.8) 106.19,159.59 106.19,159.41 106.38,159.22 106.38,159.05 106.2,158.87 106.02,158.87 105.83,159.05 105.64,159.05 105.51,158.92 105.51,157.95
MDB0: length 30.4
  TOP w0.127: UV9.D7 124.57,170.06 124.26,170.37 121.29,170.37 121.17,170.24 121.17,170 121.29,169.87 121.58,169.87 121.7,169.76 121.7,169.48 121.57,169.35 120.5,169.35 118.35,167.19 118.35,164.82 118.22,164.69 117.88,164.69 117.75,164.56 117.75,164.36 v1(117.94,164.16) 118.25,163.86 118.25,163.68 117.77,163.2 117.77,163.02 117.95,162.84 118.13,162.84 118.54,163.25 118.72,163.25 118.89,163.08 118.89,162.9 118.36,162.37 118.36,162.13 120.53,159.96 120.71,159.96 121.2,160.45 121.38,160.45 121.56,160.27 121.56,160.09 121.07,159.6 121.07,159.42 122.72,157.78 122.72,155.54 122.58,155.41 122.41,155.41 v2(122.32,155.5)
  BOTTOM w0.102: v2(122.32,155.5) 121.95,155.13 121.95,154.09 122.27,153.77 122.86,153.77 UV1.C5
MDB1: length 30.2
  TOP w0.102: UV9.C8 123.36,171.17 123.36,171.97 122.94,172.39 120.92,172.39
  TOP w0.127: 120.92,172.39 120.18,172.39 120.09,172.31 120.09,172.03 120.22,171.9 120.73,171.9 120.86,171.77 120.86,171.52 120.73,171.39 120.22,171.39 120.09,171.27 120.09,169.88 119.73,169.52 117.79,169.52 117.66,169.64 117.66,169.85 117.53,169.98 v1(117.37,169.98) 117.22,169.98 117.09,169.85 117.09,162.47 121.81,157.74 121.81,156.57 v2(122.3,156.08)
  BOTTOM w0.102: 122.61,155.77 122.73,155.65 122.73,155.36 122.79,155.29 122.79,154.73 UV1.C3
  BOTTOM w0.127: 122.61,155.77 v2(122.3,156.08)
MDB2: length 30.4
  TOP w0.102: UV9.B8 122.59,171.15 121.24,171.15
  TOP w0.127: 121.24,171.15 120.99,171.15 120.5,170.66 120.5,169.82 119.87,169.19 117.53,169.19 117.42,169.07 117.42,168.82 117.55,168.69 118.82,168.69 118.94,168.57 118.94,168.31 118.82,168.19 117.55,168.19 117.42,168.06 117.42,167.77 117.55,167.64 117.88,167.64 118,167.52 118,167.26 117.88,167.14 117.55,167.14 117.42,167.01 117.42,166.76 117.55,166.63 v1(117.72,166.63) 117.88,166.63 118,166.5 118,166.25 117.88,166.12 117.55,166.12 117.42,165.99 117.42,165.74 117.55,165.61 117.88,165.61 118,165.49 118,165.23 117.88,165.1 117.55,165.1 117.42,164.98 117.42,162.61 122.3,157.73 v2(122.3,156.71)
  BOTTOM w0.102: 123.79,155.77 123.79,154.63 UV1.E3
  BOTTOM w0.127: v2(122.3,156.71) 122.82,156.19 123.43,156.19 123.79,155.83 123.79,155.77
MDB3: length 30.1
  TOP w0.127: UV9.A7 122.17,169.14 122.04,169.02 120.69,169.02 118.69,167.02 118.69,163.88 119.48,163.09 119.48,162.91 118.89,162.31 118.89,162.13 119.06,161.96 119.24,161.96 v1(119.52,162.23) 119.84,162.55 120.02,162.55 120.2,162.37 120.2,162.19 119.58,161.58 119.58,161.4 119.76,161.22 119.94,161.22 120.56,161.83 120.74,161.83 120.92,161.65 120.92,161.47 120.32,160.88 120.32,160.7 120.5,160.52 120.68,160.52 121.28,161.11 121.46,161.11 121.7,160.87 123.01,160.87 123.14,160.74 123.14,160.47 123.01,160.35 122.03,160.35 121.9,160.22 121.9,159.96 122.03,159.84 122.96,159.84 123.08,159.71 123.08,159.46 122.96,159.33 122.14,159.33 122.01,159.2 122.01,158.95 122.14,158.82 122.97,158.82 123.1,158.69 123.1,156.68 v2(123.14,156.64)
  BOTTOM w0.102: UV1.E1 124.15,155.77
  BOTTOM w0.127: v2(123.14,156.64) 123.48,156.64 124.15,155.96 124.15,155.77
MDB4: length 30.4
  TOP w0.127: UV9.C3 123.77,166.85 122.93,167.69 121.51,167.69 120.17,166.34 120.17,164.54 121.45,163.26 124.33,163.26 124.48,163.1 124.48,162.5 125.37,161.61 125.37,159.31 125.5,159.18 126.45,159.18 126.58,159.05 126.58,158.8 126.45,158.67 125.5,158.67 125.37,158.54 125.37,158.24 125.5,158.11 127.4,158.11 127.53,157.98 127.53,157.73 127.4,157.6 v1(126.41,157.6) 125.5,157.6 125.37,157.48 125.37,157.22 125.5,157.1 127.03,157.1 127.16,156.97 127.16,156.71 127.03,156.59 125.47,156.59 125.34,156.46 125.34,155.31 125.27,155.23 124.72,155.23 124.59,155.36 v2(124.59,155.38)
  BOTTOM w0.102: 124.98,155.07 124.9,155.07 v2(124.59,155.38)
  BOTTOM w0.127: UV1.F1 124.98,155.07
MDB5: length 30.7
  TOP w0.127: UV9.A3 121.06,166.77 120.5,166.21 120.5,164.68 121.59,163.59 124.61,163.59 124.81,163.38 124.81,162.64 125.74,161.71 126.7,161.71 126.82,161.59 126.82,161.31 126.69,161.19 125.83,161.19 125.7,161.06 125.7,160.79 125.83,160.66 127.77,160.66 127.9,160.54 127.9,160.28 127.77,160.15 v1(127.38,160.15) 125.86,160.15 125.74,160.02 125.74,159.77 125.86,159.64 127.77,159.64 127.9,159.52 127.9,159.26 127.77,159.13 127.03,159.13 126.91,159.01 126.91,158.75 127.03,158.63 127.77,158.63 127.9,158.5 127.9,157.26 127.5,156.87 127.5,154.78 127.38,154.66 124.66,154.66 v2(124.63,154.68)
  BOTTOM w0.102: UV1.F3 125.04,154.27 v2(124.63,154.68)
MDB6: length 31
  TOP w0.102: 120.92,166.16 121.15,166.39 123.34,166.39 UV9.C2
  TOP w0.127: v2(124.66,153.88) 124.98,154.2 v1(125.45,154.2) 127.69,154.2 127.82,154.33 127.82,156.7 128.23,157.11 128.23,160.31 128.35,160.44 128.7,160.44 128.82,160.56 128.82,160.87 128.7,161 127.3,161 127.17,161.12 127.17,161.39 127.3,161.52 129.52,161.52 129.65,161.64 129.65,161.92 129.52,162.05 125.86,162.05 125.14,162.77 125.14,163.64 124.86,163.92 121.72,163.92 120.83,164.81 120.83,166.07 120.92,166.16
  BOTTOM w0.102: v2(124.66,153.88) 125.05,153.49 UV1.F5
MDB7: length 31.2
  TOP w0.102: 121.15,165.31 121.15,165.97 121.37,166.19 121.95,166.19 UV9.A2
  TOP w0.127: 121.15,165.31 122.19,164.27 125.22,164.27 125.34,164.14 125.34,163.99 125.47,163.87 125.72,163.87 125.85,163.99 125.85,164.14 125.98,164.27 126.23,164.27 126.36,164.14 126.36,163.99 126.49,163.87 126.74,163.87 126.87,163.99 126.87,164.14 126.99,164.27 127.25,164.27 127.38,164.14 127.38,163.99 127.5,163.87 127.76,163.87 127.88,163.99 127.88,164.14 128.01,164.27 128.26,164.27 128.39,164.14 128.39,163.99 128.52,163.87 128.77,163.87 128.9,163.99 128.9,164.14 129.03,164.27 130.93,164.27 131.06,164.14 131.06,163.51 130.93,163.38 130.01,163.38 129.89,163.25 129.89,163 130.01,162.87 130.99,162.87 131.12,162.74 131.12,162.4 130.99,162.28 130.11,162.28 129.98,162.15 129.98,161.21 128.56,159.79 128.56,156.96 128.14,156.54 128.14,154 128.01,153.87 v1(127.51,153.87) 126.65,153.87 v2(126.17,153.39)
  BOTTOM w0.102: v2(126.17,153.39) 125.85,153.7 UV1.G4
MDB8: length 31.3
  BOTTOM w0.076: UV1.H5 126.65,153.56 125.93,154.28 125.76,154.28 125.59,154.45 arc(125.53,154.54) 125.51,154.64 125.51,154.75 arc(125.52,154.79) 125.54,154.83 arc(125.57,154.86) 125.57,154.91 125.57,155.28 125.57,155.32 125.37,155.52 125.37,155.64 125.37,155.64 arc(125.36,155.65) 125.36,155.66 125.36,155.68 arc(125.35,155.7) 125.34,155.71
  BOTTOM w0.102: UV10.A3 120.92,169.97 ; 124.44,157.04 125.34,156.15 125.34,155.72 125.34,155.71
  BOTTOM w0.127: 120.92,169.97 120.64,169.97 119.88,169.21 117.95,169.21 117.24,168.51 117.24,163.44 117.37,163.32 118.73,163.32 118.85,163.19 118.85,162.94 118.73,162.81 117.37,162.81 117.24,162.68 117.24,162.43 117.37,162.3 v1(118.26,162.3) 118.73,162.3 118.85,162.17 118.85,161.87 118.73,161.75 118.14,161.75 118.02,161.62 118.02,161.37 118.14,161.24 118.73,161.24 118.85,161.11 118.85,159.89 121.26,157.48 124,157.48 124.44,157.04
MDB9: length 31.6
  BOTTOM w0.076: 125.18,155.44 125.18,155.41 125.2,155.41 125.3,155.31 arc(125.37,155.2) 125.4,155.07 125.4,155.02 arc(125.38,154.94) 125.33,154.87 125.33,154.86 125.33,154.86 arc(125.32,154.85) 125.31,154.84 125.29,154.82 arc(125.26,154.77) 125.25,154.71 125.25,154.64 arc(125.26,154.58) 125.29,154.53 arc(125.37,154.42) 125.4,154.28 125.4,153.55 126.27,152.67 UV1.H6
  BOTTOM w0.102: 125.18,155.44 125.13,155.49 arc(125.1,155.54) 125.09,155.59 125.09,155.93 124.44,156.57 ; UV10.A2 122.17,170.73 121.75,170.32 120.92,170.32
  BOTTOM w0.127: 124.44,156.57 123.86,157.15 121.12,157.15 118.52,159.75 118.52,160.78 118.4,160.91 v1(117.52,160.91) 117.22,160.91 117.09,161.03 117.09,161.33 117.22,161.45 117.56,161.45 117.69,161.58 117.69,161.84 117.56,161.97 117.04,161.97 116.91,162.1 116.91,168.64 117.81,169.54 119.74,169.54 120.14,169.94 120.14,171.23 120.27,171.36 120.61,171.36 120.73,171.23 120.73,170.5 120.92,170.32
MDB10: length 31.4
  BOTTOM w0.102: UV10.C3 123.4,169.97 123.36,169.93 123.36,169.17 123.24,169.05 120.92,169.05 ; UV1.J4 127.45,154.24 127.01,154.68 126.71,154.68 arc(126.57,154.71) 126.46,154.79 arc(126.38,154.91) 126.35,155.05 126.35,156.07 126.19,156.23
  BOTTOM w0.127: 126.19,156.23 124.27,158.14 121.55,158.14 119.54,160.15 119.54,164.01 119.41,164.14 119.12,164.14 118.99,164.27 118.99,164.52 119.12,164.65 119.41,164.65 119.54,164.78 119.54,165.04 119.41,165.17 118.14,165.17 118.01,165.29 118.01,165.55 118.14,165.67 119.41,165.67 119.54,165.8 119.54,166.05 119.41,166.18 v1(118.79,166.18) 118.14,166.18 118.01,166.31 118.01,168.34 118.22,168.55 120.15,168.55 120.65,169.05 120.92,169.05
MDB11: length 32
  BOTTOM w0.102: UV10.C2 123.9,170.64 123.9,170.48 123.77,170.35 122.65,170.35 122.58,170.28 122.58,169.83 122.24,169.5 120.92,169.5 ; 124.64,157.31 126.14,155.81 126.14,155.44 126.15,155.44 126.15,155.04 arc(126.16,154.91) 126.19,154.79 126.35,154.42 126.35,154.17 126.35,154.15 126.41,154.08 126.41,154.07 126.59,153.9 126.68,153.9 127.03,153.54 127.03,153.22 127.26,152.99 127.73,152.99 UV1.K6
  BOTTOM w0.127: 124.64,157.31 124.14,157.81 121.39,157.81 119.21,160 119.21,163.56 v1(119.08,163.69) 117.81,163.69 117.68,163.82 117.68,164.12 117.81,164.25 118.52,164.25 118.65,164.38 118.65,164.63 118.52,164.76 117.81,164.76 117.68,164.88 117.68,168.48 118.08,168.88 120.02,168.88 120.64,169.5 120.92,169.5
MDB12: length 31.7
  BOTTOM w0.102: UV1.K5 128.66,153.88 128.66,155.14 128.16,155.64 128.16,156.17 128.29,156.29 128.58,156.29 128.71,156.42 128.71,156.6 128.58,156.73 128.07,156.73 127.95,156.85 ; UV10.A7 122.05,166.89 121.42,166.89 121,166.47 121,163.92
  BOTTOM w0.127: 121,163.92 121,163.76 121.31,163.46 124.14,163.46 124.26,163.33 124.26,163.05 124.14,162.93 121.2,162.93 121.08,162.8 121.08,162.55 121.2,162.42 124.14,162.42 124.24,162.32 v1(124.24,161.36) 124.24,160.21 125.52,158.94 127.82,158.94 127.95,158.81 127.95,158.49 127.82,158.37 126.64,158.37 126.52,158.24 126.52,157.93 126.64,157.81 128.62,157.81 128.75,157.68 128.75,157.36 128.62,157.24 128.07,157.24 127.95,157.11 127.95,156.85
MDB13: length 31.9
  BOTTOM w0.102: 129.08,156.63 129.08,155.62 129.34,155.36 129.34,154.85 129.36,154.83 129.36,154.51 129.05,154.2 UV1.L4 ; 121.88,164.35 121.23,164.99 121.23,166.01 121.59,166.37 122.56,166.37 UV10.B8
  BOTTOM w0.127: 129.08,156.63 129.08,158.07 128.96,158.2 128.4,158.2 128.28,158.33 128.28,158.63 128.4,158.76 129.55,158.76 129.67,158.89 129.67,159.14 129.55,159.27 125.65,159.27 125.53,159.39 125.53,159.66 125.65,159.79 v1(126.54,159.79) 129.56,159.79 129.69,159.92 129.69,160.22 129.56,160.35 124.76,160.35 124.59,160.51 124.59,163.69 124.49,163.79 122.43,163.79 121.88,164.35
MDB14: length 32.4
  BOTTOM w0.102: UV10.C8 123.59,165.97 123.17,165.55 121.99,165.55 121.65,165.22 121.65,164.88 122.21,164.32 123.18,164.32 ; 129.41,157.31 129.41,155.58 129.54,155.45 129.54,154.95 129.57,154.92 129.57,154.43 129.53,154.39 129.53,154.07 129.66,153.95 129.66,153.78 129.5,153.62 129.26,153.62 129.03,153.39 129.03,152.96 129.21,152.77 129.21,152.72 129.36,152.58 129.56,152.58 UV1.M6
  BOTTOM w0.127: 123.18,164.32 123.39,164.12 124.67,164.12 124.92,163.87 124.92,162.05 125.24,161.73 129.25,161.73 129.37,161.6 129.37,161.31 129.25,161.18 v1(128.3,161.18) 125.05,161.18 124.92,161.06 124.92,160.8 125.05,160.68 129.89,160.68 130.02,160.55 130.02,158.75 129.41,158.14 129.41,157.31
MDB15: length 31.7
  BOTTOM w0.102: 129.74,157.31 129.74,155.18 UV1.M1
  BOTTOM w0.127: 129.74,157.31 129.74,158.01 130.42,158.69 v1(130.42,159.28) 130.42,161.02 129.29,162.16 128.79,162.16 128.67,162.28 128.67,162.67 128.54,162.79 128.28,162.79 128.16,162.67 128.16,162.28 128.03,162.16 127.78,162.16 127.65,162.28 127.65,162.72 127.52,162.85 127.27,162.85 127.14,162.72 127.14,162.28 127.01,162.16 126.76,162.16 126.63,162.28 126.63,163.07 126.51,163.2 126.25,163.2 126.13,163.07 126.13,162.28 126,162.16 125.4,162.16 125.25,162.3 125.25,163.71 125.38,163.84 127.75,163.84 127.88,163.97 127.88,164.22 127.75,164.35 123.67,164.35 123.38,164.64 123.38,165.33 123.62,165.57 124.02,165.57 124.16,165.71 124.16,168.33 124.23,168.4 124.42,168.4 124.65,168.16 124.86,168.16 124.98,168.04 124.98,167.85 124.86,167.72 124.67,167.72 124.54,167.6 124.54,166.79 UV10.D7
MDB16: length 34.9
  TOP w0.102: UV9.F8 126.17,170.75 v2(126.54,170.37)
  IN2 w0.102: v2(126.54,170.37) 126.54,170.08 126.44,169.97 125.42,169.97 125.15,170.24 122.6,170.24 121.51,169.15 ; v2(130.17,153.9) 129.54,154.53 125.98,154.53 125,155.51 125,155.66 124.81,155.85
  IN2 w0.157: 121.51,169.15 121.23,168.87 121.23,167.24 121.08,167.08 120.22,167.08 120.07,166.92 120.07,166.61 120.22,166.45 121.08,166.45 121.23,166.29 121.23,165.98 121.08,165.82 120.22,165.82 120.07,165.66 120.07,165.35 120.22,165.19 121.08,165.19 121.23,165.03 121.23,164.72 121.08,164.56 120.22,164.56 120.07,164.4 120.07,158.35 121.06,157.36 123.31,157.36 124.81,155.85
  BOTTOM w0.102: UV1.M3 129.85,154.22 v2(130.17,153.9)
MDB17: length 35.2
  TOP w0.102: v2(128.17,170.36) 127.77,170.76 UV9.H8
  IN2 w0.102: 120.92,169.86 121.4,170.34 121.84,170.34 123.05,171.56 126.7,171.56 126.93,171.33 126.93,171.05 127.2,170.77 127.76,170.77 v2(128.17,170.36) ; 121.62,155.38 121.62,154.81 122.98,153.45 125.52,153.45 125.97,153.01 127.9,153.01 128.07,153.18 v2(129.43,153.18)
  IN2 w0.157: 120.92,169.86 119.14,168.08 119.14,157.92 121.62,155.44 121.62,155.38
  BOTTOM w0.102: UV1.M5 129.72,153.47 v2(129.43,153.18)
MDB18: length 35.2
  TOP w0.102: v2(127.34,169.57) 127.74,169.97 UV9.H7
  IN2 w0.102: v2(127.34,169.57) 126.96,169.96 126.96,170.58 126.78,170.76 122.75,170.76 121.7,169.7 121.42,169.7 120.92,169.2 ; v2(130.25,153.15) 129.12,154.28 122.97,154.28 122.82,154.43 122.29,154.43 121.85,154.86 121.85,155.77
  IN2 w0.157: 120.92,169.2 119.6,167.89 119.6,158.11 121,156.72 121.29,156.72 121.47,156.89 121.66,156.89 121.85,156.7 121.85,156.46 121.62,156.23 121.62,156.09 121.85,155.86 121.85,155.77
  BOTTOM w0.102: UV1.N4 130.65,153.73 130.25,153.32 v2(130.25,153.15)
MDB19: length 35.5
  TOP w0.127: UV9.E3 125.31,166.77 124.97,166.43 v2(124.97,166.37)
  IN2 w0.102: v2(130.81,153.27) 131.44,153.27 131.55,153.39 131.55,154.81 131.11,155.26 131.11,156.85 130.96,157.01 ; v2(124.97,166.37) 124.49,166.37 124.37,166.5 124.37,167.12 124.24,167.24 123.86,167.24 123.74,167.12 123.74,164.51 123.91,164.34 125.84,164.34 126.13,164.05
  IN2 w0.157: 126.13,164.05 126.26,163.92 126.26,162.23 126.85,161.63 126.85,161.07 127.01,160.91 128.73,160.91 128.85,160.78 128.85,160.41 128.73,160.28 126.94,160.28 126.82,160.15 126.82,159.78 126.94,159.65 128.7,159.65 128.82,159.52 128.82,159.15 128.7,159.02 127.01,159.02 126.85,158.86 126.85,158.55 127.01,158.39 128.71,158.39 128.84,158.26 128.84,157.89 128.71,157.76 127.01,157.76 126.85,157.6 126.85,157.26 126.98,157.13 130.83,157.13 130.96,157.01
  BOTTOM w0.14: UV1.P6 131.25,152.83 v2(130.81,153.27)
MDB20: length 35.5
  TOP w0.127: v2(125.76,168.98) 126.14,169.36 126.14,169.94 UV9.F7
  IN2 w0.102: 125.28,156.04 125.28,155.56 126.05,154.78 130.42,154.78 131.14,154.06 v2(131.14,153.87) ; 121.81,164.61 121.81,165.26 122.09,165.54 122.09,169.35 122.77,170.03 125.07,170.03 125.32,169.78 125.32,169.41 v2(125.76,168.98)
  IN2 w0.157: 121.81,164.61 121.81,164.14 121.65,163.98 120.7,163.98 120.54,163.82 120.54,163.51 120.7,163.35 121.65,163.35 121.81,163.19 121.81,162.88 121.65,162.72 120.7,162.72 120.54,162.56 120.54,162.2 120.7,162.04 121.62,162.04 121.77,161.88 121.77,161.57 121.62,161.41 120.7,161.41 120.54,161.25 120.54,158.53 121.26,157.82 123.5,157.82 125.28,156.04
  BOTTOM w0.102: v2(131.14,153.87) 131.45,153.56 UV1.P5
MDB21: length 35.4
  TOP w0.127: v2(126.54,166.37) 126.95,165.97 UV9.G2
  IN2 w0.102: 128.49,165.98 127.15,165.98 127.02,165.85 127.02,165.4 127.12,165.3 127.12,165.16 127,165.04 126.85,165.04 126.72,165.17 126.32,165.17 126.16,165.34 126.16,166.44 126.25,166.53 126.42,166.53 126.54,166.41 v2(126.54,166.37) ; v2(131.96,156.23) 131.96,156.09 131.85,155.98 131.68,155.98 131.57,156.09 131.57,157.31
  IN2 w0.157: 128.49,165.98 128.57,166.06 128.57,166.42 128.7,166.55 130.46,166.55 130.59,166.42 130.59,165.97 130.46,165.85 129.48,165.85 129.36,165.72 129.36,165.38 129.48,165.26 130.42,165.26 130.58,165.1 130.58,164.54 130.47,164.44 129.51,164.44 129.04,164.91 128.82,164.91 128.6,164.69 128.6,164.39 128.81,164.18 128.81,163.99 128.94,163.87 131.38,163.87 131.5,163.74 131.5,163.38 131.38,163.26 131.31,163.26 131.18,163.13 131.18,162.65 131.05,162.52 130.68,162.52 130.55,162.65 130.55,163.08 130.42,163.2 130.07,163.2 129.95,163.08 129.95,162 129.78,161.84 129.78,161.63 129.91,161.5 130.11,161.5 130.23,161.37 130.23,161.05 130.11,160.92 129.91,160.92 129.78,160.79 129.78,160.45 129.94,160.29 130.24,160.29 130.4,160.14 130.4,159.82 130.24,159.66 129.94,159.66 129.78,159.51 129.78,159.23 129.91,159.1 130.59,159.1 130.87,159.38 131.59,159.38 131.71,159.26 131.71,157.46 131.57,157.31
  BOTTOM w0.102: v2(131.96,156.23) 132.42,155.78 132.42,154.96 132.56,154.82 132.56,154.51 132.25,154.2 UV1.R4
MDB22: length 35.9
  TOP w0.127: v2(125.77,165.56) 126.17,165.96 UV9.F2
  IN2 w0.102: 131.06,157.31 131.36,157 131.36,155.33 131.49,155.2 132.45,155.2 132.57,155.08 132.57,154.91 132.45,154.78 131.93,154.78 131.8,154.66 131.8,154.46 131.9,154.36 132.15,154.36 132.25,154.26 132.25,154.06 132.15,153.96 131.9,153.96 131.8,153.85 131.8,153.59 131.93,153.46 132.61,153.46 132.74,153.59 v2(132.74,153.86) ; v2(125.77,165.56) 125.34,165.99 124.66,165.99 124.53,165.86 124.53,165.29 124.66,165.16 125.99,165.16 126.17,164.98 126.17,164.5 126.21,164.46
  IN2 w0.157: 126.21,164.46 126.32,164.35 128.24,164.35 128.37,164.23 128.37,163.84 128.24,163.71 126.85,163.71 126.72,163.59 126.72,162.93 126.85,162.8 129.36,162.8 129.48,162.67 129.48,162.19 129.36,162.07 127.44,162.07 127.32,161.94 127.32,161.56 127.44,161.44 129.16,161.44 129.32,161.28 129.32,158.8 129.47,158.64 131.09,158.64 131.25,158.48 131.25,158.17 131.09,158.01 129.47,158.01 129.32,157.85 129.32,157.6 129.52,157.39 130.97,157.39 131.06,157.31
  BOTTOM w0.102: v2(132.74,153.86) 132.68,153.81 132.68,152.84 UV1.T6
MDB23: length 34.8
  TOP w0.102: UV9.H3 127.74,166.77 v2(127.37,167.14)
  IN2 w0.157: v2(127.37,167.14) 127.67,166.84 132.57,166.84 132.7,166.71 132.7,166.15 132.57,166.02 131.02,166.02 130.89,165.9 130.89,164.42 131.02,164.3 131.61,164.3 132.18,163.73 132.18,162.99 130.96,161.77 130.96,161.24 132.18,160.02 132.18,157.25 v2(131.96,157.03)
  BOTTOM w0.127: v2(131.96,157.03) 131.78,156.85 131.25,156.85 131.12,156.98 131.12,157.19 131.05,157.26 130.24,157.26 130.11,157.39 130.11,157.77 130.24,157.89 v1(132.2,157.89) 135.11,157.89 135.24,157.77 135.24,157.26 135.11,157.13 134.91,157.13 134.78,157.01 134.78,156.45 134.65,156.32 134.35,156.32 134.22,156.45 134.22,157.18 134.09,157.31 132.61,157.31 132.48,157.18 132.48,156.66 132.61,156.54 133.05,156.54 133.18,156.41 133.18,155.2 UV1.T1
MDB24: length 32.5
  IN1 w0.157: v2(133.57,155.64) 133.84,155.64 133.97,155.51 133.97,154.65 133.84,154.52 132.81,154.52 132.61,154.31 128.36,154.31 127.99,154.68 127.07,154.68 126.25,155.51 126.25,155.76 125.86,156.14 125.01,156.14 121.17,159.98 121.17,166.77 124.77,170.37 v2(125.78,170.37)
  BOTTOM w0.102: v2(125.78,170.37) 126.17,170.76 UV10.F2 ; UV1.U4 134.2,154.21 134.2,154.79 134.12,154.86 134.12,155.37 133.85,155.64 v2(133.57,155.64)
