# Allegro board IBM-Lenovo G410 G510 COMPAL LA-9641P BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_OC1#: length 7.4
  TOP w0.089: 128,96.85 128.02,96.83 v1(128.02,96.48) 128.02,96.01 128.35,95.68 128.35,94.61 128.03,94.28 U4.V1
  TOP w0.102: RP14.6 128.99,100.29 128.81,100.1 128.81,99.77 128,98.96 128,96.85
USB_OC2#: length 7.3
  TOP w0.089: U4.U2 128.46,93.68 128.55,93.77 128.55,94.25 128.78,94.48 128.78,95.5 128.91,95.63 128.91,96.32 128.38,96.85
  TOP w0.102: RP14.7 129.03,99.64 128.23,98.83 128.23,97.02 128.31,96.94 128.31,96.93 128.38,96.85
USB_OC3#: length 5.4
  TOP w0.089: 129.07,96.82 129.27,96.62 129.27,96.14 v1(129.67,95.75) 129.84,95.58 129.84,94.76 129.65,94.58 U4.P1
  TOP w0.102: RP14.9 129.03,98.34 128.7,98 128.7,97.2 129.07,96.82
USB_OC4#: length 89.3
  TOP w0.089: 132.04,96.85 132.04,96.49 130.77,95.23 130.77,94 130.47,93.7 U4.M3
  TOP w0.102: 132.04,96.85 132.31,97.12 132.31,98.6 131.76,99.15 v2(131.76,99.5) 131.62,99.64 RP14.4
  IN1 w0.127: v2(131.76,99.5) 131.76,102.18 136.21,106.63 149.77,106.63 153.74,110.6 164.58,110.6 164.89,110.29 164.89,109.64 165.49,109.04 171.86,109.04 176.19,104.7 176.19,104.7 v2(176.26,104.63)
  IN2 w0.127: v2(196.02,114.84) 196.02,114.46 186.19,104.63 v2(176.26,104.63)
  BOTTOM w0.102: v2(196.02,114.84) 196.51,114.35 U36.5
USB_OC5#: length 6
  TOP w0.089: U4.T1 128.96,94.25 128.96,95.43 129.09,95.56 129.09,96.48
  TOP w0.102: 129.09,96.48 128.46,97.12 128.46,98.4 129.04,98.99 RP14.8
USB_OC6#: length 6.1
  TOP w0.089: 131.37,96.85 131.32,96.85 130.29,95.83 130.29,94.55 130.14,94.39 130.14,93.73 130.08,93.68 U4.N2
  TOP w0.102: 131.37,96.85 131.78,97.26 131.78,98.08 131.53,98.34 RP14.2
USB_OC7#: length 6.3
  TOP w0.089: 131.71,96.85 131.71,96.74 v1(131.45,96.48) 130.54,95.56 130.54,94.49 130.47,94.42 U4.M1
  TOP w0.102: RP14.3 131.47,98.99 132.08,98.38 132.08,97.22 131.71,96.85
USB_ON#: length 327.6
  TOP w0.102: v2(21.71,30.38) 21.25,29.91 U35.4 ; v2(164.7,79.35) 164.59,79.46 164.26,79.46 163.01,80.71 163.01,81.06 162.56,81.51 161.85,81.51 161.7,81.36 U31.84 159.9,81.36 159.6,81.66 158.53,81.66 R594.1
  IN1 w0.127: v2(186.66,81.77) 186.99,81.77 190.25,85.04 190.25,89.72 188.02,91.96 188.02,110.61 188.73,111.32 195.93,111.32 196.51,110.74 v2(196.51,108.48)
  IN2 w0.127: v2(186.66,81.77) 186.66,80.67 184.66,78.66 179.52,78.66 178.93,78.08 177.35,78.08 176.94,78.48 172.62,78.48 172.17,78.04 170.42,78.04 169.72,78.74 168.15,78.74 167.8,78.38 165.67,78.38 v2(164.7,79.35) ; v2(21.71,30.38) 21.71,19.12 25.72,15.11 41.26,15.11 42.97,16.82 42.97,17.62 43.71,18.35 48,18.35 48.9,19.26 75.77,19.26 76.2,18.82 178.79,18.82 v2(180.24,20.27)
  BOTTOM w0.102: v2(164.7,79.35) 164.55,79.5 162.3,79.5 161.03,78.23 161.03,70.74 162.22,69.55 v1(162.22,68.98) 162.22,59.96 167.66,54.52 173.86,54.52 175.72,52.66 175.72,45.51 180.85,40.39 180.85,20.88 v2(180.24,20.27) ; U36.4 v2(196.51,108.48)
USBRBIAS: length 3.2
  TOP w0.102: U4.K24 131.77,84.33 131.77,83.72 U4.K26 131.58,83.53 131.58,83.15 v2(131.69,83.05)
  BOTTOM w0.089: v1(131.95,83.54) 131.69,83.28 v2(131.69,83.05)
  BOTTOM w0.102: v2(131.69,83.05) 132.34,82.39 R242.1
VGA_B: length 4.4
  BOTTOM w0.102: UV1.AF37 141.05,128.02 141.63,127.44 141.63,127 141.45,126.81 141.45,124.72 T26.1
VGA_CLK: length 8.1
  BOTTOM w0.102: T27.1 151.59,136.42 150.32,137.69 148.07,137.69 147.86,137.48 147.4,137.48 147.16,137.24 146.82,137.24 UV1.AM26
VGA_DAT: length 7.2
  BOTTOM w0.102: T28.1 152.79,135.3 149.49,135.3 149.23,135.56 149.23,135.84 149,136.06 148.37,136.06 147.69,136.75 147.13,136.75 UV1.AN26
VGA_G: length 6.3
  BOTTOM w0.102: T25.1 143.02,124.45 142.37,125.1 142.37,126.24 142.29,126.32 142.29,127.98 141.97,128.3 141.54,128.3 141.17,128.67 UV1.AE36
VGA_R: length 3.6
  BOTTOM w0.102: UV1.AD39 139.45,125.36 T24.1
VGA_SMB_CK2: length 22.4
  TOP w0.102: QV3.1 149.44,124.07 RV24.2 148.5,123.88 148.25,124.13 148.25,125.77 v2(148.71,126.22)
  IN2 w0.102: v2(144,138.29) 143.8,138.48 143.8,138.69 143.85,138.74 144.32,138.74 144.5,138.56 144.5,134.33 146.2,132.63 146.2,130.48 149.79,126.89 149.79,126.35 149.66,126.22 v2(148.71,126.22)
  BOTTOM w0.102: v2(144,138.29) 143.65,138.63 UV1.AJ23
VGA_SMB_DA2: length 21.4
  TOP w0.102: RV25.2 150.8,128 150.74,127.94 QV3.4 150.74,126.34 150.92,126.16 v2(151.3,126.16)
  IN2 w0.102: v2(151.3,126.16) 150.29,126.16 150.1,126.35 150.1,127.02 146.5,130.61 146.5,132.76 144.8,134.45 144.8,138.69 144.44,139.05 143.73,139.05 143.5,138.82 143.5,138.39 v2(143.36,138.26)
  BOTTOM w0.102: v2(143.36,138.26) 142.96,138.67 UV1.AH23
VGATE: length 237.8
  TOP w0.102: U31.74 162.23,85.36 162.74,85.86 v2(162.74,86.99) ; v2(82.94,120) 85.42,120 v3(86.72,118.7) 95.24,110.18 102.61,110.18 106.76,106.03 106.76,103.9 107.09,103.57 v2(107.09,103.46)
  IN1 w0.127: v2(118.95,101.36) 118.26,102.05 118.26,102.87 115.82,105.31 109.74,105.31 107.89,103.46 v2(107.09,103.46)
  IN2 w0.127: v2(160.41,116.48) 159.87,117.02 152.57,117.02 151.55,116 142.17,116 141.66,116.51 132.29,116.51 129.53,119.27 107.69,119.27 105.9,117.49 102.72,117.49 101.63,118.58 100.54,118.58 99.86,117.9 97.12,117.9 95.02,120 v2(82.94,120) 82.05,120.89 71.6,120.89 67.4,116.69 52.74,116.69 51.45,117.98 50.64,117.98 46.87,121.75 46.87,126.1 45.42,127.56 32.45,127.56 29.73,124.84 26.8,124.84 26.32,124.36 25.85,124.36 v2(24.84,125.37)
  BOTTOM w0.102: v2(160.41,116.48) 160.7,116.19 160.7,112.47 161.51,111.66 161.51,101.7 161.22,101.41 161.22,97.59 160.56,96.93 160.56,93.35 161.55,92.36 161.55,91.03 162.74,89.84 v2(162.74,86.99) ; v2(118.95,101.36) 120.05,100.26 U6.1
  BOTTOM w0.203: PU901.6 23.89,125.45 PR916.1
  BOTTOM w0.254: v2(24.84,125.37) 24.84,125.53 PR916.1
VL: length 187.5
  TOP w0.102: v3(99,6.56) 99,6.4 v4(99.37,6.03)
  TOP w0.254: PR212.2 187.62,74.13 186.72,74.13 v2(186.2,73.61) 185.85,73.61 185.68,73.44 PC202.1 185.67,72.94 PU201.8 ; PR210.2 PR202.2 v2(185.97,61.98)
  TOP w0.508: PC430.1 99.46,5.94 v4(99.37,6.03)
  IN1 w0.254: v2(188.45,1.24) 188.45,14.58 188.94,15.06 188.94,48.94 192.03,52.03 195.64,52.03 196.32,52.71 196.32,59.23 194.87,60.69 189.01,60.69 187.72,61.98 v2(185.97,61.98)
  IN2 w0.508: v4(99.37,6.03) 102.43,2.97 110.98,2.97 111.17,2.78 112.61,2.78 113.93,1.46 139.28,1.46 140.38,2.56 162.2,2.56 163.52,1.24 v2(188.45,1.24)
  BOTTOM w0.254: v4(99.37,6.03) 99.38,6.02 PU402.7 ; v2(185.97,61.98) 185.97,73.38 v2(186.2,73.61)
VMB: length 133
  TOP w0.254: v2(191.14,73.66) 191.55,73.66 191.83,73.38 PR203.2
  IN1 w0.254: v2(191.14,73.66) 191.69,74.2 191.69,76.67 190.61,77.75 190.61,82.65 191.52,83.56 191.52,87 197.35,92.83 197.35,105.39 198.52,106.56 198.52,134.38 199.31,135.16 199.31,137.93 202.55,141.17 205.09,141.17 v2(205.59,140.66)
  IN2 w0.254: v4(180.63,173.17) 182.43,173.17 183.5,174.24 187.85,174.24 190.16,171.93 199.37,171.93 204.74,166.56 204.74,162.44 207.17,160.02 207.17,142.72 205.59,141.15 v2(205.59,140.66)
  vias: v3(178.01,173.26) v4(179.34,173.85) v4(179.34,173.21) v4(179.32,172.57) v4(179.36,171.84) v4(179.99,173.86) v4(179.99,173.22) v4(179.98,172.57) v4(180.06,171.84) v4(180.63,173.87) v4(180.63,172.54) v4(180.69,171.84)
VMB2: length 5.4
  TOP w0.102: v3(179.48,179.35) 178.99,178.85 178.11,178.85 ; v3(178.39,181.02) 177.68,180.31 177.68,179.26 ; 176.22,179.18 176.22,180.6 v3(175.95,180.87)
VR_ON: length 210.7
  TOP w0.102: v2(19.38,127.44) v3(20.1,127.44) ; U31.121 171.99,75.72 v2(171.43,76.27)
  IN1 w0.127: v2(91.47,118.59) 91.47,110.36 93.57,108.26 147.63,108.26 150.73,111.36 164.9,111.36 166.21,110.05 v2(166.21,109.97)
  IN2 w0.127: v2(19.38,127.44) 19.22,127.28 19.22,124.88 20.25,123.85 26.53,123.85 27.01,124.33 29.94,124.33 32.66,127.05 45.2,127.05 46.36,125.89 46.36,121.54 50.43,117.47 51.24,117.47 52.53,116.18 67.61,116.18 71.81,120.38 78,120.38 79.79,118.59 v2(91.47,118.59)
  BOTTOM w0.102: v2(171.43,76.27) 171.27,76.44 171.27,78.69 169.73,80.23 169.73,87.42 169.57,87.59 169.57,94.99 169.38,95.17 169.38,96.45 167.9,97.93 167.9,99.06 166.21,100.75 166.21,108.15 166.21,108.16 v2(166.21,109.97)
  BOTTOM w0.254: PR914.1 v2(19.38,127.44)
VR_SVID_ALRT#: length 46.1
  TOP w0.127: R83.1 v2(51.74,118.61) v1(52.42,119.29) 53.3,119.29 53.61,118.97 R81.2
  IN2 w0.127: v2(22.86,125.25) 22.49,125.25 22.19,125.55 22.19,127.8 23.68,129.29 45.21,129.29 47.89,126.61 47.89,122.47 v2(51.74,118.61)
  BOTTOM w0.127: v2(22.86,125.25) 22.88,125.25 23.09,125.04 PU901.4
VR_SVID_CLK: length 52.5
  TOP w0.127: v2(54.01,108.44) 54.57,109 54.57,111.69 54.41,111.85 54.41,112.59 50.65,116.35 v1(50.65,117.13) 50.65,118.5 v2(50.79,118.64)
  IN2 w0.127: v2(50.79,118.64) 47.38,122.05 47.38,126.4 45,128.78 24.06,128.78 22.83,127.55 v2(22.83,125.96)
  BOTTOM w0.089: JCPU1.AM29 54.51,107.94 v2(54.01,108.44)
  BOTTOM w0.127: v2(22.83,125.96) PR910.1 23.49,125.95 PU901.5
VR_SVID_DAT: length 57.3
  TOP w0.102: v2(55.08,107.4) v1(56.19,108.52) 56.57,108.89 56.57,108.89 56.57,113.48 56.01,114.03 53.61,114.03 53.07,114.58 53.07,116.27 R87.1
  TOP w0.127: v2(52.68,118.54) 52.68,117.73 53.6,116.81 R87.1
  IN2 w0.127: v2(20.31,126.64) 23.47,129.79 45.42,129.79 48.39,126.82 48.39,122.68 52.53,118.54 v2(52.68,118.54)
  BOTTOM w0.089: v2(55.08,107.4) 55.51,106.97 JCPU1.AL28
  BOTTOM w0.127: PR905.1 v2(20.31,126.64)
VRON_VGA: length 7.9
  TOP w0.102: v1(188.4,131.67) 189.15,132.42 189.15,133.22 PR813.2
  TOP w0.203: PU801.38 188.22,135.05 v2(188.41,134.87)
  TOP w0.254: v2(188.41,134.87) 188.68,134.59 PR813.2
  BOTTOM w0.254: PR820.2 188.73,134.31 188.57,134.46 188.57,134.7 v2(188.41,134.87) 187.43,134.87 PC805.2
VSEN_VGA: length 10.7
  TOP w0.203: PU801.12 188.62,141.32 189.06,141.76 v2(189.18,141.76) PR843.2 189.17,143.15 PC874.2
  BOTTOM w0.254: PR850.2 190.62,144.17 PR854.2 189.15,143.98 PC863.1 189.15,141.78 v2(189.18,141.76) 189.82,141.76 190.22,141.36 v1(190.22,140.78) 190.22,139.65 PC859.1
VSUM+_VGA: length 16.9
  TOP w0.203: PR851.1 187.36,142.72 187.62,142.46 187.62,141.79 187.42,141.59 PU801.15
  TOP w0.254: PC861.1 182.03,145.32 PC860.1 184.27,145.32 PR859.1 184.52,145.08 v2(185.12,145.08) ; PR851.1 186.97,143.3 v2(186.68,143.02)
  IN2 w0.254: v2(186.68,143.02) 186.48,143.02 185.87,143.62 185.87,144.09 185.12,144.84 v2(185.12,145.08)
  BOTTOM w0.254: PR853.1 183.43,141.65 PR827.2 184.2,142.6 184.49,142.9 184.49,143.32 184.65,143.48 184.65,143.81 184.49,143.97 v1(184.49,144.54) 184.49,145.08 ; 184.49,145.08 184.49,145.9 183.55,146.85 PR856.2 ; 184.49,145.08 185.12,145.08 v2(185.12,145.08)
VSUM-_VGA: length 47.2
  TOP w0.102: PC861.2 181.53,143.93 180.82,144.64 v3(180.56,144.64)
  TOP w0.254: v2(185.12,144.16) 185.02,144.26 PR859.2 183.64,144.26 PC860.2 182.03,143.92 PC861.2
  IN1 w0.254: v2(193.08,141.09) 193.08,143.2 192.29,143.99 188.82,143.99 188.65,144.16 v2(185.12,144.16) 185.08,144.13 183.12,144.13 181.26,142.28 180.47,142.28 180.29,142.09 164.83,142.09 v2(164.32,141.58)
  IN2 w0.254: v2(185.12,144.16) 183.44,145.84 v2(183.44,146.21)
  BOTTOM w0.254: v2(183.44,146.21) PR858.2 183.44,144.46 PR829.2 ; PC866.1 184.94,141.27 PR862.2 185.12,142.34 v2(185.12,144.16) ; v2(193.08,141.09) 192.76,141.4 PC875.2 PC850.2 ; PH802.2 v2(164.32,141.58)
VSUM_VGA_N001: length 2.9
  TOP w0.102: v1(186.71,145.15) 186.34,144.78 v2(186.34,144.69)
  TOP w0.254: PR851.2 186.89,144.69 v2(186.34,144.69)
  BOTTOM w0.254: PC864.1 185.87,144.54 186.01,144.69 v2(186.34,144.69)
VSYNC: length 4
  BOTTOM w0.102: T6.1 138.83,125.42 138.83,127.7 138.66,127.87 UV1.AC38
VW_VGA: length 4.4
  TOP w0.203: v2(191.02,138.27) 190.51,138.27 190.32,138.46 PU801.6
  BOTTOM w0.102: PR841.1 192.99,137.91 193.14,137.77 v1(193.78,137.77)
  BOTTOM w0.254: v2(191.02,138.27) 191.38,137.92 PC873.1 192.65,137.92 PR841.1
WEA0#: length 33.5
  TOP w0.102: UV5.L3 111.04,134.24 110.62,134.24 110.35,133.96 109.98,133.96 109.86,133.85 109.86,133.68 109.98,133.56 v2(110.16,133.56) ; v2(127.63,136.07) 127.8,136.07 127.92,136.18 127.92,136.36 127.79,136.48 127.25,136.48 127.12,136.61 127.12,136.77 127.22,136.88 127.53,136.88 127.63,136.98 127.63,137.22 127.5,137.35 127.1,137.35 126.89,137.56 125.37,137.56 124.41,138.52 123.59,138.52 123.49,138.41 123.49,138.17 123.38,138.07 123.18,138.07 123.08,138.17 123.08,138.41 122.98,138.52 122.69,138.52 122.63,138.45 122.63,138.22 122.57,138.17 121.04,138.17 120.81,137.93
  TOP w0.203: 120.81,137.93 120.68,137.8 117.83,137.8 v1(116.22,139.41) 115.73,139.9 115.51,139.9 v2(115.48,139.88)
  IN1 w0.127: v2(115.48,139.88) 115.57,139.79 115.57,137.67 115.44,137.55 115.03,137.55 114.9,137.42 114.9,137.16 115.03,137.03 115.2,137.03 115.32,136.9 115.32,136.74 113.86,135.28 113.77,135.28 113.41,135.64 112.9,135.64 112.66,135.89 112.51,135.89 112.27,135.64 112.02,135.39 112.02,135.12 110.45,133.56 v2(110.16,133.56)
  BOTTOM w0.102: UV6.L3 108.88,133.19 109.65,133.19 110.01,133.56 v2(110.16,133.56) ; v2(127.63,136.07) 128.04,136.47 UV1.K26
WEA1#: length 34.1
  TOP w0.102: 120.81,145.23 121.63,145.23 121.83,145.03 124.49,145.03 125.29,145.83 127.27,145.83 v2(127.6,145.51) ; UV7.L3 107.74,150.32 107.61,150.45 107.61,150.66 107.74,150.78 108.2,150.78 108.4,150.58 108.83,150.58 v2(109.05,150.8)
  TOP w0.203: v2(114.41,145.93) 114.16,145.93 113.89,145.67 113.38,145.67 113.25,145.54 113.25,145 113.38,144.87 114.37,144.87 114.73,145.23 116.05,145.23 116.25,145.43 116.25,145.86 116.4,146.01 v1(116.66,146.01) 116.86,146.01 117.07,145.81 117.07,145.43 117.27,145.23 117.68,145.23 117.88,145.43 117.88,145.81 118.08,146.01 118.49,146.01 118.69,145.81 118.69,145.43 118.89,145.23 119.3,145.23 119.5,145.43 119.5,145.68 119.63,145.81 120.19,145.81 120.32,145.68 120.32,145.43 120.52,145.23 120.81,145.23
  IN1 w0.127: v2(109.05,150.8) 109.45,150.4 110.26,150.4 113.14,147.52 113.37,147.52 114.06,146.83 114.06,146.29 v2(114.41,145.93)
  BOTTOM w0.102: UV8.L3 110.78,150.32 109.92,151.18 109.56,151.18 109.18,150.8 v2(109.05,150.8) ; UV1.L15 128.42,145.23 127.87,145.23 v2(127.6,145.51)
WEB0#: length 36.4
  TOP w0.102: 132.21,154.12 132.21,152.96 131.5,152.24 v1(131.5,150.28) 131.5,149.95 131.21,149.66 v2(130.83,149.66) ; v2(129.68,167.83) 129.98,167.54 129.98,167.19 129.76,166.98 129.76,166.41 129.85,166.32 130.21,166.32 130.29,166.4 130.29,166.65 UV9.L3
  TOP w0.203: 132.21,154.12 132.21,154.24 132.41,154.43 133,154.43 133.12,154.55 133.12,155.11 132.99,155.24 132.52,155.24 132.39,155.37 132.39,155.94 132.51,156.06 132.98,156.06 133.12,156.19 133.12,156.71 132.96,156.87 132.53,156.87 132.39,157.01 132.39,157.34 132.27,157.46 131.82,157.46 131.71,157.58 131.71,158.15 131.83,158.28 132.6,158.28 132.75,158.43 132.75,159.19 133.57,160.02 133.9,160.02 133.99,160.11 133.99,160.44 134.61,161.06 135.02,161.06 135.19,161.22 135.19,161.63 135.92,162.37 136.58,162.37 136.68,162.47 136.68,162.65 136.27,163.06 v2(136.27,163.12)
  IN1 w0.127: v2(136.27,163.12) 134.9,163.12 134.1,163.92 132.42,163.92 132.23,164.11 131.95,164.11 131.7,164.36 131.7,164.87 131.45,165.12 131.07,165.12 130.45,165.74 130.45,166.77 129.68,167.54 v2(129.68,167.83)
  BOTTOM w0.102: UV1.N10 130.64,149.47 v2(130.83,149.66) ; UV10.L3 130.32,169.82 130.32,169.71 129.31,168.7 129.31,168.39 129.68,168.02 v2(129.68,167.83)
WEB1#: length 38.2
  TOP w0.102: v2(147.98,168.9) 147.98,168.67 147.86,168.55 147.67,168.55 147.59,168.63 147.59,169.05 147.5,169.14 UV12.L3 ; v2(138.07,149.28) 138.7,149.91 138.7,152.31 139.37,152.98 139.37,154.04 140.13,154.79 140.13,157.3 140.14,157.31
  TOP w0.203: 140.14,157.31 140.8,157.97 v1(141.97,157.97) 142.87,157.97 143.02,158.12 143.02,158.54 142.92,158.65 141.83,158.65 141.73,158.75 141.73,159.23 141.88,159.38 142.84,159.38 143.01,159.55 143.01,160.03 142.84,160.2 141.87,160.2 141.73,160.33 141.73,162.87 141.83,162.98 142.98,162.98 143.09,163.08 143.09,163.45 142.98,163.55 141.89,163.55 141.73,163.71 141.73,164 141.89,164.17 v2(142.48,164.17)
  IN1 w0.127: v2(142.48,164.17) 142.65,164.34 142.65,165.07 143.34,165.76 144.48,165.76 145.59,166.87 146.46,166.87 147.58,167.99 147.58,168.35 147.98,168.75 v2(147.98,168.9)
  BOTTOM w0.102: UV11.L3 148.36,167.63 148.36,168.39 147.98,168.77 v2(147.98,168.9) ; UV1.AB11 137.85,149.06 v2(138.07,149.28)
XDP_DBRESET#: length 9.8
  TOP w0.089: v1(48.48,109.42) 48.24,109.18
  TOP w0.102: R11.2 47.27,108.15 C186.1 v2(47.97,109.08) 48.14,109.08 48.24,109.18
  IN2 w0.089: 48.24,111.9 48.67,112.33 v2(52.04,112.33)
  IN2 w0.127: 48.24,111.9 47.97,111.63 v2(47.97,109.08)
  BOTTOM w0.089: v2(52.04,112.33) 52.43,111.94 JCPU1.AP33
XDP_TCLK: length 8.6
  TOP w0.102: RP19.7 47.74,113.37 v2(48.18,113.8)
  IN2 w0.089: v2(53.96,112.41) 53.93,112.41 53.59,112.75 51.23,112.75 50.5,113.48 48.5,113.48 48.24,113.74
  IN2 w0.127: 48.24,113.74 v2(48.18,113.8)
  BOTTOM w0.089: v2(53.96,112.41) 54.49,112.94 JCPU1.AM34
XDP_TDI: length 1.3
  TOP w0.089: v2(54.04,110.41) 54.05,110.41 54.05,110.14 v3(53.78,109.88)
  BOTTOM w0.089: v2(54.04,110.41) 54.51,109.94 JCPU1.AM31
XDP_TDO: length 12.7
  TOP w0.089: v3(51.62,110.82) 51.06,111.38 v2(48.84,111.38) 48.5,111.38 48.24,111.63
  TOP w0.102: 48.24,111.63 47.51,112.37 RP19.5
  IN2 w0.089: v2(48.84,111.38) 50.13,111.38 50.62,111.86 54.36,111.86 v2(54.91,112.42)
  BOTTOM w0.089: v2(54.91,112.42) 55.39,111.94 JCPU1.AL33
XDP_TMS: length 2.5
  TOP w0.089: v3(52.47,113.95) 52.47,112.94 v2(53.04,112.37)
  BOTTOM w0.089: v2(53.04,112.37) 53.46,111.94 JCPU1.AN33
XDP_TRST#: length 8.7
  TOP w0.089: 51.74,111.34 50.6,112.48 v3(50.31,112.48) 49.26,112.48 48.88,112.87 48.24,112.87
  TOP w0.102: 48.24,112.87 47.48,112.87 RP19.6 ; 51.74,111.34 52.47,111.34 52.72,111.09 53.59,111.09 v2(53.96,111.46)
  BOTTOM w0.089: v2(53.96,111.46) 54.44,111.94 JCPU1.AM33
XTAL25_IN: length 10.8
  TOP w0.089: U4.AM43 122.34,75.92 122.64,75.62 122.64,74.41 v1(122.18,73.95) 121.51,73.28 120.13,73.28 119.7,72.85
  TOP w0.102: Y2.1 119.58,69.33 C119.1 119.58,71.27 R215.2 119.58,72.73 119.7,72.85
XTAL25_OUT: length 7.7
  TOP w0.089: 120.62,72.8 v1(121.43,72.8) 121.43,72.8 122.94,74.3 122.94,75.27 122.82,75.4 122.82,75.69 122.81,75.7 122.81,75.91 122.75,75.98 U4.AL44
  TOP w0.102: 120.62,72.8 120.49,72.67 R215.1 120.49,71.28 C118.1 120.49,70.14 Y2.3
XTALIN: length 8.1
  BOTTOM w0.102: YV1.1 156.2,131.2 CV36.2 154.26,131.19 RV32.1 v1(152.1,131.19) 151.38,131.19 151.06,130.87 UV1.AV33
XTALOUT: length 6.6
  BOTTOM w0.102: UV1.AU34 149.68,130.49 153.04,130.49 153.26,130.28 RV32.2 154.26,130.28 CV37.2 155.29,130.27 YV1.3
N14438658: length 3.8
  TOP w0.102: 188.61,168.94 v1(189.67,170)
  TOP w0.254: PU301.12 188.61,169.78 187.98,170.4 PR317.1
N14480890: length 4.2
  TOP w0.254: PR316.1 PR315.2 v1(191.21,169) 190.98,168.78 190.98,168.56 190.88,168.47 190.88,167.98 190.63,167.73 PU301.10
N14491778: length 5.8
  TOP w0.102: v1(181.5,154.31) 182.01,154.82 PQ303.1
  TOP w0.254: PQ303.1 183.74,155.61 183.18,156.17 v4(182.8,156.17)
  BOTTOM w0.254: v4(182.8,156.17) 182.54,156.17 182.19,155.82 PQ304.2
N14491788: length 5
  TOP w0.102: PQ303.2 181.98,153.22 v1(181.68,152.92)
  TOP w0.254: v4(182.54,151.33) 182.64,151.23 182.96,151.23 183.08,151.36 PQ307.6 183.08,153.22 PQ303.2
  BOTTOM w0.254: PR302.2 v4(182.54,151.33)
N14491836: length 8.1
  TOP w0.254: v4(181.58,151.07) 181.88,150.76 183.41,150.76 ; PQ307.5 183.73,151.09 183.41,150.76 ; 183.41,150.76 183.73,150.44 PQ307.2
  BOTTOM w0.254: PQ305.1 179.99,152.32 180.17,152.14 v1(180.53,152.14) PR303.2 181.58,151.07 v4(181.58,151.07)
N14492090: length 5.3
  TOP w0.102: v1(164.43,174.84) 165.04,174.23 PD303.1
  TOP w0.254: PD303.1 164.98,173.57 PD302.1 163.08,171.74 PQ311.2
N14492092: length 8.7
  TOP w0.254: PR325.1 162.88,165.98 PC324.1 163.5,165.97 v2(163.62,165.85) 164.47,166.7 v1(164.47,168.64) 164.47,170.87 PD303.2
  BOTTOM w0.254: PQ313.1 v2(163.62,165.85)
N14534043: length 5.4
  TOP w0.254: 193.08,166.29 193.08,165.38 PR309.2 194.02,165.35 PR308.2 ; 193.08,166.29 PC303.2 ; 193.08,166.29 192.57,166.29 192.15,165.88 191.84,165.88 191.69,165.73 v1(191.17,165.73) PU301.6
N14561712: length 1.5
  TOP w0.102: v1(181.25,162.81) 181.66,163.22 PC317.2
N14568681: length 6.4
  TOP w0.102: v1(16.61,122.1) PC902.2
  TOP w0.254: PR903.2 PC902.2 17.65,121.21 PR904.1 PC904.1 19.04,121.19 19.16,121.07 v2(19.31,121.07)
  BOTTOM w0.203: v2(19.31,121.07) 19.31,121.07 19.49,121.07 19.75,121.32 PU901.32
N14568937: length 5.4
  TOP w0.102: v1(18.58,124.97) PR902.1
  TOP w0.254: PR902.1 18.58,123.91 PR903.1 19.26,122.33 v2(19.26,121.65)
  BOTTOM w0.203: PU901.33 19.34,121.72 v2(19.26,121.65)
N14568985: length 1.8
  TOP w0.508: PC907.2 20.42,122.95 20.14,123.23 v2(19.64,123.23)
  vias: v1(19.69,123.81)
N14569027: length 44.6
  TOP w0.254: v2(18.15,114.45) 18.58,114.89 PR911.1 18.58,117.38 PR901.2
  BOTTOM w0.254: PH901.1 42.01,129.21 31.99,129.21 31.6,129.59 18.64,129.59 15.58,126.53 v1(15.58,122.21) 15.58,117.4 17.27,115.7 17.27,115.14 17.96,114.45 v2(18.15,114.45)
N14569153: length 4
  BOTTOM w0.203: PU901.30 20.31,120.52 19.6,119.81 19.6,119.49 v1(19.51,119.4) PC905.1
  BOTTOM w0.254: PC905.1 PR907.1
N14569169: length 3.7
  BOTTOM w0.203: PU901.1 21.89,124.24 21.64,124.49 20.7,124.49 v1(20.15,125.04) 19.38,125.81 PR914.2
N14569201: length 4.7
  BOTTOM w0.203: PR913.1 19.02,116.68 19.23,116.89 19.23,117.3 v1(19.6,117.68) 20.34,118.41 20.34,119.51 20.55,119.72 PU901.28
N14569343: length 5.1
  TOP w0.102: v1(20.17,124.7) 20.4,124.47 21.28,124.47 21.47,124.66 v2(21.47,124.97)
  TOP w0.254: PC987.1 22.19,124.95 PR915.2 22.17,124.97 v2(21.47,124.97)
  BOTTOM w0.203: PU901.2 22.29,124.43 21.74,124.97 v2(21.47,124.97)
N14569697: length 3.6
  TOP w0.254: v2(19.32,120.48) 19.11,120.28 PC904.2 PR904.2
  BOTTOM w0.203: 19.86,120.74 20.05,120.92 PU901.31 ; 19.86,120.74 v1(19.86,120.72) ; 19.86,120.74 19.61,120.48 19.32,120.48 v2(19.32,120.48)
N14569701: length 23.7
  TOP w0.102: PH902.2 v1(31.49,115.98)
  TOP w0.254: v2(25.13,127.59) 25.04,127.59 24.45,127.01 PR923.2 ; v2(32.61,115.18) PH902.2
  IN1 w0.254: v2(32.61,115.18) 32.25,115.18 31.41,116.02 31.41,127.19 30.49,128.11 25.65,128.11 v2(25.13,127.59)
  BOTTOM w0.254: v2(25.13,127.59) 25.13,127.07 PR942.2
N14569997: length 2.7
  TOP w0.102: v2(24.42,124.94) 24.42,125.09 v1(24.14,125.37)
  TOP w0.254: PR917.2 24.29,124.82 v2(24.42,124.94)
  BOTTOM w0.203: PU901.7 24.29,124.81 v2(24.42,124.94)
N14570301: length 3.5
  TOP w0.102: PR921.1 v1(27.18,124.03)
  TOP w0.254: v2(26.08,124.78) PR921.1
  BOTTOM w0.203: v2(26.08,124.78) 25.58,124.78 25.09,124.29 PU901.9
N14570423: length 2.1
  TOP w0.102: PR902.2 16.72,123.91 v1(16.56,124.08)
  TOP w0.254: PC902.1 17.65,123.9 PR902.2
N14570565: length 3.3
  BOTTOM w0.203: PR909.2 18.58,122.12 v1(19.72,122.12) PU901.34
  BOTTOM w0.254: PR909.2 18.58,121.23 PC906.2
N14598669: length 4.8
  TOP w0.102: PR704.2 v1(100.41,27.83)
  TOP w0.254: PU701.1 102.65,30.44 101.62,29.4 PC702.1 101.62,27.83 PR704.2
N14598673: length 5.2
  TOP w0.102: v1(102.53,26.76) PR704.1
  TOP w0.254: PU701.2 103.15,29.02 PC703.2 103.39,27.84 PR705.2 103.39,27.83 PR704.1
N14598909: length 3.5
  TOP w0.102: v1(108.87,30.9) 108.81,30.83 PC706.1
  TOP w0.254: PR709.1 PC705.2 106.89,29.92 PC706.1
N14598941: length 2.9
  TOP w0.254: PC706.2 106.89,31.56 v1(106.61,31.84) 106.56,31.89 106.1,31.89 105.92,31.71 PU701.5
N14599337: length 4.5
  TOP w0.254: PR707.2 105.77,28.8 PC704.2 v1(104.72,29.82) 104.15,30.38 PU701.4
N14599537: length 0.9
  TOP w0.102: 115.67,45.56 v1(115.67,46.49)
N16190418: length 6.2
  TOP w0.203: PU801.1 190.15,136.46 190.62,135.99 v2(191.55,135.99)
  BOTTOM w0.254: PR832.2 190.81,133.92 PR831.2 191.69,133.91 191.97,134.19 v1(191.97,135.01) 191.97,135.57 v2(191.55,135.99)
N16774791: length 27.6
  TOP w0.102: v3(186.43,173.67) 185,175.1 JBATT2.5
  IN2 w0.254: JBATT1.5 197.5,179.62 197.04,179.16 190.98,179.16 190.52,178.7 190.52,175.97 189.56,175.01 185.28,175.01 185,175.29 JBATT2.5
  BOTTOM w0.254: PR209.1 PR206.1 185.14,172.05 PR207.1 184.22,175.28 JBATT2.5
N16791696: length 4.6
  BOTTOM w0.102: v1(197.66,16.22) 197.66,15.05
  BOTTOM w0.254: PR608.1 197.66,15.05 PR607.2 197.66,13.24 PC607.2 197.66,12.21 197.71,12.16 PU601.4
N16791716: length 4.9
  TOP w0.102: v1(198.28,11.39) 198.55,11.66 PC637.1
  TOP w0.254: PC637.1 199.67,12 v2(199.67,12.47) 199.71,12.52 199.71,13.13 PR601.2
  BOTTOM w0.254: PU601.1 199.06,11.87 v2(199.67,12.47) 199.73,12.53 199.73,13.12 PR613.2
N16791765: length 7
  BOTTOM w0.102: PC605.1 194.84,13.27 194.36,13.75 194.36,16.51 v1(194.44,16.6)
  BOTTOM w0.254: PC605.1 195.82,12.69 196.76,12.69 197.26,12.19 PU601.5
N16792189: length 5.1
  TOP w0.102: v1(29.35,12.06) PR506.1
  TOP w0.203: PR507.2 30.48,8.92 30.66,8.74 PU501.6
  TOP w0.254: PR507.2 30.48,12.04 PR506.1
N16792225: length 7
  TOP w0.203: PU501.13 32.74,4.97 v2(32.66,4.88)
  TOP w0.254: PR511.2 28.4,3.88 v2(28.53,3.75)
  BOTTOM w0.254: v2(28.53,3.75) 29.66,4.88 v1(30.46,4.88) v2(32.66,4.88)
N16792229: length 3.4
  TOP w0.203: PR509.2 29.9,5.69 30.14,5.93 v1(30.14,6.65) 30.14,7.22 30.46,7.54 PU501.9
N16792231:
  vias: v1(29.2,3.18)
N16849024: length 8.7
  TOP w0.102: PC635.2 167.9,128.23 v1(167.9,127.37)
  TOP w0.254: v4(168.96,129.59) 168.96,129.94 PR615.1 168.26,130.22 168.07,130.03 PR611.2 PC635.2 ; PU604.4 172.23,129.6 v4(171.73,130.1)
  IN1 w0.254: v4(168.96,129.59) 171.21,129.59 v4(171.73,130.1)
N16849157: length 3.3
  TOP w0.254: v4(172.31,130.85) 172.31,130.66 172.78,130.2 v1(172.78,129.88) 172.78,129.22 172.68,129.12 PU604.5
  BOTTOM w0.508: PC630.1 172.96,131.49 v4(172.31,130.85)
N16986054: length 5.8
  TOP w0.254: PD105.1 181.7,113 181.16,113.54 v1(181.16,114.04) 181.16,114.52 181.33,114.68 PR104.2 PC105.2 183.71,114.81 PQ101.2
N16986060: length 4.2
  TOP w0.254: v2(187.8,119.24) PC106.1 187.18,119.23 PU101.7
  BOTTOM w0.102: v1(187.18,118.31) PR107.1
  BOTTOM w0.254: PR107.1 v2(187.8,119.24)
N16987330: length 6
  TOP w0.102: v1(184.43,75.38) PQ206.1
  TOP w0.254: PQ206.1 185.32,76.79 185.9,77.37 185.9,80.1 PR230.1
N16987354: length 6.3
  TOP w0.102: v1(187.81,75.38) PQ208.1
  TOP w0.254: PR229.1 189.35,80.12 189.35,77.05 189.12,76.82 PQ208.1
N16987356: length 7
  TOP w0.254: PR232.1 192.49,79.78 192.49,76.27 v1(192.28,76.06) 191.94,75.73 191.13,75.73 190.8,76.05 PQ207.1
N16989960: length 4.1
  TOP w0.102: v1(185.67,169.9) 186.37,169.9 186.95,170.48 PR318.1
  TOP w0.254: PR318.1 187.09,170.35 188.11,169.33 PU301.13
N16992568: length 4.5
  BOTTOM w0.102: v1(179.29,151.75) 179.75,151.75 180.82,150.68 PQ306.1
  BOTTOM w0.254: PQ306.1 181.62,149.81 181.87,149.57 PR306.2
N16993177: length 144.2
  TOP w0.102: PR228.1 v2(181.37,61.24)
  TOP w0.254: PH201.2 v2(68.84,96.4)
  IN1 w0.089: 87.23,93.29 86.93,92.99 80.44,92.99 77.63,95.79 69.45,95.79 v2(68.84,96.4)
  IN1 w0.127: v2(132.9,62.28) 132.32,61.69 114.57,61.69 107.31,68.96 107.31,85.39 97.77,94.93 96.11,94.93 95.18,95.86 92.87,95.86 90.67,93.65 87.59,93.65 87.23,93.29
  IN2 w0.127: v2(132.9,62.28) 137.69,62.28 139.63,60.33 156.15,60.33 157.5,61.68 160.23,61.68 161.05,60.86 168.55,60.86 169.56,59.84 179.97,59.84 v2(181.37,61.24)
  BOTTOM w0.102: v2(132.9,62.28) v1(133.46,62.84)
N16993569: length 7.9
  TOP w0.102: v1(188.64,110.2) 188.26,110.58 186.1,110.58 185.91,110.76 PU101.1
  TOP w0.254: PU101.1 185.91,113.06 185.63,113.34 184.98,113.34 PR106.1 184.54,113.77 PC105.1
N16994095: length 8.2
  TOP w0.254: PQ101.5 183.71,118.66 v1(184.44,119.39) 185.24,120.2 185.24,121.38 185.4,121.54 PD104.1 186.49,120.9 186.26,120.67 PR105.2 186.26,119.24 PC106.2
N16994577: length 11.1
  TOP w0.102: v1(190.66,121.35) 190.13,121.35 189.72,120.94 PR108.1
  TOP w0.254: PU101.2 187.18,113.53 189.72,116.07 PU101.5 189.72,118.99 PC107.1 189.67,119.05 PR109.2 189.67,120.77 PR108.1
N17005206: length 1.1
  TOP w0.102: PR102.1 v1(199.78,29.56)
N17017158: length 1
  TOP w0.102: PR110.2 v1(197.12,82.98)
N17017351: length 1
  TOP w0.102: PR103.2 v1(193.08,78.56)
N17041264: length 0.9
  TOP w0.254: PR413.1 PC419.2
N17139623: length 2.1
  BOTTOM w0.102: PC435.2 66.47,8.33 v1(66.68,8.54)
  BOTTOM w0.254: PC435.2 PR414.1
N17139626: length 3.7
  TOP w0.254: PU401.3 66.2,6.36 66.38,6.18 v1(66.38,5.8) v2(66.75,5.43)
  BOTTOM w0.254: PR411.2 66.5,6.59 PC435.1 66.47,6.13 66.75,5.85 v2(66.75,5.43)
N17144944: length 7.6
  TOP w0.254: PU401.7 64.25,7.45 64.09,7.3 64.09,6.98 v2(64.13,6.94)
  IN1 w0.254: v2(64.13,6.94) 64.49,6.59 v2(68.96,6.59)
  BOTTOM w0.102: v1(69.6,6.59) v2(68.96,6.59)
  BOTTOM w0.254: PR415.2 v2(68.96,6.59)
N17242868: length 30.8
  TOP w0.254: PC210.1 189.24,73.91 189.5,73.64 v2(189.5,73.07) ; PQ209.2 177.68,64.26 177.03,63.61 PR208.2 175.89,62.77 175.61,62.49 174.84,62.49 174.49,62.84 PD203.1 174.49,64.21 173.41,65.29 173.41,68.22 174.86,69.67 v1(177.25,69.67) v2(180.45,69.67)
  IN2 w0.254: v2(189.5,73.07) 187.19,70.76 184.75,70.76 183.66,69.67 v2(180.45,69.67)
N17242951: length 5.8
  TOP w0.102: PQ209.1 178.33,67.61 178.83,68.11 v1(179.49,68.11) PR211.1 180.53,67.07 PQ202.3 180.54,66.69 180.64,66.58 181.07,66.58 181.19,66.7 PQ202.2
N17242953: length 5.6
  TOP w0.254: PD201.1 183.5,63.82 PC208.1 183.45,63.78 v1(182.28,63.78) PR205.2 PQ202.5
N17243007: length 6
  TOP w0.102: PR213.2 186.42,62.03 v1(186.86,61.58)
  TOP w0.254: PR202.1 185.32,62.9 PR213.2 186.41,62.9 PC207.1 186.41,64.26 186.94,64.78 PU201.2
N17243023: length 5.8
  TOP w0.102: PR210.1 183.34,62.89 v1(182.95,62.51)
  TOP w0.254: PR210.1 184.37,62.91 PC208.2 184.37,64.2 184.66,64.49 185.48,64.49 185.67,64.68 PU201.1
N17243100: length 5.9
  TOP w0.254: PU201.6 188.21,72.09 188.59,72.48 189.61,72.48 v1(190.01,72.88) PR203.1 190.91,71.89 PC209.1 190.9,70.9 PR217.2
N17243144: length 3.2
  TOP w0.254: PU201.7 186.94,72.33 187.6,73 PR212.1 PC210.2
N17243787:
  vias: v1(35.53,10.03)
N17454478: length 9
  TOP w0.102: v1(79.27,20.42) 79.75,19.94 U39.4
  TOP w0.254: U39.4 79.75,17.85 79.5,17.6 C727.1 77.39,17.6 R650.2 76.51,17.6 R647.2 75.95,17.05 75.95,16.31 75.66,16.02 Q111.1
N17967384: length 3.8
  TOP w0.102: CL7.2 40.52,17.92 QL1.2 ; CL7.2 RL3.1 ; CL7.2 v1(40.83,16.56)
N18116330:
  vias: v1(191.74,17.43)
N19865382: length 10.8
  TOP w0.203: UA1.24 153.32,49.67 151.87,51.11 CA5.1
  TOP w0.508: CA5.1 151.86,51.67 CA6.1 v2(150.73,52.35) ; v2(148.8,54.52) 148.41,54.91 147.86,54.91 RA1.2 RA2.2
  BOTTOM w0.508: v2(148.8,54.52) v1(149.93,54.52) 150.73,53.72 v2(150.73,52.35)
N19867921: length 15.2
  TOP w0.102: v2(163.41,49.34) 162.85,49.9 CA16.1 161.54,49.9 161.42,50.01 CA17.1 159.87,50.01 159.54,49.67 UA1.7 ; RA4.2 160.62,54.95 160.62,55.4 160.77,55.55 v2(161.07,55.55) 161.07,56.28 v1(160.98,56.37)
  IN1 w0.127: v2(161.07,55.55) 162.13,55.55 162.81,54.87 162.81,50.61 163.41,50.02 v2(163.41,49.34)
N19871308: length 7.1
  BOTTOM w0.381: TL1.3 27.63,82.6 27.89,82.34 CL31.1 v1(27.89,80.46) 27.89,79.04 27.63,78.79 TL1.6
N19871378: length 1.6
  TOP w0.127: RL14.2 v1(18.22,87.2)
N19889959: length 4.6
  TOP w0.102: CA45.2 162.03,54.82 161.98,54.77 RA22.1 RA492.1 162.4,53.26 162.92,53.78 CA37.2 v1(163.94,54.2)
N19913181: length 2
  TOP w0.102: RL12.2 33.52,22.97 33.29,23.19 UL1.39
N20556954: length 2
  TOP w0.102: v2(141.33,135.11) 141.33,135.05 141.02,134.73 TV15.1
  BOTTOM w0.102: UV1.AG28 141.71,134.67 141.33,135.05 v2(141.33,135.11)
N23177764: length 6.7
  BOTTOM w0.254: R644.2 136.65,7.33 v1(138.84,7.33) 140.93,7.33 141.53,6.73 Q107.1
N23177889: length 3.4
  TOP w0.102: R645.2 69.3,19.36 v1(69.3,20.83)
  TOP w0.254: Q108.1 69.3,17.47 69.3,19.31 R645.2
N23302468: length 4.3
  TOP w0.102: v1(201.12,161.72) R507.2 200.05,161.74 R505.2 200.55,162.68 v2(200.68,162.8)
  BOTTOM w0.102: JWLN1.49 v2(200.68,162.8)
N24504317: length 5.8
  TOP w0.089: v1(86.57,89.05) 87.23,89.71
  TOP w0.102: 87.23,89.71 87.29,89.77 R35.2 89.43,89.77 89.81,89.38 89.81,88.47 89.64,88.29 Q1.1
N24517890: length 1.8
  TOP w0.089: v2(63.04,85.41) 63.16,85.41 T12.1
  BOTTOM w0.089: v2(63.04,85.41) 63.51,85.88 JCPU1.AC7
N24518400: length 1.6
  TOP w0.089: v2(59.04,86.36) 59.04,86.51 T13.1
  BOTTOM w0.089: v2(59.04,86.36) 59.51,86.84 JCPU1.AG8
N24564926: length 1.6
  TOP w0.089: v2(71.05,106.42) 71.16,106.42 T14.1
  BOTTOM w0.089: v2(71.05,106.42) 71.51,105.96 JCPU1.R27
N24573387: length 14.5
  TOP w0.089: v2(79.03,105.39) 78.59,105.83 78.59,107.49 78.95,107.85 83.39,107.85 85.17,109.64 v1(85.57,109.64) 86.88,109.64 87.23,109.99
  TOP w0.102: R88.1 87.95,110.29 R89.2 87.53,110.29 87.23,109.99
  BOTTOM w0.089: JCPU1.H27 78.51,105.91 v2(79.03,105.39)
N24581358: length 15.7
  TOP w0.089: 48.24,103.47 48.26,103.45 T15.1
  TOP w0.102: 48.24,103.47 v2(47.94,103.78)
  IN2 w0.089: 48.24,104.47 49.58,105.81 55.12,105.81 55.59,106.28 55.59,110.98 v2(56.03,111.42)
  IN2 w0.127: 48.24,104.47 47.94,104.17 v2(47.94,103.78)
  BOTTOM w0.089: JCPU1.AK33 56.51,111.9 v2(56.03,111.42)
N24621013: length 6.5
  TOP w0.102: v1(143.06,97.94) 143.06,97.38 142.55,96.87 142.55,96.31 C111.1 141.81,95.57 Y1.1 139.79,95.57 138.83,94.61 R689.2
N24629451: length 2.2
  BOTTOM w0.102: v1(111.59,100.12) 111.59,101.13 C120.2 R237.2
N24881149: length 3.9
  TOP w0.102: v1(94.64,100.14) R458.2 91.88,101.28 Q6.2
N25182664: length 16.6
  TOP w0.254: CA27.1 148.86,49.89 148.86,49.45 147.53,48.11 147.53,44.23 v1(147.35,44.05) 147.35,43.02 148.48,41.89 152.42,41.89 154.16,43.63 RA12.2
N25182692: length 13.9
  TOP w0.254: CA28.1 149.37,48.85 148.83,48.31 148.26,48.31 147.92,47.97 147.92,43.32 v1(148.48,42.77) 148.97,42.28 152.26,42.28 153.27,43.28 RA16.2
N25274724: length 15.8
  TOP w0.102: v1(148.62,53.79) 148.86,53.55 v2(148.86,53.25)
  TOP w0.254: RA17.2 v2(155.05,43.27) ; CA36.1 149.41,52.68 148.86,53.22 v2(148.86,53.25)
  BOTTOM w0.254: v2(155.05,43.27) 154.56,43.76 153.16,43.76 149,47.92 149,53.11 v2(148.86,53.25)
N25274821: length 17.1
  TOP w0.102: v1(155.49,42.97) 155.75,43.23 v2(155.94,43.23)
  TOP w0.254: CA46.1 149.93,52 149.93,53.01 v2(149.63,53.31) ; RA18.2 v2(155.94,43.23)
  BOTTOM w0.254: v2(155.94,43.23) 155.03,44.14 153.89,44.14 149.38,48.65 149.38,53.07 v2(149.63,53.31)
N25318268: length 27.2
  BOTTOM w0.102: JWLN1.30 206.28,155.2 206,155.49 205.56,155.49 205.2,155.13 205.2,150.06 201.71,146.56 201.71,139.66 200.95,138.91 198.04,138.91 197.87,138.74 197.87,137.41 197.35,136.89 197.35,135.58 R501.1
N25318300: length 27.7
  BOTTOM w0.102: R502.1 197.12,135.82 197.12,136.99 197.64,137.51 197.64,138.83 197.95,139.14 200.86,139.14 201.48,139.76 201.48,146.66 204.97,150.15 204.97,155.22 205.46,155.71 206.02,155.71 206.3,156 JWLN1.32
N25469058: length 1.3
  TOP w0.102: v3(15.86,59.04) 15.96,58.94 17.11,58.94
N25473460: length 4.2
  TOP w0.102: Q156.2 201.86,144.61 202.05,144.8 C1331.1 202.05,145.42 R5581.2 201.09,145.42 200.97,145.54 v1(199.88,145.54)
N25769445: length 3.6
  TOP w0.102: U1.1 94.32,90.85 R28.2 95.24,90.85 R32.2 95.24,91.85 v1(95.08,92.01)
N25827471: length 3.3
  TOP w0.102: U9.4 150.08,73.47 150.31,73.71 150.31,74.77 R335.2 v1(149.15,74.87)
N26062000: length 5.4
  TOP w0.102: R506.2 200.03,163.63 R405.2 v2(200.03,165.28) v1(200.03,165.97)
  BOTTOM w0.102: v2(200.03,165.28) 200.4,164.91 200.4,163.76 200.24,163.6 JWLN1.51
N26145701: length 5.3
  BOTTOM w0.102: R675.2 195.35,52.6 193.77,52.6 v1(193.75,52.58)
  BOTTOM w0.254: Q99.2 197.17,52.97 196.75,52.55 C607.1 196.44,52.13 196.44,52.13 R675.2
N26145913: length 13
  BOTTOM w0.254: Q100.1 192.71,57.36 192.32,56.97 189.89,56.97 189.66,56.74 v1(189.66,55.83) 189.66,54.9 191.69,52.86 R568.2 191.69,52.13 R675.1
N26456136: length 3.6
  TOP w0.089: T23.1 48.48,111.93 v2(49.18,111.93)
  BOTTOM w0.089: v2(49.18,111.93) 49.76,111.35 51.11,111.35 JCPU1.AR32
N26485616: length 2
  TOP w0.102: v1(73.85,35.16) 74.05,35.36 R45.1
  TOP w0.508: R45.1 74.86,35.37 C37.2
N26486894: length 2
  TOP w0.102: v1(30.69,55.85) 30.78,55.94 C39.2
  TOP w0.508: C39.2 R54.1
N26487339: length 2
  TOP w0.102: C40.2 31.84,43.18 v1(31.74,43.09)
  TOP w0.508: C40.2 32.75,44.16 R59.1
N26542098: length 14.4
  TOP w0.102: R623.2 149.68,2.81 147.96,1.09 v1(146.43,1.09) 143.69,1.09 LED1.2
N26542118: length 10.1
  TOP w0.102: R764.2 v1(152.35,7.71) 152.35,6.31 150.78,4.74 150.78,3.13 151.16,2.75 152.54,2.75 LED2.2
N26555073: length 2
  TOP w0.102: v1(157.53,58.42) 157.53,58.41 CA7.2 159.52,58.41 RA21.1
N26597830: length 20.6
  TOP w0.102: LED6.2 162.33,2.45 v1(158.52,2.45) 150.95,2.45 150.39,3.01 150.39,4.82 151.45,5.89 R303.2
N26629490: length 11.3
  TOP w0.102: v2(36.75,26.22) 36.58,26.06 UL1.3 ; v1(43.84,28.13) 43,27.3 RL6.2 42.96,26.93 RL7.2 41.25,26.93 RL9.2 40.76,26.92 40.49,26.65 v2(40.49,26.34)
  BOTTOM w0.102: v2(40.49,26.34) 39.86,26.97 37.5,26.97 v2(36.75,26.22)
N26736976:
  vias: v1(152.9,87.86)
N26737023: length 0.4
  TOP w0.102: 145.94,84.93 v1(145.94,84.5)
N26853750: length 2.2
  BOTTOM w0.102: C4.1 v1(86.57,144.18)
  BOTTOM w0.508: U72.4 C4.1
N26857011: length 4.3
  TOP w0.102: v2(9.7,113.59) 9.24,114.04 v1(9.24,114.61) 9.24,115.05 9.37,115.17 C6.1
  BOTTOM w0.102: v2(9.7,113.59) 9.76,113.59 10.14,113.97 U10.8
N27500400: length 3.8
  TOP w0.102: T3.1 160.78,44.79 159.62,45.95 159.62,47.09 159.44,47.27 UA1.1
N28570922: length 2.5
  TOP w0.102: JLVDS1.6 99.14,150.34 99.8,150.34 R39.2
N28572861: length 2.4
  BOTTOM w0.102: JWLN1.1 197.94,140.4 197.72,140.18 196.86,140.18 R41.2
N29040315: length 5
  TOP w0.102: U31.98 162.79,73.74 162.49,73.44 161.35,73.44 v1(160.83,72.92) 160.26,72.35 R406.1
N29503322: length 3.7
  TOP w0.102: Q116.1 111.64,53.12 R659.2 v1(109.97,55.12)
N35039154:
  vias: v2(98.25,164.53)
N36335803: length 9.6
  BOTTOM w0.102: v1(153.37,125.56) RV44.1 148.52,126.67 148.21,126.37 146.36,126.37 145.85,126.87 UV1.AM39
N36492944: length 1
  BOTTOM w0.102: CV42.2 RV34.1
N36493087: length 1
  BOTTOM w0.102: CV41.2 RV33.1
N36493316: length 11.8
  IN2 w0.102: v2(143.94,149.22) 145.18,149.22 146.73,147.67 148.49,147.67 150.02,149.21 150.02,149.41 150.4,149.79 152.27,149.79 v2(152.64,150.16)
  BOTTOM w0.102: v2(143.94,149.22) 144.19,149.47 UV1.AK10 ; CV42.1 153.08,150.16 v2(152.64,150.16)
N36493324: length 11.3
  IN2 w0.102: v2(152.06,150.2) 150.52,150.2 149.81,149.5 149.81,149.31 148.38,147.88 146.87,147.88 v2(144.88,149.87)
  BOTTOM w0.102: CV41.1 152.53,149.45 152.06,149.93 v2(152.06,150.2) ; UV1.AL10 145.25,149.49 v2(144.88,149.87)
N36581302: length 8.1
  TOP w0.102: v2(147.1,139.47) 147.11,139.48 v1(148.94,139.48) 148.98,139.48 149.7,138.76 RV12.2
  BOTTOM w0.102: v2(147.1,139.47) 147.21,139.58 147.21,140.27 146.46,141.02 146.46,141.1 146.46,141.1 146.46,141.44 146.46,141.44 146.46,141.53 145.7,142.3 145.7,143.31 UV1.AM17
N36581441: length 1.8
  TOP w0.102: v1(138.45,130.1) 138.45,130.08 138.06,130.48 v2(138.05,130.48) 138.14,130.56 RV11.1
  BOTTOM w0.102: UV1.AB34 v2(138.05,130.48)
N36775625: length 4.1
  TOP w0.102: RV3.1 134.08,132.76 134.08,132.84 134.31,133.07 v1(136.13,133.07) 136.31,133.07 v2(136.8,133.56)
  BOTTOM w0.102: v2(136.8,133.56) 136.5,133.87 UV1.Y29
N36775642: length 5.5
  TOP w0.102: v2(136.85,132.93) 136.1,132.18 135.47,132.18 135.33,132.04 v1(134.98,132.04) 133.52,132.04 133.37,132.18 132.93,132.18 RV1.1
  BOTTOM w0.102: v2(136.85,132.93) 136.7,133.07 UV1.Y30
N36777317: length 25.2
  IN2 w0.102: 152.86,148.83 151.4,148.83 150.72,148.15 150.72,147.81 151.3,147.23 151.3,146.85 150.66,146.21 148.54,146.21 147.99,145.66 144.81,145.66 v2(143.26,144.11)
  IN2 w0.127: v2(156.57,153.21) 156.57,151.06 157.36,150.26 157.36,149.18 157.01,148.83 152.86,148.83
  BOTTOM w0.102: v2(156.57,153.21) RV2.1 v1(155.77,155.16) ; v2(143.26,144.11) 142.85,144.52 UV1.AH16
N36816710: length 6
  TOP w0.102: QV8.2 RV38.2 CV52.1 150.36,121.85 150.17,121.66 v1(147.52,121.66)
N36841309: length 7.4
  TOP w0.102: RV47.2 135.73,136.41 135.48,136.65 131.93,136.65 v1(131.82,136.55) 131.73,136.46 131.55,136.46 v2(131.3,136.2)
  BOTTOM w0.102: v2(131.3,136.2) 130.78,136.2 130.25,135.67 UV1.M27
N38004471:
  vias: v1(145.31,147.33)
N38105566: length 4.8
  BOTTOM w0.102: UV6.L8 112.37,134.39 115.48,134.39 v1(115.55,134.46) 115.68,134.59 RV85.1
N38105572: length 8.8
  TOP w0.102: v1(101.32,133.42) 101.77,133.42 103.64,131.56 RV84.1 103.66,131.55 104.52,131.55 105.22,132.25 105.22,133.5 106.13,134.41 106.86,134.41 UV5.L8
N38105577: length 3.2
  TOP w0.102: RV60.2 RV61.2 CV195.1 102.71,139.15 v1(102.6,139.27)
N38190157: length 6.1
  TOP w0.102: RV86.1 115.16,147.7 v1(115.16,148.35) 115.16,149.21 114.1,150.27 113.24,150.27 112.88,149.92 112.38,149.92 UV7.L8
N38190161: length 5.5
  BOTTOM w0.089: 105.29,149.85 106.15,150.71 106.8,150.71 UV8.L8
  BOTTOM w0.102: 105.29,149.85 105.18,149.73 104.05,149.73 RV87.1 v1(102.5,150.23)
N38194049: length 2.9
  TOP w0.102: v1(101.72,148.61) 102.24,149.14 CV196.1 102.66,149.15 RV69.2 RV66.2
N38198198: length 4.4
  BOTTOM w0.102: RV90.1 147.61,172.59 147.86,172.34 147.86,171.35 147.5,170.99 UV11.L8
N38198202: length 9.2
  TOP w0.102: v1(142.53,160.87) 142.49,160.91 RV91.1 142.49,161.87 142.92,162.3 143.42,162.3 144.67,163.56 147.06,163.56 147.44,163.94 147.44,164.77 147.11,165.1 147.11,165.59 147.49,165.97 UV12.L8
N38199303: length 2.8
  TOP w0.102: RV79.2 RV81.2 145.87,175.78 CV198.1 v1(144.04,175.78)
N38203425: length 7.3
  BOTTOM w0.102: UV10.L8 130.58,165.56 130.58,164.78 131.95,163.41 RV89.1 132.4,161.36 133.92,161.36 v1(134.09,161.54)
N38203429: length 10.3
  TOP w0.102: UV9.L8 130.53,171.13 130.53,171.71 128.81,173.43 126.33,173.43 125.98,173.78 RV88.1 125.98,175.22 126.11,175.35 127.55,175.35 127.95,175.74 v1(127.95,175.96)
N38203433: length 2.7
  TOP w0.102: v1(135.17,175.79) CV197.1 133.33,175.79 RV72.2 RV73.2
N38212508: length 9.1
  TOP w0.254: QV2.1 134.65,106.16 134.98,105.83 135.77,105.83 136.02,106.07 v1(136.02,106.41) 136.02,106.86 135.87,107.01 135.15,107.01 RV41.1 134.37,107.78 RV42.2 134.35,108.79 CV53.1 UV4.4
N38212553: length 7.1
  TOP w0.254: RV39.1 128.66,110.89 v1(127.95,110.89) 127.57,110.89 127.16,110.49 QV1.1
N39986171: length 5.1
  TOP w0.102: RV38.1 152.14,121.58 152.33,121.39 RV37.2 153.24,121.75 v1(153.91,121.75) 154.64,121.75 154.68,121.71 155.38,121.71 155.48,121.81 QV6.1
N39986251: length 5.7
  TOP w0.102: RV36.2 155.76,116.7 157.84,116.7 158.08,116.94 QV7.1 158.86,117.76 v1(159.71,116.91)
N42328962: length 4
  BOTTOM w0.102: R435.2 101.91,138 v1(102.24,137.67)
  BOTTOM w0.254: C520.1 100.13,138 R435.2 101.11,138 Q83.2
N48539214: length 3.7
  TOP w0.102: R589.2 C660.1 181.05,81.43 181.82,81.43 181.93,81.32 v1(181.93,80.03)
N57698799: length 12.2
  TOP w0.102: R765.2 150.57,5.51 150.04,4.98 150.04,2.93 150.75,2.22 152.56,2.22 LED5.2 153.88,1.6 v1(154.38,1.1)
N61785845: length 3.4
  TOP w0.203: CA29.1 153.02,53.45 153.02,52.78 v1(153.13,52.66) 153.13,52.69 153.56,52.26 154.37,52.26 154.65,51.98 UA1.20
N61785847: length 7.5
  TOP w0.102: CA29.2 152.76,55.59 153.32,56.14 v1(153.32,57.45)
  TOP w0.203: UA1.19 155.05,52.05 154.51,52.59 153.75,52.59 153.44,52.91 153.44,54.43 CA29.2
N61785857: length 8
  TOP w0.102: v1(148.75,55.38) 149.92,54.21 CA30.2
  TOP w0.203: UA1.21 153.96,51.39 153.19,52.16 152.7,52.16 152.62,52.24 152.62,52.73 152.09,53.26 152.09,53.78 151.67,54.2 CA35.1 149.98,54.2 CA30.2
N61786084: length 2.8
  TOP w0.102: CA26.2 159.7,52.96 158.95,52.21 158.5,52.21 158.25,51.95 UA1.11
N61786096: length 3.6
  TOP w0.102: UA1.6 159.59,49.27 160,49.68 160.51,49.68 160.81,49.37 161.27,49.37 RA9.2
N62096303: length 3.6
  TOP w0.102: v2(96.91,42.93) 96.78,43.06 R93.2 v1(96.78,44.85)
  BOTTOM w0.102: v2(96.91,42.93) 96.91,42.92 JDIMM2.201
N68070790: length 3.4
  TOP w0.102: UT2.8 82.66,128.48 RT8.2 v1(81.39,126.22)
N293979640: length 2.9
  TOP w0.254: v1(106.28,33.83) 106.41,33.7 PR711.1 105.83,32.21 PU701.6
N293979960: length 2.8
  TOP w0.254: PU701.15 101.35,32.21 v1(100.54,31.4) 99.97,30.83 PR712.1

## Copper pours and planes (outline as drawn)
1.05VSP_B+ on TOP (solid shape): 116.41,36.37 118.16,36.37 118.85,35.67 118.85,28.12 118.47,27.73 113.3,27.73 112.99,28.05 112.99,36.88 113.56,37.45 115.32,37.45
1.35V_B+ on TOP (solid shape): 58.53,5.19 58.53,4.43 57.3,3.2 57.3,1.88 56.99,1.57 55.66,1.57 55.43,1.8 55.43,4.95 55.86,5.38 58.34,5.38
1.35V_B+ on BOTTOM (solid shape): 55.26,7.2 55.26,6.6 55.64,6.22 58.56,6.22 58.7,6.07 58.7,2.56 58.2,2.06 50.92,2.06 50.42,2.55 50.42,7.15 50.61,7.34 55.12,7.34
1.35V_SN on BOTTOM (solid shape): 46.29,4.68 46.29,2.53 46.13,2.37 45.41,2.37 45.22,2.56 45.22,3.51 45.09,3.64 44.29,3.64 44.17,3.76 44.17,5 44.38,5.21 45.76,5.21
3V_SN on TOP (solid shape): 70.58,13.87 70.58,12.23 70.39,12.04 68.5,12.04 68.3,12.24 68.3,13.07 69.15,13.92 70.53,13.92
3V_VIN on TOP (solid shape): 65.5,9.69 65.5,7.8 65.44,7.75 64.12,7.75 63.76,7.38 63.76,6.67 64.14,6.28 64.14,5.17 64.02,5.04 62.19,5.04 61.82,5.41 61.82,9.48 62.11,9.78 65.41,9.78
3V_VIN on BOTTOM (solid shape): 63.79,9.09 63.79,7.47 63.72,7.4 63.72,6.68 63.9,6.5 63.9,5.18 63.79,5.06 63.35,5.06 62.7,4.41 61.01,4.41 60.8,4.61 60.8,5.27 61.84,6.31 61.84,9.09 61.97,9.22 63.66,9.22
3VALW_EN on TOP (solid shape): 68.22,6.97 68.22,5.89 68.04,5.71 67.14,5.71 66.97,5.88 66.97,7.02 67.06,7.11 68.08,7.11
3VALW_EN on BOTTOM (solid shape): 68.61,5.99 68.61,4.4 68.47,4.26 66.94,4.26 66.8,4.4 66.8,4.77 67.14,5.12 67.14,6.09 67.24,6.19 68.41,6.19
5V_VCC on TOP (solid shape): 101.01,8.57 101.01,7.94 100.7,7.63 100.7,7.41 100.52,7.23 100.32,7.23 100.15,7.4 100.15,7.71 100.01,7.86 100.01,8.54 100.07,8.61 100.97,8.61
5V_VIN on TOP (solid shape): 99.19,5.26 99.19,4.34 99.07,4.21 95.63,4.21 95.44,4.41 95.44,5.52 95.73,5.81 98.64,5.81
5V_VIN on BOTTOM (solid shape): 98.96,5.61 99.79,5.61 99.91,5.72 100.92,5.72 100.92,3.76 100.85,3.68 93.92,3.68 93.72,3.88 93.72,5.96 94.3,6.54 98.03,6.54
+0.95VGS on TOP (solid shape): 158.53,127.56 158.53,126.15 158.41,126.03 155.4,126.03 155.29,126.14 155.29,127.61 155.35,127.68 158.41,127.68
+0.95VGS on TOP (solid shape): 150.71,132.81 150.71,132.22 150.56,131.98 150.63,131.72 150.66,131.65 150.63,131.58 150.54,131.31 150.71,131.07 150.71,130.96 150.6,130.86 149.21,130.86 149.06,131.01 148.24,131.01 148.11,131.14 148.11,132.65 148.17,132.72 148.78,132.72 149.11,133.04 150.48,133.04
+0.95VGS on TOP (solid shape): 133.34,135.86 133.44,135.87 134.04,135.87 134.29,135.63 134.29,133.77 134.14,133.55 134.2,133.29 134.22,133.26 134.07,133.1 133.53,133.1 133.44,133.16 133.45,133.27 133.19,133.8 132.94,133.27 132.95,133.16 132.86,133.1 132.28,133.1 132.19,133.16 132.2,133.27 131.95,133.81 131.69,133.27 131.71,133.16 131.62,133.1 126.02,133.1 125.75,133.38 125.75,133.56 125.75,133.57 125.75,133.93 126.11,134.28 127.07,134.28 127.18,134.4 127.21,134.4 127.49,134.49 127.58,134.77 127.58,134.79 127.87,135.09 132.03,135.09 132.04,135.05 132.53,134.89 132.59,135.41 132.56,135.48 132.59,135.55 132.91,135.87 133.25,135.87
+0.95VGS on BOTTOM (solid shape): 148.45,132.56 148.45,131.93 148.41,131.92 148.2,131.67 148.41,131.42 148.45,131.41 148.45,130.6 148.1,130.24 145.19,130.24 144.68,129.74 144.38,129.74 144.17,129.94 144.17,130.69 144.42,130.94 144.61,131.13 147.03,131.13 147.22,131.32 147.22,131.57 146.6,132.19 146.6,132.34 146.95,132.7 148.32,132.7
+0.95VGS on BOTTOM (solid shape): outline of 345 points within 125.38,132.02 134.14,135.16
+0.95VGS on VCC: 130.56,126.03 128.79,127.81 126.26,127.81 125.96,128.11 125.96,133.64 126.94,134.62 143.3,134.62 144.74,133.17 158.22,133.17 158.48,132.91 158.48,126.52 157.99,126.03
+0.95VGSP on TOP (solid shape): 166.49,131.24 166.49,129.18 166.25,128.94 159.94,128.94 158.82,127.82 157.91,127.82 157.85,127.87 157.85,128.34 157.81,128.39 155.9,128.39 155.9,127.9 155.84,127.84 155.32,127.84 155.18,127.98 155.18,131.18 155.54,131.54 166.18,131.54
+0.95VGSP on BOTTOM (solid shape): 162.77,131.26 162.77,126.59 162.4,126.23 160.34,126.23 159.94,126.62 159.94,131.31 160.22,131.58 162.45,131.58
+0.675VS on TOP (solid shape): 32.48,15.51 32.48,13.49 32.37,13.38 29.75,13.38 29.56,13.57 29.56,15.17 29.99,15.59 32.4,15.59
+0.675VS on TOP (solid shape): 99.24,56.4 99.24,54.22 98.76,53.48 99.24,52.75 99.24,50.81 99.71,50.35 99.71,45.25 98.79,44.33 98.79,40.67 98.78,40.66 98.76,40.48 98.78,40.31 98.79,40.3 98.79,35.76 98.48,35.45 97.66,35.45 97.37,35.75 97.37,44.08 97.2,44.25 97.2,56.34 97.54,56.69 98.96,56.69
+0.675VS on BOTTOM (solid shape): 98.6,37.35 98.6,35.48 98.45,35.33 97.74,35.33 97.63,35.44 97.63,37.4 97.72,37.49 98.46,37.49
+0.675VS on BOTTOM (solid shape): 98.77,50 98.98,49.8 98.98,48.63 98.66,48.32 97.76,48.32 97.62,48.46 97.62,50.35 97.71,50.44 98.33,50.44
+0.675VS on BOTTOM (solid shape): 98.33,58.45 98.33,55.39 98.04,55.09 97.41,55.09 97.15,55.35 97.15,56.36 97.34,56.55 97.34,58.51 97.42,58.59 98.19,58.59
+0.675VS on BOTTOM (solid shape): 97.84,45.51 97.84,42.24 97.74,42.13 97.6,42.13 97.6,42.18 97.53,42.48 97.33,42.71 97.33,45.53 97.43,45.63 97.71,45.63
+0.675VS on IN1 (solid shape): 33.99,15.65 33.99,13.8 33.59,13.4 29.79,13.4 29.41,13.78 29.41,15.67 29.68,15.94 33.7,15.94
+0.675VS on IN1 (solid shape): 98.83,36.99 98.83,35.27 98.6,35.04 96.44,35.04 96.12,35.35 96.12,36.69 96.55,37.12 98.7,37.12
+0.675VSP on TOP (solid shape): 35.78,14.37 35.78,10.91 35.03,10.15 35.03,8.96 34.69,8.62 33.92,8.62 33.87,8.67 33.87,8.82 33.94,8.89 34.52,8.89 34.67,9.04 34.67,10.47 34.44,10.7 33.74,10.7 33.33,11.12 33.33,12.67 32.65,13.34 32.65,13.75 32.73,13.83 33.17,13.83 33.21,13.87 33.21,15.15 33.15,15.22 32.71,15.22 32.66,15.27 32.66,15.55 32.73,15.62 34.53,15.62
+1.05V_+1.5V_RUN on BOTTOM (solid shape): 115.4,87.67 115.4,87.53 115.34,87.53 115.34,86.77 115.4,86.77 115.4,85.56 115.65,85.31 115.65,84.76 115.48,84.59 114.67,84.59 114.29,84.97 114.29,87.73 114.37,87.82 115.25,87.82
+1.05V_+1.5V_RUN on BOTTOM (solid shape): outline of 321 points within 122.99,75.61 124.77,83.57
+1.05V_+1.5V_RUN on IN1 (solid shape): 125.08,81.11 125.11,81.04 125.08,80.97 124.98,80.73 125.12,80.43 125.09,80.35 124.99,80.08 125.16,79.84 125.16,79.44 125.05,79.33 124.72,79.33 124.63,79.42 124.63,80.12 124.54,80.22 124.53,80.23 124.38,80.42 124.12,80.44 124.12,80.44 124,80.44 123.93,80.5 123.93,81.05 124.06,81.18 125.01,81.18
+1.05V_+1.5V_RUN on IN1 (solid shape): outline of 349 points within 119.54,86.88 122.54,90.48
+1.5VGS on TOP (solid shape): 106.7,161.16 106.7,159.74 106.45,159.49 104.92,159.49 104.83,159.58 103.71,159.58 103.51,159.78 103.51,161.16 103.72,161.37 106.49,161.37
+1.5VGS on TOP (solid shape): 106.7,161.16 106.7,159.74 106.45,159.49 104.92,159.49 104.83,159.58 103.22,159.58 103.07,159.73 103.07,161.17 103.26,161.37 106.49,161.37
