# Allegro board IBM-Lenovo G410 G510 COMPAL LA-9641P BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_GPIO49: length 9.9
  TOP w0.089: U4.AK3 123.15,93.66 122.84,93.97 122.84,94.28 122.97,94.41 122.97,95.58 122.84,95.71 122.84,96.24 122.4,96.69
  TOP w0.102: R281.1 v2(121.72,101.81) 121.9,101.63 121.9,97.94 122.4,97.44 v1(122.4,97.23) 122.4,96.69
PCH_GPIO52: length 5.6
  TOP w0.089: U4.B13 134.94,88.77 135.72,88.77 135.81,88.68 v1(137.08,88.68) 137.26,88.5 137.71,88.5 137.89,88.33 137.96,88.33
  TOP w0.102: v2(139.15,88.83) 138.98,88.83 138.48,88.33 137.96,88.33
  BOTTOM w0.102: RP13.2 139.07,88.76 v2(139.15,88.83)
PCH_GPIO53: length 3.2
  TOP w0.089: U4.A10 137.93,90.1
  TOP w0.102: T21.1 138.1,90.1 137.93,90.1
PCH_GPIO56: length 6.6
  TOP w0.089: U4.U4 128.43,93.22 128.15,93.5 128.15,93.78 128.36,93.99 128.36,94.31 128.58,94.54 128.58,96.05 v2(128.51,96.12)
  BOTTOM w0.102: v2(128.51,96.12) 128.52,96.14 128.52,98.19 R191.2
PCH_GPIO57: length 5
  TOP w0.102: v2(128.73,89.49) 128.45,89.21 U4.U12
  BOTTOM w0.102: v2(128.73,89.49) 128.14,90.08 128.14,91.14 127.9,91.38 v1(127.71,91.38) 127.3,91.79 R272.2
PCH_GPIO60: length 2.7
  TOP w0.102: U4.N8 129.87,91.34 v2(129.73,91.34)
  BOTTOM w0.102: v2(129.73,91.34) 130.12,91.73 130.12,92.19 130.03,92.27 R221.2
PCH_GPIO67: length 3.8
  TOP w0.102: U4.F39 133.41,77.91 v2(133.22,77.72)
  BOTTOM w0.102: R282.2 134.37,75.64 R277.1 133.13,75.96 v1(133.13,76.72) 133.13,77.63 v2(133.22,77.72)
PCH_GPIO69: length 25.4
  TOP w0.089: v2(134.01,87.92) 133.97,87.97 U4.D13
  TOP w0.102: R279.2 138.64,77.72 v2(138.88,77.48) 140.38,77.48 R276.1
  IN1 w0.089: v2(134.01,87.92) 132.23,87.92 132.01,87.7 132.01,87.37 132.39,86.98 132.39,86.43 132.12,86.15 131.74,86.15 131.55,85.96 131.07,85.96 130.86,85.75 130.86,85.31 131.24,84.93 133,84.93 133.79,84.14 135.94,84.14 136,84.08 136.57,84.08 136.75,83.91 136.76,83.91
  IN1 w0.127: 136.76,83.91 137.43,83.91 137.61,83.73 138.46,83.73 139.45,82.74 139.45,78.05 v2(138.88,77.48)
  BOTTOM w0.102: v2(138.88,77.48) v1(138.88,78.17)
PCH_GPIO70: length 30.1
  TOP w0.089: v2(137.36,74.89) 137.79,75.32 137.79,77.1 137.96,77.27 ; v2(132.41,88.52) 132.41,88.69 132.76,89.03 U4.G13
  TOP w0.102: R287.1 140.31,80.68 139.14,80.68 R289.2 138.2,79.73 138.2,77.51 137.96,77.27
  IN1 w0.089: 136.76,75.17 136.76,75.99 135.76,76.99 135.76,82.43 134.23,83.96 133.72,83.96 132.93,84.76 130.69,84.76 130.13,85.32 130.13,86.71 130.56,87.14 131.68,87.14 131.83,87.28 131.83,87.93 v2(132.41,88.52)
  IN1 w0.127: v2(137.36,74.89) 137.04,74.89 136.76,75.17
  BOTTOM w0.089: v1(133.14,88.03) 132.89,88.03 v2(132.41,88.52)
PCH_GPIO71: length 22.1
  TOP w0.089: U4.H15 132.18,87.74 v2(132.37,87.55)
  TOP w0.102: R288.2 139.1,79.59 140.39,79.59 R286.1 140.81,78.77 141,78.58 v2(141.28,78.58)
  IN1 w0.089: 136.76,84.82 136.46,84.82 136.39,84.88 135.74,84.88 135.22,84.36 133.84,84.36 133.02,85.18 131.87,85.18 131.62,85.43 131.62,85.75 131.82,85.95 132.16,85.95 132.57,86.36 132.57,87.35 v2(132.37,87.55)
  IN1 w0.127: v2(141.28,78.58) 141.28,79.91 140.11,81.08 140.11,82.56 138.69,83.98 137.85,83.98 137.01,84.82 136.76,84.82
  BOTTOM w0.102: v2(141.28,78.58) v1(141.28,77.98)
PCH_GPIO72: length 7.6
  TOP w0.089: 131.5,91.6 v2(131.66,91.43)
  TOP w0.102: U4.K7 131.5,91.6
  BOTTOM w0.102: v2(131.66,91.43) 131.66,91.44 131.19,91.91 131.19,92.2 131.53,92.53 131.53,92.99 131.24,93.27 v1(131.24,93.73) 131.02,93.95 131.02,95.61 131.81,96.4 131.81,97.11 131.82,97.11 RP10.7
PCH_GPIO73: length 6.6
  TOP w0.089: U4.AB1 126.13,94.4 126.13,95.4 126.33,95.6 126.33,96.41 126.6,96.68 126.6,97.07
  TOP w0.102: 126.6,97.07 126.6,98.81 R181.1 125.84,99.15 v1(125.34,99.64)
PCH_HOT#: length 12.7
  TOP w0.089: U4.H6 132.28,92.19 132.67,91.81 v2(133.12,91.81)
  TOP w0.102: v1(137.64,99.54) 137.79,99.39 v2(137.79,97.75) 137.56,97.75 R222.2
  IN1 w0.089: 134.35,94.79 133.08,93.51 133.08,91.84 v2(133.12,91.81)
  IN1 w0.127: v2(137.79,97.75) 136.02,97.75 135,96.72 135,96.19 134.7,95.9 134.7,95.14 134.35,94.79
PCH_INTVRMEN: length 3.2
  TOP w0.102: v2(132.48,90.45) 132.78,90.16 U4.G10
  BOTTOM w0.089: v1(132.94,90.98) 132.71,90.98 132.48,90.75
  BOTTOM w0.102: R97.2 134.25,91 134.18,90.93 133.74,90.93 133.69,90.98 v1(132.94,90.98) ; 132.48,90.75 v2(132.48,90.45)
PCH_JTAG_TCK: length 7.7
  TOP w0.089: 126.87,97.07 126.87,96.7 126.51,96.34 126.51,95.68 126.94,95.25 126.94,94.56 126.72,94.33 126.72,94.04 126.4,93.72 U4.AB3
  TOP w0.102: v3(128.01,99.88) 127.97,99.88 128.01,99.84 128.01,99.44 127.39,98.82 R110.1 126.87,97.77 126.87,97.07
PCH_JTAG_TDI: length 5
  TOP w0.089: U4.AE2 125.3,93.77 125.3,94.25 125.6,94.54 125.6,95.35 124.99,95.95 124.99,96.07 v3(124.82,96.24) 124.55,96.51 124.55,96.65 v2(124.44,96.76) 124.44,96.77 124.44,96.85
  TOP w0.102: 124.44,96.85 124.44,97.3 R124.1
  BOTTOM w0.102: R121.2 124.47,96.79 v2(124.44,96.76)
PCH_JTAG_TDO: length 6.2
  TOP w0.089: U4.AD3 125.59,93.72 125.95,94.08 125.95,95.5 125.39,96.05 125.39,96.72 v2(125.34,96.77) 125.34,96.85
  TOP w0.102: v1(126.27,97.65) 126.02,97.39 R122.1 125.34,96.85
  BOTTOM w0.102: R119.2 v2(125.34,96.77)
PCH_JTAG_TMS: length 9.3
  TOP w0.089: 124.86,96.74 125.17,96.43 125.17,96.02 125.77,95.42 125.77,94.31 U4.AD1
  TOP w0.102: v2(125.01,100.52) 125.01,99.31 124.86,99.16 124.86,96.74 ; v2(125.01,100.52) 125.55,101.06 125.55,101.22 v3(125.64,101.31) ; v2(125.01,100.52) 124.99,100.54 R123.1
  BOTTOM w0.102: v2(125.01,100.52) 124.99,100.55 R311.2
PCH_PCIE_RCOMP: length 4.4
  TOP w0.305: R244.2 113.98,82.54 v1(114.36,82.17) 114.89,81.63 115.62,81.63 116.35,82.37 117.11,82.37 U4.BD29
PCH_PECI_R: length 8.7
  TOP w0.089: 114.28,96.85 114.28,96.07 114.54,95.82 117.59,95.82 118.42,94.99 118.42,94.99 118.64,94.77 118.64,94.77 119.07,94.34 U4.AY1
  TOP w0.102: v1(113.24,98.64) 113.24,98.49 114.28,97.44 R255.1 114.28,96.85
PCH_PWM: length 140.3
  TOP w0.102: UT2.16 87.5,127.19 87.59,127.11 89.41,127.11 v2(89.44,127.07) ; U4.N36 130.48,78.96 v2(130.66,78.96)
  IN1 w0.089: 131.9,74.85 131.15,75.6 131.15,78.47 v2(130.66,78.96) ; v2(79.1,112.43) 79.53,112 83.33,112 84.81,110.53 84.81,103.44 85.85,102.4 85.85,99.76 86.58,99.02 87.23,99.02
  IN1 w0.127: 87.23,99.02 90.56,99.02 91.3,99.76 99.12,99.76 100.05,98.83 104.27,98.83 105.81,97.29 108.23,97.29 108.98,96.54 110.56,96.54 110.81,96.29 110.81,95.25 109.27,93.7 109.27,68.7 114.94,63.03 129.4,63.03 130.6,64.23 130.6,70.69 131.49,71.57 132.75,71.57 133.69,72.51 133.69,73.8 133.39,74.1 132.65,74.1 131.9,74.85
  BOTTOM w0.089: v2(79.1,112.43) 79.1,114.36 80.74,116
  BOTTOM w0.102: v2(89.44,127.07) v3(89.44,124.93) 89.44,120.11 87.17,117.84 82.58,117.84 80.74,116
PCH_PWR_EN: length 40.1
  TOP w0.102: v2(164.54,62.93) 165.59,63.98 v1(165.59,65.52) 165.59,69.91 165.32,70.18 165.32,72.72 166.39,73.78 U31.107 ; v2(154.9,77.84) 155.37,78.31 R38.1
  IN2 w0.127: v2(154.21,63.03) 164.43,63.03 v2(164.54,62.93)
  BOTTOM w0.102: v2(154.9,77.84) 154.9,76.15 153.74,74.99 153.74,67.26 154.6,66.39 154.6,63.42 v2(154.21,63.03)
PCH_PWROK: length 110.6
  TOP w0.089: v2(126.79,91.37) 126.56,91.6 U4.AB7
  TOP w0.102: v2(133.08,90.45) 133.37,90.16 U4.F10 ; U31.32 R608.1 178.81,89.94 178.71,90.04 v2(178.71,90.87)
  IN1 w0.089: v2(133.08,90.45) 133.73,90.45 134.74,91.46 134.74,93.51 135.91,94.68 135.91,94.79 ; v2(126.79,91.37) 126.79,91.38 126.38,91.79 126.38,93.56 125.96,93.97 125.96,94.79
  IN1 w0.127: 135.91,94.79 135.91,94.99 136.41,95.5 137.6,95.5 137.82,95.29 138.54,95.29 139.13,95.87 139.13,98.77 137.76,100.13 v2(137.76,105.1) ; v2(179.22,96.06) 179.22,91.98 178.71,91.48 v2(178.71,90.87) ; v2(125.97,96.12) 125.96,96.12 125.96,94.79
  IN2 w0.127: v2(120.7,100.38) 122.09,100.38 123.36,101.65 125.99,101.65 128.66,104.32 129.98,104.32 130.76,105.1 v2(137.76,105.1) 147.54,105.1 149.67,102.98 154.19,102.98 159.25,97.92 177.36,97.92 v2(179.22,96.06) ; v2(125.97,96.12) 122.65,96.12 v2(122.12,95.59)
  BOTTOM w0.102: v2(122.12,95.59) 122.51,95.99 122.51,96.47 121.85,97.13 121.85,98 121.51,98.34 121.13,98.34 120.71,98.77 120.71,99.23 120.7,99.24 U6.2 v2(120.7,100.38) ; v2(137.76,105.1) v1(137.76,104.4)
PCH_RTCRST#: length 5.6
  TOP w0.089: v2(136.23,90.66) 136.19,90.62 135.15,90.62 134.97,90.8 134.72,90.8 134.43,90.51 U4.D9
  BOTTOM w0.102: C115.1 138.28,89.68 R99.2 138.28,90.75 CLRP3.1 136.32,90.75 v2(136.23,90.66)
PCH_RTCX1: length 9.9
  TOP w0.089: v2(137.23,96.5) 137.31,96.58 137.96,96.58
  TOP w0.102: 137.96,96.58 138.41,96.58 R95.1 138.64,96.35 138.64,95.53 R689.1 ; U4.B5 134.61,92.06 133.97,92.06 133.85,91.94 v2(133.85,91.93)
  IN2 w0.089: v2(133.85,91.93) 134.83,91.93 135.36,92.47 135.36,94.13 135.97,94.74 135.97,94.79
  IN2 w0.127: v2(137.23,96.5) 137.23,96.36 135.97,95.11 135.97,94.79
PCH_RTCX2: length 12.7
  TOP w0.089: U4.B4 134.27,92.36 133.56,92.36 v2(133.5,92.43)
  TOP w0.102: Y1.2 140.21,98.13 C112.1 138.63,97.28 R95.2 138,97.27 v2(137.81,97.09)
  IN1 w0.089: 135.36,94.79 135.36,94.47 133.5,92.61 v2(133.5,92.43)
  IN1 w0.127: v2(137.81,97.09) 136.95,97.09 136.67,96.81 136.67,96.33 136.47,96.12 136.25,96.12 135.36,95.23 135.36,94.79
  BOTTOM w0.102: v2(137.81,97.09) 138.35,97.63 v1(138.35,97.66)
PCH_SMBCLK: length 35.1
  TOP w0.102: U4.R10 129.41,90.4 v2(129.73,90.72)
  IN2 w0.089: v2(129.73,90.72) 129.29,90.28 129.29,89.99 129.38,89.9 129.38,89.17 130.11,88.45 130.11,82.18 130.03,82.11 130.03,81.44 131.43,80.04 131.43,75.41 131.97,74.86
  IN2 w0.127: v2(134.78,74.11) 134.68,74 132.84,74 131.97,74.86
  BOTTOM w0.102: v2(134.78,74.11) 134.61,73.93 134.31,73.93 134.08,73.71 134.08,73.2 134.4,72.88 134.59,72.88 134.6,72.88 135.05,72.88 135.05,72.89 136.16,74 v4(137.13,74) 138.07,74 138.86,74.79 139.3,74.79 139.52,74.57 Q11.6 139.52,72.6 139.81,72.31 140.96,72.31 142.64,73.99 RP16.5
PCH_SMBDATA: length 35.3
  TOP w0.102: v2(128.73,90.14) 128.4,89.81 U4.U11
  IN2 w0.089: v2(128.73,90.14) 129.09,89.78 129.09,89.05 129.81,88.33 129.81,82.31 129.74,82.23 129.74,81.32 131.13,79.92 131.13,75.23 131.52,74.85
  IN2 w0.127: 131.52,74.85 132.7,73.67 134.64,73.67 v2(134.78,73.53)
  BOTTOM w0.102: RP16.8 141.78,75.49 141.21,74.91 140.89,74.91 140.82,74.99 Q11.3 140.82,76.64 140.32,77.14 139.36,77.14 138.86,76.63 138.86,75.11 137.98,74.23 136.07,74.23 134.95,73.11 134.5,73.11 134.49,73.11 134.31,73.29 134.31,73.61 134.4,73.7 134.61,73.7 v2(134.78,73.53)
PCH_SML0CLK: length 2.7
  TOP w0.102: U4.U8 128.61,91.35 v2(128.75,91.35)
  BOTTOM w0.089: 128.52,91.58 v2(128.75,91.35)
  BOTTOM w0.102: R226.1 128.21,91.89 128.52,91.58
PCH_SML0DATA: length 2.4
  TOP w0.102: U4.R7 129.4,91.6 v2(129.73,91.94)
  BOTTOM w0.089: v2(129.73,91.94) 129.39,91.94 129.19,92.13 129.19,92.77
  BOTTOM w0.102: R227.1 129.13,92.84 129.19,92.77
PCH_SRTCRST#: length 9.7
  TOP w0.089: U4.B9 134.95,90.39 135.43,90.39 135.52,90.29 136.44,90.29 136.84,90.69 v1(137.03,90.69) 137.93,90.69
  TOP w0.102: R98.2 141.05,93.95 C113.2 141.05,93.1 CLRP2.2 141.05,91.26 140.75,90.95 138.2,90.95 137.93,90.69
PCH_TD_IREF: length 2.4
  TOP w0.089: U4.AY43 119.13,76.41 v2(119.5,76.77)
  BOTTOM w0.089: v1(118.35,76.63) 118.49,76.77 v2(119.5,76.77) 119.52,76.75 R228.1
PCH_THRMTRIP#_R: length 8.3
  TOP w0.089: 115.24,97.07 116,96.3 117.68,96.3 119.85,94.13 U4.AV1
  TOP w0.102: 115.24,97.07 115.18,97.12 R262.1 R258.1 116.61,97.35 v1(117.1,97.84)
PCH_WL_OFF#: length 170.2
  TOP w0.102: R176.1 123.41,102.83 122.92,103.33 v2(122.92,103.37) ; U4.AL6 122.72,92.19 v2(122.35,92.56)
  IN1 w0.089: v2(122.35,92.56) 120.56,94.36 120.56,94.79
  IN1 w0.127: v2(122.92,103.37) 122.92,102.9 122.14,102.12 122.14,100.96 120.56,99.38 120.56,94.79 ; v2(199.16,101.32) 199.16,133.99 202.95,137.78 207.9,137.78 208.52,138.4 208.52,151.07 v2(208.66,151.2)
  IN2 w0.089: 126.04,94.79 126.04,94.65 125.61,94.22 123.29,94.22 122.35,93.29 v2(122.35,92.56)
  IN2 w0.127: v2(160,101.71) 160.39,101.32 v2(199.16,101.32) ; v2(160.29,92.03) 157.13,95.2 157.13,96.36 156.05,97.44 150.35,97.44 147.71,100.09 140.34,100.09 139.23,101.19 136.37,101.19 135.2,100.02 132.95,100.02 130.85,97.93 129.65,97.93 129.03,97.3 127.2,97.3 126.49,96.59 126.49,95.74 126.04,95.3 126.04,94.79
  BOTTOM w0.089: R158.1 121.85,93.06 v2(122.35,92.56)
  BOTTOM w0.102: JWLN1.20 v2(208.66,151.2) ; v2(160,101.71) 159.74,101.44 v1(159.74,100.91) 159.74,100.44 160.18,100 160.18,98.87 159.62,98.31 159.62,92.71 v2(160.29,92.03)
PCI_PIRQA#: length 10.6
  TOP w0.089: v2(132.57,85.58) 132.18,85.97 U4.H20
  IN1 w0.089: 136.76,86.78 135.34,86.78 134.47,85.91 132.89,85.91 v2(132.57,85.58)
  IN1 w0.127: 136.76,86.78 137.08,86.78 137.33,86.53 137.33,85.83 v2(137.63,85.53)
  BOTTOM w0.089: 136.76,85.95 136.19,85.95 136.08,85.84 136.08,85.18 135.99,85.09 135.86,85.09 135.72,85.22 RP1.8
  BOTTOM w0.102: 136.76,85.95 137.48,85.95 137.63,85.8 v2(137.63,85.53)
PCI_PIRQB#: length 5.6
  TOP w0.089: v2(131.25,86.6) 130.99,86.33 U4.L20
  BOTTOM w0.089: RP1.7 135.22,86.02 134.25,86.99 v1(133.94,86.99) 131.65,86.99 v2(131.25,86.6)
PCI_PIRQC#: length 4
  TOP w0.089: U4.K17 131.58,86.99 v2(131.97,86.6)
  BOTTOM w0.089: RP1.6 134.72,85.91 134.47,86.16 132.71,86.16 v1(132.55,86.31) 132.27,86.6 v2(131.97,86.6)
PCI_PIRQD#: length 4.9
  TOP w0.089: U4.M20 130.39,86.34 v2(130.66,86.61)
  BOTTOM w0.102: v2(130.66,86.61) 130.66,86.46 v1(131.01,86.12) 131.15,85.97 134.08,85.97 134.22,85.83 RP1.5
PCIE_CRX_C_GTX_N0: length 19.8
  IN2 w0.102: v2(136.88,131.72) 136.88,131.52 137.01,131.39 137.25,131.39 137.52,131.11 137.52,130.54 137.05,130.07 136.53,130.07 136.15,129.69 136.15,128.93 134.39,127.17 134.39,125.16 133.42,124.19 132.42,124.19 132.03,123.8 132.03,123.77 132.01,123.75
  IN2 w0.14: v2(129.32,121.7) 129.26,121.76 129.26,122.13 129.43,122.31 130.57,122.31 132.01,123.75
  BOTTOM w0.102: v2(136.88,131.72) 136.63,131.47 UV1.Y32
  BOTTOM w0.109: CV2.1 128.24,118.9 128.24,119.29 129.29,120.34 129.29,121.67 v2(129.32,121.7)
PCIE_CRX_C_GTX_N1: length 17.4
  IN2 w0.102: 129.64,123.75 129.67,123.78 130.8,123.78 133.75,126.73 133.75,127.56 135.55,129.36 135.55,129.78 136.28,130.51 136.28,131.2 136.06,131.43 135.74,131.43 135.66,131.51 v2(135.66,131.74)
  IN2 w0.14: v2(129.34,123.11) 129.34,123.46 129.64,123.75
  BOTTOM w0.102: v2(135.66,131.74) 135.39,131.47 UV1.W32
  BOTTOM w0.109: v2(129.34,123.11) 129.28,123.04 129.28,122.62 128.87,122.21 127.92,122.21 126.98,121.27 126.98,120.88 CV4.1
PCIE_CRX_C_GTX_N2: length 19.7
  IN2 w0.102: v2(128.47,123.89) 128.42,123.95 128.42,124.34 128.58,124.51 129.94,124.51 130.82,125.38 130.82,126.88 131.28,127.35 132.11,127.35 133.59,128.83 133.59,129.11 134.38,129.91 134.67,129.91 135.24,130.48 135.24,130.99 134.92,131.3 134.64,131.3 134.51,131.43 v2(134.51,131.6)
  BOTTOM w0.102: v2(128.47,123.89) 128.36,123.79 128.36,123.77 128.35,123.75 ; UV1.U32 134.39,131.47 v2(134.51,131.6)
  BOTTOM w0.109: CV6.1 125.83,118.85 125.83,121.15 127.77,123.09 127.96,123.09 128.35,123.48 128.35,123.75
PCIE_CRX_C_GTX_N3: length 20.6
  IN2 w0.102: v2(134.46,133.49) 134.46,133.31 134.35,133.19 133.95,133.19 133.66,132.9 133.66,130.08 131.77,128.19 130.11,128.19 128.93,127.01 128.93,125.8 129.2,125.52 129.4,125.52 v2(129.59,125.33)
  BOTTOM w0.102: v2(129.59,125.33) 127.79,125.33 127.31,124.85 127.31,123.78 127.32,123.78 127.32,123.75 ; v2(134.46,133.49) 134.08,133.87 UV1.U29
  BOTTOM w0.109: CV8.1 124.74,120.78 124.74,121.06 v4(126.75,123.07) 127.32,123.64 127.32,123.75
PCIE_CRX_C_GTX_N4: length 20
  IN2 w0.102: 126.66,123.72 126.7,123.76 126.7,124.79 128.38,126.46 128.38,127.37 130.03,129.02 131.16,129.02 132.56,130.41 132.56,131.1 132.9,131.44 133.17,131.44 133.26,131.53 v2(133.26,131.76)
  IN2 w0.14: v2(122.98,121.64) 123.2,121.86 123.2,122.02 123.53,122.36 125.3,122.36 126.66,123.72
  BOTTOM w0.102: UV1.T32 132.97,131.47 v2(133.26,131.76)
  BOTTOM w0.109: CV10.1 122.98,118.86 v2(122.98,121.64)
PCIE_CRX_C_GTX_N5: length 20.8
  IN2 w0.102: v2(125.14,125.13) 125.32,125.3 125.32,125.54 125.92,126.13 125.92,127.43 126.8,128.32 127.2,128.32 130.93,132.05 132,132.05 132.39,132.45 132.39,132.93 132.76,133.3 133.02,133.3 v2(133.19,133.47)
  BOTTOM w0.102: v2(133.19,133.47) 132.79,133.87 UV1.T29 ; v2(125.14,125.13) 125.33,124.94 125.33,124.8 125.33,124.79 125.33,124.77
  BOTTOM w0.109: 125.33,124.77 125.33,122.95 124.76,122.37 122.59,122.37 121.93,121.71 121.93,120.97 CV12.1
PCIE_CRX_C_GTX_N6: length 20.6
  IN2 w0.102: v2(126.9,126.36) 126.99,126.27 127.21,126.27 127.4,126.46 127.4,127.77 128.39,128.76 129.07,128.76 131.4,131.09 131.74,131.09 v2(132.07,131.41)
  BOTTOM w0.102: v2(132.07,131.41) 132.01,131.47 UV1.P32 ; v2(126.9,126.36) 124.93,126.36 123.85,125.28 123.37,125.28 123.06,124.98 123.06,124.98 123.02,124.93 123.01,124.93 122.99,124.92
  BOTTOM w0.109: CV14.1 120.63,119.03 120.63,120.91 121.21,121.48 121.21,121.99 121.84,122.63 121.84,123.77 122.99,124.92
PCIE_CRX_C_GTX_N7: length 20.9
  IN2 w0.102: 122,124.95 122.02,124.97 122.04,124.97 122.75,125.68 123.97,125.68 124.79,126.5 125.1,126.5 125.36,126.76 125.36,127.99 126.37,129 126.37,129.47 128.1,131.2 128.56,131.2 129,131.65 129,132.14 130.09,133.23 131.7,133.23 v2(131.95,133.48)
  IN2 w0.14: v2(120.63,123.04) 120.82,123.23 120.82,123.77 122,124.95
  BOTTOM w0.102: v2(131.95,133.48) 131.94,133.48 131.94,133.49 131.57,133.87 UV1.P29
  BOTTOM w0.109: CV16.1 119.43,120.94 119.43,121.28 120.63,122.48 v2(120.63,123.04)
PCIE_CRX_C_GTX_P0: length 19.7
  IN2 w0.102: v2(136.87,130.84) 136.87,131.08 136.95,131.17 137.16,131.17 137.31,131.02 137.31,130.63 136.96,130.29 136.44,130.29 135.94,129.78 135.94,129.02 134.18,127.26 134.18,125.25 133.33,124.41 132.33,124.41 131.87,123.94 131.84,123.94 131.83,123.93
  IN2 w0.14: v2(128.73,121.7) 128.73,121.73 129,121.99 129,122.24 129.33,122.56 130.46,122.56 131.83,123.93
  BOTTOM w0.102: UV1.Y33 136.7,130.67 v2(136.87,130.84)
  BOTTOM w0.109: v2(128.73,121.7) 129.08,121.36 129.08,120.42 128.03,119.38 128.03,119.05 CV1.1
PCIE_CRX_C_GTX_P1: length 17.4
  IN2 w0.102: v2(135.63,130.9) 135.63,131.1 135.74,131.21 135.97,131.21 136.07,131.11 136.07,130.6 135.34,129.87 135.34,129.45 133.54,127.65 133.54,126.82 130.71,124 129.53,124 129.33,123.8
  IN2 w0.14: 129.33,123.8 129.06,123.54 129.06,123.43 128.76,123.12 v2(128.76,123.11)
  BOTTOM w0.102: v2(135.63,130.9) 135.4,130.67 UV1.W33
  BOTTOM w0.109: v2(128.76,123.11) 129.07,122.8 129.07,122.7 128.79,122.42 127.83,122.42 126.77,121.36 126.77,121.09 CV3.1
PCIE_CRX_C_GTX_P2: length 19.7
  IN2 w0.102: v2(134.52,130.69) 134.52,131.02 134.59,131.09 134.83,131.09 135.02,130.9 135.02,130.57 134.58,130.12 134.29,130.12 133.37,129.2 133.37,128.92 132.02,127.56 131.19,127.56 130.6,126.97 130.6,125.47 129.85,124.72 128.49,124.72 128.2,124.43 128.2,124.21 v2(127.88,123.89)
  BOTTOM w0.102: UV1.U33 134.5,130.67 v2(134.52,130.69) ; 128.02,123.75 v2(127.88,123.89)
  BOTTOM w0.109: CV5.1 125.62,119.12 125.62,121.23 127.68,123.3 127.87,123.3 128.14,123.56 128.14,123.65 128.11,123.68 128.1,123.68 128.02,123.75
PCIE_CRX_C_GTX_P3: length 20.6
  IN2 w0.102: v2(129.59,125.92) 129.41,125.74 129.29,125.74 129.14,125.89 129.14,126.92 130.2,127.98 131.86,127.98 133.87,129.99 133.87,132.81 134.04,132.98 134.38,132.98 134.46,132.89 v2(134.46,132.69)
  BOTTOM w0.102: 127.11,123.75 127.11,123.78 127.11,123.78 127.11,124.94 127.71,125.54 129.21,125.54 v2(129.59,125.92) ; v2(134.46,132.69) 134.08,133.07 UV1.U30
  BOTTOM w0.109: CV7.1 124.25,120.88 124.32,120.88 124.52,121.07 124.52,121.14 126.37,122.99 126.37,123.02 126.79,123.44 126.83,123.44 127.11,123.72 127.11,123.75
PCIE_CRX_C_GTX_P4: length 20
  IN2 w0.102: v2(133.28,130.82) 133.33,130.88 133.33,131.1 133.2,131.23 132.99,131.23 132.77,131.01 132.77,130.32 131.25,128.8 130.12,128.8 128.59,127.28 128.59,126.37 126.92,124.7 126.92,123.67 126.89,123.65 126.89,123.62 126.84,123.57 126.85,123.56 126.85,123.55 126.84,123.54
  IN2 w0.14: v2(123.56,121.64) 123.45,121.75 123.45,121.91 123.64,122.1 125.4,122.1 126.84,123.54
  BOTTOM w0.102: UV1.T33 133.13,130.67 v2(133.28,130.82)
  BOTTOM w0.109: CV9.1 123.19,119.15 123.19,121.26 v2(123.56,121.64)
PCIE_CRX_C_GTX_P5: length 20.8
  IN2 w0.102: v2(133.21,132.67) 133.21,133 133.13,133.08 132.85,133.08 132.61,132.84 132.61,132.36 132.09,131.84 131.02,131.84 127.29,128.1 126.89,128.1 126.13,127.34 126.13,126.04 125.53,125.45 125.53,125.32 v2(125.73,125.13)
  BOTTOM w0.102: v2(133.21,132.67) 132.81,133.07 UV1.T30 ; v2(125.73,125.13) 125.54,124.94 125.54,124.8 125.54,124.79 125.54,124.77
  BOTTOM w0.109: CV11.1 122.14,120.97 122.14,121.62 122.68,122.16 124.84,122.16 125.54,122.86 125.54,124.77
PCIE_CRX_C_GTX_P6: length 20.6
  IN2 w0.102: v2(126.9,125.78) 127.18,126.06 127.3,126.06 127.62,126.37 127.62,127.68 128.48,128.55 129.16,128.55 131.49,130.87 131.73,130.87 v2(132.07,130.53)
  BOTTOM w0.102: 123.14,124.77 123.45,125.08 123.93,125.08 125.01,126.16 126.52,126.16 v2(126.9,125.78) ; UV1.P33 131.93,130.67 v2(132.07,130.53)
  BOTTOM w0.109: CV13.1 120.85,119.01 120.85,120.82 121.42,121.4 121.42,121.9 122.05,122.54 122.05,123.68 123.14,124.77
PCIE_CRX_C_GTX_P7: length 20.9
  IN2 w0.102: 122.18,124.77 122.2,124.79 122.2,124.82 122.84,125.46 124.06,125.46 124.88,126.29 125.19,126.29 125.57,126.67 125.57,127.9 126.59,128.91 126.59,129.38 128.19,130.99 128.65,130.99 129.22,131.56 129.22,132.05 130.18,133.02 131.91,133.02 131.98,132.95 v2(131.98,132.7)
  IN2 w0.14: 122.18,124.77 121.08,123.67 121.08,123.18 v2(121.21,123.04)
  BOTTOM w0.102: v2(131.98,132.7) 131.6,133.07 UV1.P30
  BOTTOM w0.109: CV15.1 119.64,121 119.64,121.19 120.84,122.39 120.84,122.67 v2(121.21,123.04)
PCIE_CRX_GTX_N0: length 53
  IN2 w0.089: v2(82.04,110.45) 82.23,110.64 84.25,110.64 86.93,113.31 87.23,113.31
  IN2 w0.14: 87.23,113.31 95.25,113.31 96.28,112.28 106.56,112.28 109.55,115.27 122.24,115.27 123.03,114.48 127.09,114.48 128.13,115.51 128.13,116.11 v2(128.29,116.27)
  BOTTOM w0.089: v2(82.04,110.45) 81.54,110.94 JCPU1.E32
  BOTTOM w0.109: CV2.2 128.1,117.33 128.1,116.46 v2(128.29,116.27)
PCIE_CRX_GTX_N1: length 54.1
  IN2 w0.089: v2(81.01,111.43) 81.38,111.8 84.74,111.8 87.06,114.11 87.19,114.11 87.22,114.09 87.23,114.09
  IN2 w0.14: v2(127.05,116.23) 126.85,116.04 126.85,115.68 126.47,115.3 123.37,115.3 122.63,116.04 109.22,116.04 106.32,113.14 96.8,113.14 95.86,114.09 87.23,114.09
  BOTTOM w0.089: v2(81.01,111.43) 81.51,111.93 JCPU1.E33
  BOTTOM w0.109: v2(127.05,116.23) 126.86,116.42 126.86,119.36 CV4.2
PCIE_CRX_GTX_N2: length 50.5
  IN2 w0.089: v2(82.02,112.51) 82.24,112.72 83.17,112.72 83.27,112.63 83.27,112.45 83.51,112.2 84.03,112.2 84.27,112.45 84.27,112.71 84.4,112.84 84.79,112.84 85.21,113.26 85.21,113.56 84.98,113.79 84.98,113.92 85.17,114.11 85.29,114.11 85.53,113.87 85.82,113.87 86.81,114.86 87.23,114.86
  IN2 w0.14: 87.23,114.86 96.53,114.86 97.36,114.03 106.08,114.03 108.88,116.84 122.93,116.84 123.69,116.08 125.42,116.08 125.71,116.37 125.71,116.84 v2(125.88,117)
  BOTTOM w0.089: v2(82.02,112.51) 82.46,112.94 JCPU1.D34
  BOTTOM w0.109: v2(125.88,117) 125.69,117.19 125.69,117.38 CV6.2
PCIE_CRX_GTX_N3: length 49.8
  IN2 w0.089: v2(81.01,114.54) 81.01,114.25 81.13,114.12 84.19,114.12 85.96,115.89 87.23,115.89
  IN2 w0.14: v2(124.71,117.07) 124.56,117.22 124.56,117.57 124.26,117.87 108.31,117.87 106.34,115.89 87.23,115.89
  BOTTOM w0.089: v2(81.01,114.54) 81.51,114.03 JCPU1.E35
  BOTTOM w0.109: CV8.2 124.52,119.35 124.52,117.25 v2(124.71,117.07)
PCIE_CRX_GTX_N4: length 50.9
  IN2 w0.089: v2(82.05,108.42) 81.91,108.56 81.91,108.76 82.01,108.86 83.87,108.86 85.73,110.72 87.16,110.72 87.21,110.77 87.23,110.77
  IN2 w0.14: v2(122.99,112.6) 123.16,112.76 123.16,113 122.9,113.26 109.78,113.26 106.45,109.93 95.14,109.93 94.69,110.37 87.75,110.37 87.36,110.77 87.23,110.77
  BOTTOM w0.089: JCPU1.D30 82.51,108.88 v2(82.05,108.42)
  BOTTOM w0.109: CV10.2 123.18,117.37 123.18,112.78 v2(122.99,112.6)
PCIE_CRX_GTX_N5: length 51.8
  IN2 w0.089: 87.23,112.2 86.38,111.35 85.5,111.35 84.03,109.88 81.01,109.88 80.89,109.76 80.89,109.53 v2(81.01,109.41)
  IN2 w0.14: 87.23,112.2 87.29,112.26 87.33,112.26 87.37,112.3 87.4,112.3 87.54,112.44 94.59,112.44 96.21,110.82 106.19,110.82 109.87,114.49 121.78,114.49 121.9,114.37 121.9,114.21 v2(121.75,114.06)
  BOTTOM w0.089: JCPU1.E31 81.51,109.89 81.03,109.41 v2(81.01,109.41)
  BOTTOM w0.109: v2(121.75,114.06) 121.94,114.24 121.94,119.37 CV12.2
PCIE_CRX_GTX_N6: length 48.5
  IN2 w0.089: v2(82.02,107.4) 81.83,107.21 81.83,107.05 81.94,106.94 83.1,106.94 83.57,107.41 84.17,107.41 85.75,108.99 87.19,108.99 87.22,109.02 87.23,109.02
  IN2 w0.14: v2(120.45,112.6) 120.61,112.44 120.61,112.05 119.9,111.34 109.69,111.34 106.83,108.48 94.14,108.48 93.6,109.02 87.23,109.02
  BOTTOM w0.089: JCPU1.D28 82.49,106.94 v2(82.02,107.4)
  BOTTOM w0.109: CV14.2 120.62,117.44 120.62,112.77 v2(120.45,112.6)
PCIE_CRX_GTX_N7: length 49.6
  IN2 w0.089: 87.23,109.81 87.22,109.81 87.19,109.78 85.52,109.78 83.71,107.97 81.32,107.97 81.19,107.84 80.97,107.84 80.83,107.99 80.83,108.2 80.95,108.32 v2(81.03,108.32)
  IN2 w0.14: v2(119.15,112.63) 119.32,112.46 119.32,112.27 119.19,112.14 109.4,112.14 106.61,109.36 94.47,109.36 94.02,109.81 87.23,109.81
  BOTTOM w0.089: v2(81.03,108.32) 81.41,107.94 JCPU1.E29
  BOTTOM w0.109: v2(119.15,112.63) 119.33,112.82 119.33,119.51 CV16.2
PCIE_CRX_GTX_P0: length 53
  IN2 w0.089: 87.23,113.57 86.89,113.57 84.17,110.84 82.05,110.84 81.91,110.98 81.91,111.25 v2(82.04,111.38)
  IN2 w0.14: v2(127.7,116.27) 127.87,116.11 127.87,115.62 126.98,114.73 123.13,114.73 122.34,115.52 109.44,115.52 106.45,112.53 96.39,112.53 95.35,113.57 87.23,113.57
  BOTTOM w0.089: JCPU1.D32 82.48,110.94 v2(82.04,111.38)
  BOTTOM w0.109: CV1.2 127.89,117.46 127.89,116.46 v2(127.7,116.27)
PCIE_CRX_GTX_P1: length 54.1
  IN2 w0.089: v2(81.01,112.41) 80.94,112.41 80.82,112.29 80.82,112.11 80.93,112 84.66,112 87,114.34 87.23,114.34
  IN2 w0.14: 87.23,114.34 95.96,114.34 96.91,113.4 106.22,113.4 109.12,116.3 122.74,116.3 123.48,115.55 126.37,115.55 126.6,115.79 126.6,116.09 126.54,116.15 126.54,116.16 v2(126.46,116.23)
  BOTTOM w0.089: v2(81.01,112.41) 80.54,111.94 JCPU1.F33
  BOTTOM w0.109: v2(126.46,116.23) 126.65,116.42 126.65,119.39 CV3.2
PCIE_CRX_GTX_P2: length 50.5
  IN2 w0.089: v2(82.04,113.41) 81.99,113.35 81.99,113.09 82.15,112.93 83.26,112.93 83.47,112.71 83.47,112.53 83.6,112.4 83.94,112.4 84.07,112.53 84.07,112.79 84.31,113.04 84.7,113.04 85.01,113.35 85.01,113.47 84.78,113.71 84.78,114 85.08,114.31 85.38,114.31 85.61,114.08 85.74,114.08 86.73,115.07 87.11,115.07 87.14,115.09 87.19,115.09 87.22,115.12 87.23,115.12
  IN2 w0.14: v2(125.29,117) 125.46,116.84 125.46,116.47 125.31,116.33 123.8,116.33 123.04,117.09 108.78,117.09 105.97,114.28 97.47,114.28 96.63,115.12 87.23,115.12
  BOTTOM w0.089: JCPU1.E34 81.58,112.94 v2(82.04,113.41)
  BOTTOM w0.109: CV5.2 125.47,117.41 125.47,117.19 v2(125.29,117)
PCIE_CRX_GTX_P3: length 49.8
  IN2 w0.089: 87.23,115.64 87.22,115.64 87.19,115.67 87.14,115.67 87.11,115.69 86.05,115.69 84.27,113.92 80.89,113.92 80.78,113.8 80.78,113.62 v2(81.01,113.4)
  IN2 w0.14: v2(124.13,117.07) 124.3,117.24 124.3,117.47 124.16,117.61 108.41,117.61 106.44,115.64 87.23,115.64
  BOTTOM w0.089: JCPU1.F35 80.51,113.89 v2(81.01,113.4)
  BOTTOM w0.109: CV7.2 124.31,119.42 124.31,117.25 v2(124.13,117.07)
PCIE_CRX_GTX_P4: length 50.9
  IN2 w0.089: v2(82.04,109.44) 82.41,109.06 83.79,109.06 85.64,110.92 87,110.92 87.05,110.97
  IN2 w0.14: v2(123.58,112.6) 123.41,112.76 123.41,113.1 123.01,113.51 109.67,113.51 106.34,110.18 95.24,110.18 94.8,110.63 87.86,110.63 87.47,111.02 87.11,111.02 87.05,110.97
  BOTTOM w0.089: JCPU1.E30 81.51,108.95 82,109.44 v2(82.04,109.44)
  BOTTOM w0.109: CV9.2 123.39,117.46 123.39,112.78 v2(123.58,112.6)
PCIE_CRX_GTX_P5: length 51.8
  IN2 w0.089: 87.23,112.53 87.22,112.52 87.18,112.52 87.04,112.37 87.04,112.34 87,112.3 87,112.26 86.29,111.55 85.42,111.55 83.95,110.08 81.34,110.08 v2(81.01,110.42)
  IN2 w0.14: v2(122.33,114.06) 122.16,114.23 122.16,114.48 121.88,114.75 109.76,114.75 106.09,111.07 96.31,111.07 94.69,112.69 87.43,112.69 87.3,112.56 87.26,112.56 87.23,112.53
  BOTTOM w0.089: v2(81.01,110.42) 80.54,109.94 JCPU1.F31
  BOTTOM w0.109: CV11.2 122.15,119.39 122.15,114.24 v2(122.33,114.06)
PCIE_CRX_GTX_P6: length 48.5
  IN2 w0.089: v2(82.02,106.36) 82.4,106.74 83.18,106.74 83.65,107.21 84.25,107.21 85.84,108.79 87.21,108.79 87.23,108.77
  IN2 w0.14: v2(121.03,112.6) 120.86,112.42 120.86,111.94 120,111.08 109.8,111.08 106.94,108.23 94.03,108.23 93.5,108.77 87.23,108.77
  BOTTOM w0.089: JCPU1.E28 81.51,106.87 v2(82.02,106.36)
  BOTTOM w0.109: CV13.2 120.83,117.4 120.83,112.8 v2(121.03,112.6)
PCIE_CRX_GTX_P7: length 49.5
  IN2 w0.089: 87.23,109.55 87.21,109.55 87.18,109.58 85.6,109.58 83.8,107.77 81.4,107.77 v2(81.04,107.41)
  IN2 w0.14: 87.23,109.55 93.92,109.55 94.36,109.1 106.72,109.1 109.5,111.88 119.3,111.88 119.58,112.16 119.58,112.48 v2(119.73,112.63)
  BOTTOM w0.089: v2(81.04,107.41) 80.51,107.94 JCPU1.F29
  BOTTOM w0.109: CV15.2 119.54,119.26 119.54,112.82 v2(119.73,112.63)
PCIE_CTX_GRX_C_N0: length 7.1
  BOTTOM w0.089: 87.23,102.51 87.22,102.51 87.21,102.49 85.13,102.49 84.97,102.65 84.97,102.84 85.07,102.94 JCPU1.A24
  BOTTOM w0.109: C16.1 90.58,102.73 90.11,102.73 90.08,102.77 89.33,102.77 89.29,102.73 89.01,102.73 88.79,102.51 87.23,102.51
PCIE_CTX_GRX_C_N1: length 8.5
  BOTTOM w0.089: 87.23,103.29 87.22,103.29 87.21,103.28 87.15,103.28 87.14,103.27 86.34,103.27 86.09,103.53 84.12,103.53 83.99,103.65 83.99,103.86 84.08,103.94 JCPU1.B25
  BOTTOM w0.109: 87.23,103.29 88.56,103.29 89.06,103.79 89.06,103.85 89.56,104.34 89.61,104.34 89.79,104.53 90.58,104.53 C15.1
PCIE_CTX_GRX_C_N2: length 9.3
  BOTTOM w0.089: JCPU1.A26 85.03,104.94 84.92,104.83 84.92,104.67 85.1,104.49 85.82,104.49 86.12,104.79 87.23,104.79
  BOTTOM w0.109: 87.23,104.79 88.54,104.79 88.96,105.21 88.96,105.25 89.42,105.71 89.46,105.71 89.62,105.87 92.37,105.87 C14.1
PCIE_CTX_GRX_C_N3: length 8.6
  BOTTOM w0.089: JCPU1.B27 84.06,105.94 83.93,105.81 83.93,105.65 84.07,105.51 87.1,105.51 87.23,105.65
  BOTTOM w0.109: C13.1 90.56,107.06 89.98,107.06 89.96,107.08 89.3,107.08 89.28,107.06 88.64,107.06 87.23,105.65
PCIE_CTX_GRX_C_N4: length 9.7
  BOTTOM w0.089: JCPU1.A28 85.05,106.94 84.96,106.86 84.96,106.58 85.04,106.5 85.96,106.5 86.14,106.68 87.08,106.68 87.23,106.83
  BOTTOM w0.109: 87.23,106.83 88.75,108.35 89.22,108.35 89.26,108.38 89.92,108.38 89.95,108.35 90.12,108.35 90.46,108.7 91.24,108.7 91.39,108.55 92.3,108.55 C12.1
PCIE_CTX_GRX_C_N5: length 9
  BOTTOM w0.089: 87.23,107.92 86.82,107.51 84.03,107.51 83.94,107.6 83.94,107.82 84.06,107.94 JCPU1.B29
  BOTTOM w0.109: 87.23,107.92 88.46,109.15 88.46,109.19 88.95,109.67 88.98,109.67 89.19,109.88 90.53,109.88 C11.1
PCIE_CTX_GRX_C_N6: length 9.8
  BOTTOM w0.089: 87.23,109.33 87.07,109.18 87.07,109.16 87.03,109.12 87.03,109.1 86.87,108.94 86.25,108.94 85.82,108.51 85.11,108.51 84.97,108.65 84.97,108.86 85.05,108.94 JCPU1.A30
  BOTTOM w0.109: C10.1 92.37,111.24 90.8,111.24 90.14,110.58 89.92,110.58 89.89,110.61 89.3,110.61 89.27,110.58 88.48,110.58 87.23,109.33
PCIE_CTX_GRX_C_N7: length 9.2
  BOTTOM w0.089: 87.08,110.25 87.07,110.24 87.07,110.23 86.35,109.5 84.13,109.5 83.97,109.66 83.97,109.85 84.06,109.94 JCPU1.B31
  BOTTOM w0.109: C9.1 90.56,112.57 v4(89.92,112.57) 89.4,112.57 88.89,112.06 88.84,112.06 88.33,111.55 88.33,111.5 87.08,110.25
PCIE_CTX_GRX_C_P0: length 7.1
  BOTTOM w0.089: JCPU1.B24 84.65,102.94 84.78,102.82 84.78,102.58 85.05,102.3 87.21,102.3 87.22,102.29 87.23,102.29
  BOTTOM w0.109: C32.1 90.61,102.52 v4(89.73,102.52) 89.1,102.52 88.87,102.29 87.23,102.29
PCIE_CTX_GRX_C_P1: length 8.5
  BOTTOM w0.089: 87.23,103.08 86.27,103.08 86.01,103.34 84.04,103.34 83.8,103.58 83.8,103.77 83.63,103.94 JCPU1.C25
  BOTTOM w0.109: C31.1 90.61,104.32 89.88,104.32 v4(89.47,103.91) 88.65,103.08 87.23,103.08
PCIE_CTX_GRX_C_P2: length 9.3
  BOTTOM w0.089: 87.23,104.58 87.22,104.58 87.21,104.59 87.15,104.59 87.14,104.6 86.19,104.6 85.9,104.3 85.02,104.3 84.73,104.59 84.73,104.85 84.64,104.94 JCPU1.B26
  BOTTOM w0.109: C30.1 92.3,105.66 89.71,105.66 v4(89.37,105.32) 88.63,104.58 87.23,104.58
PCIE_CTX_GRX_C_P3: length 8.6
  BOTTOM w0.089: 87.23,105.35 87.21,105.32 83.99,105.32 83.74,105.57 83.74,105.85 83.65,105.94 JCPU1.C27
  BOTTOM w0.109: 87.23,105.35 88.73,106.85 v4(89.58,106.85) 90.49,106.85 C29.1
PCIE_CTX_GRX_C_P4: length 9.7
  BOTTOM w0.089: 87.23,106.53 87.18,106.49 86.22,106.49 86.04,106.31 84.96,106.31 84.77,106.5 84.77,106.8 84.63,106.94 JCPU1.B28
  BOTTOM w0.109: C28.1 92.28,108.34 91.3,108.34 91.15,108.48 90.55,108.48 90.21,108.14 v4(89.53,108.14) 88.84,108.14 87.23,106.53
PCIE_CTX_GRX_C_P5: length 8.9
  BOTTOM w0.089: JCPU1.C29 83.64,107.94 83.75,107.83 83.75,107.52 83.95,107.32 86.94,107.32 87.23,107.61
  BOTTOM w0.109: C27.1 90.54,109.67 89.29,109.67 v4(88.85,109.23) 87.23,107.61
PCIE_CTX_GRX_C_P6: length 9.8
  BOTTOM w0.089: JCPU1.B30 84.64,108.94 84.78,108.8 84.78,108.57 85.03,108.32 85.9,108.32 86.33,108.75 86.95,108.75 87.23,109.03
  BOTTOM w0.109: C26.1 92.27,111.03 90.89,111.03 90.23,110.37 v4(89.59,110.37) 88.57,110.37 87.23,109.03
PCIE_CTX_GRX_C_P7: length 9.3
  BOTTOM w0.089: 87.23,110.1 87.22,110.1 86.43,109.31 84.05,109.31 83.78,109.59 83.78,109.85 83.69,109.94 JCPU1.C31
  BOTTOM w0.109: 87.23,110.1 v4(88.77,111.64) 89.49,112.36 89.6,112.36 89.63,112.33 90.29,112.33 90.32,112.36 90.59,112.36 C25.1
PCIE_CTX_GRX_N0: length 67.1
  BOTTOM w0.102: 136.74,124.77 136.74,124.8 136.75,124.8 136.75,127.78 UV1.Y37
  BOTTOM w0.109: 136.74,124.77 136.74,123.08 134.77,121.11 134.77,114.23 134.74,114.2 134.74,113.46 134.77,113.43 v4(134.77,111.68) 134.77,110.58 131.39,107.2 115.61,107.2 112.99,109.82 100.05,109.82 93.18,102.95 91.98,102.95 C16.2
PCIE_CTX_GRX_N1: length 64.6
  BOTTOM w0.102: 135.74,124.77 135.74,124.8 135.74,124.8 135.74,127.68 135.82,127.76 135.82,127.99 135.74,128.06 135.74,128.49 135.9,128.65 135.9,128.79 135.8,128.9 135.59,128.9 135.45,128.76 UV1.W36
  BOTTOM w0.109: C15.2 92.24,104.48 92.77,104.48 92.79,104.51 93.48,104.51 93.5,104.48 93.71,104.48 99.84,110.61 113.19,110.61 115.9,107.9 127.52,107.9 v4(130.86,111.23) 134.05,114.43 134.05,121.39 135.74,123.08 135.74,124.77
PCIE_CTX_GRX_N2: length 60.1
  BOTTOM w0.102: UV1.V37 135.16,127.76 135.16,126.68 135.02,126.54 135.02,124.86 135.02,124.86 135.02,124.8 135.02,124.79 135.02,124.77
  BOTTOM w0.109: C14.2 93.67,106.08 94.26,106.08 94.55,106.37 94.55,106.41 94.96,106.83 95.01,106.83 v4(96.14,107.96) 99.5,111.32 113.47,111.32 116.19,108.6 127.18,108.6 133.35,114.77 133.35,121.81 135.02,123.48 135.02,124.77
PCIE_CTX_GRX_N3: length 62.2
  BOTTOM w0.102: 134.26,123.77 134.26,123.79 134.26,123.79 134.26,126.56 134.15,126.67 134.15,127.7 134.2,127.75 134.2,128.01 134.14,128.06 134.14,128.6 134.07,128.67 UV1.U36
  BOTTOM w0.109: 134.26,123.77 134.26,123.71 132.65,122.1 132.65,115.06 126.89,109.3 116.48,109.3 113.41,112.37 99.45,112.37 v4(98.25,111.17) 97.39,110.31 97.35,110.31 96.81,109.77 96.81,109.73 94,106.92 91.59,106.92 91.51,106.99 91.51,107.1 C13.2
PCIE_CTX_GRX_N4: length 57.5
  BOTTOM w0.102: UV1.T37 133.56,127.76 133.56,124.53 132.99,123.96 132.99,123.96 132.95,123.92 132.94,123.92 132.92,123.9
  BOTTOM w0.109: 132.92,123.9 v4(132.37,123.35) 131.95,122.93 131.95,115.41 130.97,114.44 130.94,114.44 130.55,114.04 130.55,114.01 126.54,110 116.78,110 113.7,113.07 99.08,113.07 94.78,108.77 93.67,108.77 C12.2
PCIE_CTX_GRX_N5: length 58.5
  BOTTOM w0.102: UV1.R36 132.41,128.67 132.54,128.53 132.54,128.06 132.6,128.01 132.6,127.75 132.55,127.7 132.55,125.34 131.25,124.05 131.25,123.78 131.25,123.78 131.25,123.75
  BOTTOM w0.109: C11.2 91.55,109.99 91.55,109.85 91.61,109.79 94.56,109.79 97.45,112.68 97.45,112.73 97.85,113.12 97.89,113.12 98.54,113.77 113.99,113.77 117.07,110.7 125.39,110.7 v4(127.2,112.51) 131.25,116.56 131.25,123.75
PCIE_CTX_GRX_N6: length 54.2
  BOTTOM w0.102: 130.55,123.75 130.55,123.78 130.55,123.78 130.55,124.48 132.11,126.04 132.11,127.15 131.92,127.34 131.92,127.7 131.45,128.17 UV1.P37
  BOTTOM w0.109: C10.2 93.74,111.38 94.98,111.38 95.19,111.6 95.19,111.63 95.64,112.07 95.67,112.07 98.07,114.48 114.32,114.48 v4(114.89,113.91) 117.39,111.4 125.1,111.4 130.55,116.85 130.55,123.75
PCIE_CTX_GRX_N7: length 56
  BOTTOM w0.102: UV1.N36 130.87,128.67 130.94,128.6 130.94,128.06 131,128.01 131,127.75 130.87,127.63 130.87,125.83 129.85,124.81 129.85,123.78 129.84,123.78 129.84,123.75
  BOTTOM w0.109: C9.2 91.56,112.66 91.56,112.54 91.62,112.49 v4(93.17,112.49) 94.72,112.49 96.75,114.52 96.75,114.56 97.27,115.07 97.31,115.07 97.88,115.64 105.7,115.64 106.15,115.19 114.61,115.19 117.7,112.11 124.81,112.11 129.84,117.14 129.84,123.75
PCIE_CTX_GRX_P0: length 67
  BOTTOM w0.102: UV1.AA38 136.95,127.77 136.95,124.8 136.96,124.8 136.96,124.77
  BOTTOM w0.109: 136.96,124.77 136.96,122.99 134.98,121.02 v4(134.98,113.84) 134.98,112.07 135.01,112.05 135.01,111.31 134.98,111.29 134.98,110.5 131.48,106.99 115.53,106.99 112.9,109.61 100.13,109.61 93.26,102.74 92.4,102.74 C32.2
PCIE_CTX_GRX_P1: length 64.6
  BOTTOM w0.102: 135.95,124.77 135.95,124.8 135.95,124.8 135.95,127.6 136.02,127.67 136.02,128.07 135.95,128.15 135.95,128.41 136.25,128.71 UV1.Y35
  BOTTOM w0.109: C31.2 92.13,104.27 v4(93.1,104.27) 93.8,104.27 99.92,110.4 113.11,110.4 115.82,107.69 127.61,107.69 130.75,110.83 130.82,110.83 131.27,111.29 131.27,111.35 134.26,114.34 134.26,121.3 135.95,122.99 135.95,124.77
PCIE_CTX_GRX_P2: length 60.1
  BOTTOM w0.102: UV1.W38 135.36,127.78 135.36,126.59 135.23,126.45 135.23,124.77
  BOTTOM w0.109: 135.23,124.77 135.23,123.39 133.56,121.72 133.56,114.68 127.27,108.39 116.11,108.39 113.39,111.11 99.59,111.11 96.51,108.04 96.51,108 96.09,107.58 96.06,107.58 v4(94.93,106.45) 94.35,105.87 94.19,105.87 C30.2
PCIE_CTX_GRX_P3: length 62.1
  BOTTOM w0.102: UV1.V35 134.35,128.77 134.35,128.14 134.4,128.09 134.4,127.67 134.35,127.62 134.35,126.76 134.46,126.64 134.46,123.85 134.46,123.85 134.46,123.79 134.47,123.79 134.47,123.77
  BOTTOM w0.109: C29.2 92.05,106.71 94.09,106.71 v4(97.24,109.86) 98.1,110.72 98.14,110.72 98.64,111.21 98.64,111.26 99.54,112.16 113.33,112.16 116.4,109.09 126.98,109.09 132.86,114.97 132.86,122.01 134.47,123.62 134.47,123.77
PCIE_CTX_GRX_P4: length 57.5
  BOTTOM w0.102: UV1.U38 133.76,127.78 133.76,124.44 133.07,123.75
  BOTTOM w0.109: 133.07,123.75 132.77,123.45 132.77,123.42 132.3,122.95 132.27,122.95 132.16,122.84 132.16,115.32 v4(130.91,114.08) 126.63,109.79 116.69,109.79 113.62,112.86 99.17,112.86 94.87,108.56 94.1,108.56 C28.2
PCIE_CTX_GRX_P5: length 58.5
  BOTTOM w0.102: 131.46,123.75 131.46,123.78 131.45,123.78 131.45,123.96 132.75,125.26 132.75,127.62 132.8,127.67 132.8,128.09 132.75,128.14 132.75,128.77 UV1.T35
  BOTTOM w0.109: C27.2 92.02,109.56 94.63,109.56 v4(97.83,112.76) 98.63,113.56 113.91,113.56 116.98,110.49 125.48,110.49 127.14,112.15 127.17,112.15 127.56,112.55 127.56,112.58 131.46,116.47 131.46,123.75
PCIE_CTX_GRX_P6: length 54.2
  BOTTOM w0.102: UV1.R38 132.13,127.74 132.13,127.43 132.32,127.24 132.32,125.96 130.75,124.39 130.75,123.78 130.76,123.78 130.76,123.75
  BOTTOM w0.109: C26.2 94.07,111.17 95.07,111.17 v4(95.59,111.69) 98.16,114.26 114.24,114.26 114.52,113.98 114.52,113.95 114.96,113.51 114.99,113.51 117.31,111.19 125.19,111.19 130.76,116.76 130.76,123.75
PCIE_CTX_GRX_P7: length 55.9
  BOTTOM w0.102: UV1.P35 131.15,128.77 131.15,128.14 131.2,128.09 131.2,127.67 131.07,127.54 131.07,125.74 130.05,124.72 130.05,123.78 130.06,123.78 130.06,123.75
  BOTTOM w0.109: C25.2 92.07,112.25 92.09,112.28 92.81,112.28 92.83,112.26 93.45,112.26 93.48,112.28 94.81,112.28 v4(97.17,114.63) 97.97,115.43 105.61,115.43 106.06,114.98 114.53,114.98 117.61,111.89 124.9,111.89 130.06,117.05 130.06,123.75
PCIE_PRX_C_DTX_N3: length 3.4
  TOP w0.102: CL9.2 27.81,27.05 28.05,27.05 28.24,26.86 28.24,25.78 28.45,25.58 28.66,25.58 28.74,25.66 UL1.29
PCIE_PRX_C_DTX_P3: length 3.5
  TOP w0.102: UL1.30 28.74,25.26 28.63,25.36 28.34,25.36 v4(28.16,25.54) 28.02,25.68 28.02,26.77 27.96,26.84 27.81,26.84 CL11.2
PCIE_PRX_DTX_N2: length 160.8
  TOP w0.089: v2(120.18,81.12) 120.18,81.35 U4.AT31
  IN2 w0.127: v2(197.41,152.5) 197.18,152.73 196.75,152.73 196.34,152.31 196.34,131.39 197.51,130.22 197.51,123.04 191.65,117.18 191.65,115.92 183.96,108.23 160.02,108.23 157.81,110.44 140.3,110.44 139.55,109.69 130.69,109.69 130.07,109.07 126.77,109.07 125.31,107.6 125.03,107.6 123.33,105.9 115.5,105.9 113.7,104.1 113.7,103.63 114.03,103.3 v2(114.03,103.29)
  BOTTOM w0.089: 115.45,81.11 115.46,81.1 115.46,81.09 115.51,81.04 115.51,81.04 115.95,80.59 120.37,80.59 120.52,80.73 120.52,80.9 120.29,81.12 v2(120.18,81.12)
  BOTTOM w0.102: v2(114.03,103.29) 113.66,102.92 113.66,102.76 113.84,102.59 114.73,102.59 115.62,101.7 115.62,98 113.87,96.25 113.87,93.21 113.87,92.97 114.49,92.35 114.49,88.22 113.87,87.61 113.87,84.48 113.49,84.1 113.49,83.07 115.45,81.11 ; v2(197.41,152.5) 197.78,152.86 197.92,152.86 198.01,152.77 198.01,152.48 198.09,152.4 JWLN1.23
PCIE_PRX_DTX_N3: length 161.5
  TOP w0.089: v2(118.95,81.16) 119.21,80.89 U4.AW33
  TOP w0.102: CL9.1 26.22,27.18 25.84,27.18 v2(25.77,27.25)
  IN2 w0.089: v2(118.95,81.16) 118.84,81.05 118.84,80.74 118.53,80.43 117.95,80.43 115.82,78.3 115.82,74.85
  IN2 w0.127: 115.82,74.85 115.82,73.08 117.06,71.84 117.06,67.23 122.31,61.99 122.31,30.9 114.43,23.02 46.74,23.02 46.02,22.3 41.17,22.3 39.3,24.17 34.2,24.17 32.75,22.72 31.11,22.72 29.65,24.17 26.92,24.17 24.96,26.14 24.96,26.79 25.32,27.15 25.67,27.15 v2(25.77,27.25)
PCIE_PRX_DTX_P2: length 160.9
  TOP w0.089: U4.AR31 120.79,81.36 v2(120.79,81.15)
  IN2 w0.127: v2(197.41,153.08) 197.31,152.98 196.64,152.98 196.08,152.42 196.08,131.29 197.25,130.11 197.25,123.14 191.4,117.28 191.4,116.03 183.85,108.48 160.12,108.48 157.91,110.69 140.2,110.69 139.45,109.94 130.58,109.94 129.97,109.33 126.67,109.33 125.2,107.86 124.92,107.86 123.22,106.16 115.4,106.16 113.45,104.21 v2(113.45,103.29)
  BOTTOM w0.089: 115.3,80.96 115.87,80.39 120.46,80.39 120.72,80.65 120.72,81.08 v2(120.79,81.15)
  BOTTOM w0.102: JWLN1.25 198.07,153.2 197.95,153.08 v2(197.41,153.08) ; 115.3,80.96 113.27,82.98 113.27,84.19 113.65,84.57 113.65,87.7 114.27,88.31 114.27,92.26 113.65,92.88 113.65,93.3 113.65,93.3 113.65,96.34 115.4,98.09 115.4,101.61 114.64,102.37 113.75,102.37 113.45,102.67 v2(113.45,103.29)
PCIE_PRX_DTX_P3: length 161.4
  TOP w0.089: v2(118.34,81.14) 118.45,81.14 118.74,80.85 118.74,80.72 U4.AY33
  TOP w0.102: CL11.1 26.77,26.72 26.77,26.87 26.68,26.96 26.07,26.96 25.77,26.67 v2(25.77,26.67)
  IN2 w0.089: v2(118.34,81.14) 118.47,81.14 118.63,80.98 118.63,80.83 118.44,80.64 117.81,80.64 115.57,78.41 115.57,74.85
  IN2 w0.127: 115.57,74.85 115.57,72.97 116.81,71.74 116.81,67.13 122.05,61.88 122.05,31.01 114.33,23.28 46.64,23.28 45.91,22.55 41.27,22.55 39.41,24.42 34.09,24.42 32.64,22.97 31.21,22.97 29.76,24.43 27.03,24.43 25.21,26.24 25.21,26.68 25.43,26.9 25.54,26.9 v2(25.77,26.67)
PCIE_PTX_C_DRX_N2: length 176.4
  IN2 w0.127: v2(153.41,106.85) 153.58,107.02 156.77,107.02 157.89,105.89 186,105.89 193.99,113.87 193.99,116.21 199.66,121.89 199.66,138.01 200.55,138.9 200.55,141.86 199.85,142.56 199.85,147.72 201.8,149.68 201.8,157.17 v2(201.89,157.26)
  BOTTOM w0.102: v2(153.41,106.85) 153.03,106.85 152.86,106.69 152.86,101.05 150.83,99.02 150.83,75.83 148.08,73.08 148.08,72.58 144.56,69.06 127.36,69.06 125.46,67.17 117.32,67.17 116.76,67.74 116.23,67.74 116.21,67.73 115.5,67.73 115.49,67.74 111.79,67.74 110.59,68.94 110.59,72.2 C125.1 ; JWLN1.31 201,155.6 201.89,156.49 v2(201.89,157.26)
PCIE_PTX_C_DRX_N3: length 135.4
  TOP w0.102: UL1.36 32.09,24.09 32.02,24.02 32.02,23.79 v2(32.26,23.55)
  IN2 w0.127: v2(111.72,69.31) 111.86,69.17 112.53,69.17 113.01,68.7 113.01,66.46 119.54,59.93 119.54,31.95 113.39,25.8 44.06,25.8 43.19,24.93 32.87,24.93 32.11,24.17 32.11,23.7 v2(32.26,23.55)
  BOTTOM w0.102: C122.1 112.27,70.03 112.27,69.27 112.13,69.13 111.9,69.13 v2(111.72,69.31)
PCIE_PTX_C_DRX_P2: length 176.3
  IN2 w0.127: v2(201.31,157.26) 201.55,157.02 201.55,149.78 199.6,147.83 199.6,142.46 200.3,141.75 200.3,139 199.41,138.11 199.41,121.99 193.73,116.31 193.73,113.98 185.9,106.14 158,106.14 156.87,107.27 153.58,107.27 v2(153.41,107.44)
  BOTTOM w0.102: v2(201.31,157.26) 201.68,156.89 201.68,156.58 200.91,155.82 200.39,155.82 200.27,155.93 200.27,156.25 200.12,156.4 JWLN1.33 ; C123.1 110.92,72.45 110.81,72.33 110.81,69.03 111.88,67.95 v4(115.86,67.95) 116.85,67.95 117.41,67.39 125.37,67.39 127.27,69.28 144.47,69.28 147.87,72.67 147.87,73.17 150.62,75.92 150.62,99.11 152.65,101.14 152.65,106.78 152.94,107.07 153.05,107.07 v2(153.41,107.44)
PCIE_PTX_C_DRX_P3: length 135.4
  TOP w0.102: v2(31.67,23.54) 31.81,23.67 31.81,23.95 31.69,24.07 UL1.35
  IN2 w0.127: v2(111.72,68.73) 111.91,68.92 112.43,68.92 112.76,68.59 112.76,66.35 119.29,59.82 119.29,32.06 113.28,26.06 43.96,26.06 43.08,25.18 32.77,25.18 31.86,24.27 31.86,23.72 v2(31.67,23.54)
  BOTTOM w0.102: v2(111.72,68.73) 111.9,68.91 112.22,68.91 112.48,69.18 112.48,70.04 C124.1
PCIE_PTX_DRX_N2: length 13.2
  TOP w0.102: v2(110.76,74.7) 110.94,74.89 110.94,77.92 113.88,80.86 v4(114.43,80.86) 116.8,80.86 117.08,81.14 117.2,81.14 117.34,81 117.34,80.82 117.3,80.77 U4.BD33
  BOTTOM w0.102: C125.2 110.69,73.7 110.69,73.99 110.93,74.23 110.93,74.53 v2(110.76,74.7)
PCIE_PTX_DRX_N3: length 12.4
  TOP w0.102: U4.BE34 116.58,80.45 116.34,80.45 116.23,80.34 116.23,80.03 116.15,79.94 115.04,79.94 v4(114.45,79.35) 112.28,77.18 112.28,72.52 v2(112.09,72.33)
  BOTTOM w0.102: C122.2 112.23,71.3 112.37,71.44 112.37,72.04 v2(112.09,72.33)
PCIE_PTX_DRX_P2: length 13.1
  TOP w0.102: U4.BB33 117.58,80.75 117.28,80.45 117.03,80.45 116.83,80.64 114.74,80.64 114.73,80.63 114.15,80.63 114.14,80.64 113.97,80.64 111.16,77.83 111.16,74.89 v2(111.34,74.7)
  BOTTOM w0.102: v2(111.34,74.7) 111.15,74.5 111.15,74.14 110.91,73.9 110.91,73.72 C123.2
PCIE_PTX_DRX_P3: length 12.4
  TOP w0.102: v2(112.67,72.33) 112.49,72.51 112.49,77.09 114.11,78.71 114.39,78.98 114.41,78.98 114.82,79.39 114.82,79.41 115.13,79.73 116.28,79.73 116.59,80.05 116.83,80.05 117.05,80.26 117.5,80.26 U4.BC34
  BOTTOM w0.102: v2(112.67,72.33) 112.59,72.25 112.59,71.55 C124.2
PCIE_WAKE#: length 302.4
  TOP w0.089: U4.K3 131.28,93.69 130.99,93.98 130.99,95.09 131.42,95.52 v2(131.68,95.52)
  TOP w0.102: RL6.1 44.26,26.89 v2(44.62,26.52)
  IN2 w0.127: v2(131.68,95.52) 131.71,95.52 132.27,96.07 132.27,96.89 133.9,98.52 135.64,98.52 136.14,98.03 137.21,98.03 138.04,98.85 147.29,98.85 149.96,96.19 152.85,96.19 v2(153.83,95.21) ; v2(201,143.98) 201,143.62 201.7,142.92 201.7,138.42 200.81,137.53 200.81,117.93 192.88,110 192.88,103.7 192.1,102.92 164.93,102.92 163.11,104.75 156.94,104.75 v2(156.1,105.58)
  BOTTOM w0.102: v2(44.62,26.52) 45.55,26.52 48.16,29.13 92.09,29.13 96.05,25.17 116.51,25.17 120.24,28.9 120.24,48.02 134.77,62.55 135.17,62.55 136.77,64.16 136.77,66.55 138.32,68.1 145.74,68.1 146.97,69.33 v3(148.69,69.33) 151.87,69.33 153.26,70.71 153.26,75.19 154.38,76.32 154.38,79.56 154.88,80.06 154.88,81.83 154.7,82.01 154.7,88.27 154.23,88.74 154.23,91.12 153.83,91.53 v2(153.83,95.21) 153.83,98.08 156.1,100.35 v2(156.1,105.58) ; v2(131.68,95.52) 131.68,95.57 132.31,96.2 RP10.6 ; v2(201,143.98) 201,140.37 200.34,139.71 197.84,139.71 197.72,139.6 197.06,139.6 R41.1
PECI_KB9012: length 4.7
  TOP w0.102: v1(171.38,70.47) 171.38,71.73 R669.1 170.79,72.33 U31.118
PEG_CLKREQ#_R: length 4.5
  TOP w0.102: v2(124.24,92.36) 124.41,92.19 U4.AF6
  BOTTOM w0.089: v2(124.24,92.36) 124.95,92.36 125.03,92.44 125.38,92.44 125.55,92.28 125.94,92.28 126.39,92.72 R177.2
  BOTTOM w0.102: v2(124.24,92.36) 124.2,92.4 124.2,93.35 R178.1
PEG_RCOMP: length 6.1
  TOP w0.305: R1.2 v1(79.64,99.81) 80.33,99.81 v2(81.93,101.41)
  BOTTOM w0.305: JCPU1.E23 81.51,101.82 v2(81.93,101.41)
PHASE1_VGA: length 10.2
  IN2 w0.508: v4(183.96,140.63) 183.96,140.62 182.18,142.4 180.7,142.4 180,143.11 v2(180,145.53)
  BOTTOM w0.508: v2(180,145.53) 179.55,145.08 v1(178.92,145.08) PQ802.3
PHASE2_VGA: length 6.8
  IN2 w0.508: v2(182.9,136.87) 180.87,136.87 v4(179.48,135.48)
  BOTTOM w0.508: PQ801.3 177.54,136.95 v1(178.52,135.97) 179.01,135.48 v4(179.48,135.48)
PLT_RST#: length 404.4
  TOP w0.102: v2(139.37,114.93) 139.37,115.19 138.95,115.61 137.32,115.61 134.65,118.27 134.65,124.13 134.47,124.31 UV2.1 ; RL4.2 v2(36.79,25.6) 36.77,25.61 34.98,25.61 34.93,25.66 UL1.2 ; U4.Y11 127.43,89.81 v2(127.75,90.12) ; v2(191.5,81.95) 191.17,81.95 190.84,82.28 180.58,82.28 v2(180.13,81.84) 178.58,81.84 178.1,81.36 U31.13
  IN1 w0.127: v2(191.5,81.95) 191.82,81.95 192.68,82.81 192.68,86.8 199.66,93.79 199.66,133.78 203.16,137.28 207.69,137.28 208.11,137.28 209.14,138.3 209.14,141.78 209.14,141.78 v2(209.14,152)
  IN2 w0.089: 133.94,94.79 133.2,94.05 132.42,94.05 131.64,93.27 127.84,93.27 127.22,92.65 127.22,90.65 v2(127.75,90.12)
  IN2 w0.127: v2(177.7,57.93) 177.69,57.94 v2(156.25,57.94) ; v2(133.28,97.19) 133.74,97.65 134.68,97.65 135.16,97.16 135.16,96.01 133.94,94.79 ; v2(140.24,101.19) 143.35,101.19 143.77,100.77 148.74,100.77 151.21,98.3 156.42,98.3 158.91,95.81 158.91,94.17 161.2,91.88 161.81,91.88 163.27,90.42 174.37,90.42 174.84,89.95 176.56,89.95 177.03,90.42 179.11,90.42 v2(179.15,90.38)
  BOTTOM w0.102: v2(156.25,57.94) 131.52,57.94 121.2,47.62 121.2,28.5 116.91,24.21 95.65,24.21 91.69,28.17 48.57,28.17 45.86,25.46 43.02,25.46 42.87,25.61 41.79,25.61 41.02,24.84 37.55,24.84 v2(36.79,25.6) ; v2(177.7,57.93) 177.7,68.43 178.72,69.45 178.72,73.56 180.61,75.45 180.61,81.35 v2(180.13,81.84) 180.13,84.72 179.45,85.4 179.45,86.21 179.9,86.67 179.9,89.62 v2(179.15,90.38) ; JWLN1.22 209.13,152 v2(209.14,152) ; v2(133.28,97.19) 133.93,97.84 R156.1 134.97,100.2 C494.1 135.31,99.86 v1(137.5,99.86) 138.91,99.86 v2(140.24,101.19) 140.24,107.16 137.76,109.64 137.76,113.32 v2(139.37,114.93)
PLUG_IN: length 199.6
  TOP w0.254: RA7.2 RA8.2 v2(161.18,41.98)
  IN1 w0.254: v2(15.87,17.28) 15.06,18.08 8.93,18.08 JHP1.5
  BOTTOM w0.254: v2(15.87,17.28) 22.82,17.28 26.24,20.7 32.18,20.7 33.87,22.39 39.72,22.39 40.29,21.82 44.27,21.82 49.85,27.4 90.47,27.4 94.22,23.65 117.14,23.65 121.76,28.27 121.76,47.39 131.75,57.37 156.12,57.37 156.62,56.87 156.62,55.26 158.87,53.02 158.87,44.85 161.18,42.54 v2(161.18,41.98)
PM_CLKRUN#: length 4.4
  TOP w0.089: v2(121.29,91.37) 121.52,91.6 U4.AN7
  BOTTOM w0.089: v1(120.42,92.38) 120.31,92.28 119.35,92.28 119.13,92.49 R172.2
  BOTTOM w0.102: v1(120.42,92.38) 120.64,92.38 120.86,92.16 120.86,91.8 v2(121.29,91.37)
