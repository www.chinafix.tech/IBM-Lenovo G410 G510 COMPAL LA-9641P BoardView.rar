# Allegro board IBM-Lenovo G410 G510 COMPAL LA-9641P BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CRT_HSYNC: length 165
  TOP w0.089: U4.N42 130.06,76.35 130.34,76.07 130.34,75.83 130.17,75.66 130.17,73.97 v2(129.61,73.41)
  IN2 w0.127: v2(13.95,118.92) 13.9,118.87 13.9,107.19 v2(14.61,106.47)
  BOTTOM w0.102: v2(129.61,73.41) 128.59,73.41 127.34,72.16 123.34,72.16 122.51,71.33 v1(120.09,71.33) 115.91,71.33 111.97,75.27 103.91,75.27 100.43,71.79 63.47,71.79 63.13,71.45 36.97,71.45 35.45,72.96 35.45,86.74 32.25,89.94 29.47,89.94 29.33,90.08 21.7,90.08 16.3,95.49 16.3,102.16 14.87,103.59 14.87,106.22 v2(14.61,106.47) ; v2(13.95,118.92) U10.15
CRT_IREF: length 3.3
  TOP w0.102: v2(127.77,77.65) 127.99,77.44 U4.U40
  BOTTOM w0.089: R132.2 127.64,76.14 128.24,76.74 v1(128.24,77.35) 128.24,77.53 128.12,77.65 v2(127.77,77.65)
CRT_VSYNC: length 164.1
  TOP w0.089: U4.N44 129.99,75.91 129.99,74.46 v2(129.58,74.05)
  IN2 w0.127: v2(14.52,118.51) 14.36,118.35 14.36,107.52 v2(14.61,107.27)
  BOTTOM w0.102: v2(14.61,107.27) 15.27,106.61 15.27,104.14 16.71,102.7 16.71,95.66 21.87,90.49 29.5,90.49 29.64,90.35 32.42,90.35 35.86,86.91 35.86,73.13 37.13,71.85 62.96,71.85 63.31,72.2 100.26,72.2 103.74,75.68 112.14,75.68 116.08,71.74 v1(116.33,71.74) 122.35,71.74 123.2,72.59 127.2,72.59 128.65,74.05 v2(129.58,74.05) ; U10.13 12.68,119.26 13.43,118.51 v2(14.52,118.51)
CSA0#_0: length 37.5
  TOP w0.102: v2(110.16,134.35) 110.25,134.44 113.19,134.44 113.32,134.31 113.32,133.77 113.19,133.64 112.43,133.64 UV5.L2 ; v2(128.02,137.11) 128.62,137.11 128.75,137.23 128.75,137.46 128.62,137.58 127.15,137.58 126.97,137.76 125.47,137.76 124.51,138.72 122.46,138.72 122.36,138.62 122.36,138.49 122.24,138.38 121.99,138.38 121.9,138.47 121.9,138.58 121.77,138.71 121.61,138.71 121.48,138.58 121.48,138.44 121.42,138.38 120.82,138.38 120.81,138.37
  TOP w0.127: v2(114.61,139.88) 114.61,140.1 114.81,140.3 116.39,140.3 116.53,140.15 116.53,139.68 116.76,139.46 117.3,139.46 117.42,139.34 117.42,138.8 118.11,138.1 120.55,138.1 120.81,138.37
  IN1 w0.102: 114.07,138.37 114.06,138.36
  IN1 w0.127: v2(110.16,134.35) 110.59,134.35 111.56,135.31 111.56,135.73 113.19,137.36 113.86,137.36 114.06,137.56 114.06,138.36
  IN1 w0.157: v2(114.61,139.88) 114.69,139.8 114.69,138.68 114.56,138.55 114.26,138.55 114.07,138.37
  BOTTOM w0.102: v2(110.16,134.35) 109.99,134.35 109.61,133.97 109.19,133.97 108.9,133.68 108.72,133.68 108.57,133.84 108.57,134.01 108.77,134.21 108.77,134.39 108.6,134.56 108.42,134.56 108.29,134.43 107.03,134.43 106.92,134.32 106.92,134.16 107.03,134.05 UV6.L2 ; UV1.K24 128.05,137.14 v2(128.02,137.11)
CSA1#_0: length 34.7
  TOP w0.102: UV7.L2 107.47,150.32 107.88,149.91 108.33,149.91 108.41,150 108.41,150.25 108.54,150.38 108.92,150.38 109.05,150.25 v2(109.05,150.02) ; 120.81,144.92 121.4,144.92 121.51,144.82 124.65,144.82 124.87,145.04 v1(128.09,145.04) 128.46,145.04 128.58,144.91 128.58,144.43 128.46,144.3 v2(128.12,144.3)
  TOP w0.127: v2(114.77,144.63) 115.07,144.92 115.34,144.92 115.47,144.8 115.47,144.43 115.6,144.31 115.85,144.31 115.98,144.43 115.98,144.8 116.1,144.92 116.36,144.92 116.48,144.8 116.48,144.43 116.61,144.31 116.87,144.31 116.99,144.43 116.99,144.8 117.12,144.92 120.81,144.92
  IN1 w0.102: v2(109.05,150.02) 109.13,150.02 109.54,149.61 109.94,149.61 110.14,149.41
  IN1 w0.127: 113.55,145.39 112.9,146.03 112.9,146.17 111.54,147.53 111.54,148.02 110.14,149.41
  IN1 w0.157: 113.55,145.39 113.88,145.39 114.09,145.17 114.23,145.17 v2(114.77,144.63)
  BOTTOM w0.102: UV8.L2 111.66,150 110.4,150 110.02,150.38 109.57,150.38 109.22,150.02 v2(109.05,150.02) ; UV1.M13 129.78,146.67 129.27,146.16 129.27,145.35 129.13,145.21 128.82,145.21 128.42,144.82 128.42,144.61 v2(128.12,144.3)
CSB0#_0: length 38.1
  TOP w0.102: v2(130.87,150.28) 131.29,150.7 131.29,152.47 v1(131.44,152.61) 131.9,153.07 131.9,154.89 131.4,155.38 131.4,157.04 131.29,157.16 130.37,157.16 130.26,157.27 130.26,157.31 ; v2(130.47,167.83) 130.49,167.81 130.49,166.29 UV9.L2
  TOP w0.127: v2(136.62,164.07) 136.65,164.07 137,163.71 137,163.57 136.93,163.5 136.47,163.5 136.43,163.54 135.85,163.54 135.55,163.24 135.55,162.43 132.44,159.32 132.44,158.67 132.35,158.58 131.91,158.58 131.85,158.65 131.85,158.96 131.76,159.05 131.36,159.05 131.27,158.96 131.27,157.72 131.17,157.62 130.87,157.62 130.77,157.72 130.77,158.93 130.64,159.05 130.36,159.05 130.26,158.95 130.26,157.31
  IN1 w0.127: v2(130.47,167.83) 130.47,167.61 131.49,166.58 131.64,166.58 132.85,165.37 134.28,165.37 134.66,164.98
  IN1 w0.157: 134.66,164.98 134.81,164.84 134.81,164.82 135.2,164.42 136.27,164.42 v2(136.62,164.07)
  BOTTOM w0.102: UV10.L2 130.56,170.38 130.56,169.55 130.09,169.08 130.09,168.38 130.47,168 v2(130.47,167.83) ; UV1.P10 131.45,149.69 v2(130.87,150.28)
CSB1#_0: length 38.3
  TOP w0.102: UV12.L2 147.5,171.16 147.4,171.26 147.21,171.26 147.11,171.16 147.11,170.15 147.18,170.08 147.18,168.93 v2(147.21,168.9)
  IN1 w0.102: 146.65,167.75 146.79,167.9 146.79,168.41 146.95,168.57 147.14,168.57 147.21,168.63 v2(147.21,168.9)
  IN1 w0.127: 146.65,167.75 146.22,167.32 145.4,167.32 144.29,166.21 143.15,166.21 142.18,165.25 142.18,165
  IN1 w0.157: 142.18,165 141.87,164.69 141.86,164.69 141.83,164.67 v2(141.83,164.67)
  IN2 w0.102: v2(139.13,149.93) 139.93,150.73 139.93,152.25 140.93,153.24 140.93,156.19 141.49,156.75 141.49,157.31
  IN2 w0.157: v2(141.83,164.67) 141.83,164.8 142.26,165.24 144.24,165.24 144.34,165.14 144.34,164.44 144.24,164.34 143.26,164.34 142.84,163.92 142.84,163.65 143.11,163.38 143.86,163.38 144.01,163.23 144.01,162.91 143.86,162.75 142.83,162.75 142.67,162.6 142.67,161.22 142.19,160.74 141.66,160.74 141.49,160.57 141.49,157.31
  BOTTOM w0.102: v2(147.21,168.9) 147.21,168.73 147.56,168.38 147.56,167.28 147.18,166.9 147.18,166.29 UV11.L2 ; UV1.AD10 139.4,149.93 v2(139.13,149.93)
CSCOMP: length 52.8
  TOP w0.254: v2(18.09,115.1) 18.09,115.77 17.93,115.93 17.93,117.69 18.34,118.1 19.21,118.1 19.49,117.82 PR901.1 PC901.1 21.33,117.39 PC910.1
  BOTTOM w0.203: 21.56,118 21.56,118.02 21.89,118.35 PU901.27
  BOTTOM w0.254: PH901.2 42.01,128.83 31.83,128.83 31.45,129.21 18.84,129.21 16.02,126.39 v1(16.02,124.44) 16.02,117.5 17.85,115.67 17.85,115.34 v2(18.09,115.1) 18.22,115.1 18.51,115.39 PR913.2 19.1,115.76 19.84,116.51 19.84,116.94 20.84,117.94 21.5,117.94 21.56,118
CSP1: length 7.1
  TOP w0.254: PR928.1 25.77,114.51 PR931.2 ; PR928.1 25.59,114.52 25.24,114.86 25.24,116.47 v1(25.04,116.67) 24.72,116.99 v2(24.72,117.1) ; PR928.1 PC918.2
  BOTTOM w0.203: v2(24.72,117.1) 24.61,117.1 23.89,117.82 PU901.22
CSP2: length 7.2
  TOP w0.254: PR927.1 24.14,113.64 PR930.2 ; PR927.1 24.54,114.55 24.73,114.74 v2(24.73,116.09) ; PR927.1 23.23,114.55 PC917.2
  BOTTOM w0.203: PR932.2 24.14,116.6 23.49,117.24 v1(23.49,117.6) PU901.23
  BOTTOM w0.254: v2(24.73,116.09) 24.73,116.1 24.25,116.58 PR932.2
CSP3: length 7.1
  TOP w0.254: PR926.1 21.33,113.72 PR929.2 ; PR926.1 21.89,114.56 22.08,114.75 22.08,116.24 v1(22.38,116.54) 22.65,116.81 v2(22.65,117.08) ; PR926.1 20.44,114.56 PC916.2
  BOTTOM w0.203: v2(22.65,117.08) 23.09,117.52 PU901.24
CSREF: length 27.8
  TOP w0.254: PC917.1 24.14,115.46 PR927.2 ; PC917.1 23.22,116.57 23.29,116.64 PC911.1 ; PC917.1 22.83,115.46 22.61,115.23 22.61,114.49 22.55,114.43 v2(22.59,114.43) ; PC911.1 22.81,118.29 22.59,118.07 v2(22.59,117.73) ; PC911.1 25.17,118.29 25.78,117.69 PR928.2 PC918.1 27.19,115.43 27.4,115.22 v2(27.4,113.64) PR939.1 ; v2(19.62,114.44) 19.27,114.44 19.17,114.55 v1(19.17,114.88) 19.17,115.23 19.42,115.48 PC916.1 21.32,115.48 PR926.2 ; v2(24.75,112.67) 24.74,112.69 PR941.1
  IN1 w0.254: v2(19.62,114.44) 19.63,114.43 v2(22.59,114.43)
  IN2 w0.254: v2(27.4,113.64) 26.97,113.21 25.29,113.21 v2(24.75,112.67)
  BOTTOM w0.203: v2(22.59,117.73) 22.69,117.83 PU901.25
  BOTTOM w0.254: PR944.1 22.35,114.97 22.55,114.77 22.55,114.43 v2(22.59,114.43)
CSSUM: length 13
  TOP w0.254: v2(22.08,117.36) 22.08,116.89 21.66,116.47 PC910.2 21.33,116.47 PC901.2 19.5,116.47 PR911.2
  BOTTOM w0.203: PU901.26 22.29,118.19 22.08,117.98 v2(22.08,117.36)
  BOTTOM w0.254: v2(22.08,117.36) 21.06,117.36 20.87,117.16 v1(20.87,116.71) PR918.1 23.75,115.52 PR919.1 26.13,115.51 PR920.1
DAC_BLU: length 162
  TOP w0.089: U4.T45 128.84,73.07 128.92,73 128.92,72.63
  TOP w0.102: RP22.5 12.2,107.48 12.02,107.3 v2(11.83,107.3) ; v2(128.56,68.01) 129.33,68.78 129.33,71.04 128.92,71.46 RP23.5 128.92,72.63
  BOTTOM w0.102: L32.1 10.94,108.82 C524.1 11.83,107.93 v2(11.83,107.3) 11.83,103.55 14.16,101.21 14.16,94.68 20.98,87.86 31.39,87.86 33.31,85.94 33.31,72.16 36.1,69.36 63.99,69.36 64.34,69.71 106.45,69.71 111.07,65.09 v1(124.76,65.09) 125.97,65.09 128.56,67.68 v2(128.56,68.01)
DAC_GRN: length 160.1
  TOP w0.089: U4.U44 128.42,75.95 128.42,72.63
  TOP w0.102: RP23.6 v2(128.42,72.57) 128.42,72.63 ; RP22.6 12.7,107.31 v2(12.71,107.3)
  IN2 w0.127: v2(127.74,68.02) 128,68.28 128,72.15 v2(128.42,72.57)
  BOTTOM w0.102: L31.1 C523.1 12.71,108.79 v2(12.71,107.3) 12.71,103.53 14.77,101.47 14.77,94.94 14.83,94.88 21.23,88.47 31.64,88.47 33.92,86.2 33.92,72.41 36.35,69.97 63.74,69.97 64.08,70.32 106.71,70.32 111.32,65.7 v1(117.66,65.7) 125.72,65.7 127.74,67.72 v2(127.74,68.02)
DAC_RED: length 157.6
  TOP w0.089: U4.V45 128.03,73.14 127.92,73.02 127.92,72.63
  TOP w0.102: v2(13.44,107.3) 13.2,107.55 RP22.7 ; 127.92,72.63 RP23.7 127.92,71.4 127.81,71.3 127.24,71.3 127.04,71.09 127.04,68.15 v2(126.94,68.06)
  BOTTOM w0.102: v2(126.94,68.06) 126.94,67.78 125.46,66.31 v1(113.81,66.31) 111.58,66.31 106.96,70.93 63.83,70.93 63.49,70.58 36.61,70.58 34.59,72.6 34.59,86.39 31.89,89.08 21.49,89.08 15.44,95.13 15.44,101.75 13.44,103.74 v2(13.44,107.3) 13.44,107.5 13.95,108.01 C522.1 13.96,108.81 L30.1
DDR3_DRAMRST#: length 103.3
  IN1 w0.127: v2(43.22,48.01) 43.22,40.1 v2(42.5,39.38) 41.74,38.62 31.5,38.62 28.96,41.15 28.96,84.66 29.17,84.86 29.17,87.2 31.87,89.91 v2(33.58,89.91)
  BOTTOM w0.102: v2(42.5,39.38) 43.22,38.67 JDIMM2.30 ; JDIMM1.30 v2(43.22,48.01) ; v2(33.58,89.91) 36.63,86.86 v1(36.63,83.63) 36.63,78.24 39.78,75.08 R46.2
DDR_A_BS0: length 56.7
  IN1 w0.089: v2(69.04,84.4) 69.04,84.98 68.91,85.11 68.66,85.11 68.54,84.98 68.54,84.07 69.78,82.83 70.24,82.83 70.61,82.46 71.35,82.46 71.44,82.36 71.44,79.28 70.96,78.8 70.96,77.14
  IN1 w0.208: v2(69.84,55.03) 70.31,55.5 70.31,57.8 70.96,58.44 70.96,63.15 71.17,63.35 71.62,63.35 71.75,63.48 71.75,64.06 71.62,64.19 71.17,64.19 70.96,64.4 70.96,64.81 71.17,65.02 72.87,65.02 72.99,65.15 72.99,65.73 72.87,65.85 71.17,65.85 70.96,66.06 70.96,66.48 71.17,66.69 72.87,66.69 72.99,66.81 72.99,67.39 72.87,67.52 71.17,67.52 70.96,67.73 70.96,68.14 71.17,68.35 72.87,68.35 72.99,68.48 72.99,69.06 72.87,69.19 71.17,69.19 70.96,69.39 70.96,69.81 71.17,70.02 72.87,70.02 72.99,70.15 72.99,70.73 72.87,70.85 71.17,70.85 70.96,71.06 70.96,71.48 71.17,71.69 72.87,71.69 72.99,71.81 72.99,72.39 72.87,72.52 71.17,72.52 70.96,72.73 70.96,77.14
  BOTTOM w0.089: v2(69.04,84.4) 68.58,83.94 JCPU1.V5
  BOTTOM w0.165: JDIMM1.109 69.32,55.67 69.84,55.15 v2(69.84,55.03)
DDR_A_BS1: length 59
  IN1 w0.089: 73.03,77.14 73.03,78.38 72.46,78.95 72.46,82.56 72.21,82.81 70.77,82.81 70.18,83.41 v2(70.04,83.41)
  IN1 w0.208: 73.03,77.14 73.03,73.9 73.16,73.77 74.1,73.77 74.22,73.64 74.22,72.47 74.35,72.35 75.53,72.35 75.65,72.22 75.65,71.59 75.53,71.46 74.35,71.46 74.22,71.33 74.22,70.75 74.35,70.63 76.7,70.63 76.82,70.5 76.82,69.93 76.7,69.8 75.83,69.8 75.7,69.67 75.7,69.15 75.83,69.02 76.7,69.02 76.82,68.9 76.82,68.32 76.7,68.19 75.91,68.19 75.7,67.98 75.7,67.57 75.91,67.36 76.53,67.36 76.66,67.23 76.66,66.65 76.53,66.52 75.91,66.52 75.7,66.32 75.7,65.7 72.21,62.2 72.21,57.95 71.54,57.29 71.54,54.96 71.02,54.43 71.02,53.38 70.89,53.26 70.46,53.26 70.34,53.13 70.34,52.55 70.46,52.42 70.89,52.42 71.02,52.3 71.02,50.19 70.89,50.06 70.43,50.06 70.3,50.19 70.3,51.53 70.18,51.66 69.97,51.66 69.84,51.79 v2(69.84,51.98)
  BOTTOM w0.089: JCPU1.U5 69.51,83.94 v2(70.04,83.41)
  BOTTOM w0.165: JDIMM1.108 69.02,50.6 68.85,50.76 67.41,50.76 67.28,50.89 67.28,51.27 67.41,51.39 68.89,51.39 69.02,51.52 69.02,51.85 69.14,51.98 v2(69.84,51.98)
DDR_A_BS2: length 54
  IN1 w0.089: v2(62.04,79.5) 61.75,79.5 60.15,77.9 58.28,77.9 57.51,77.14
  IN1 w0.208: v2(57.8,53.5) 57.37,53.5 57.24,53.38 57.24,53.02 57.11,52.89 56.59,52.89 56.46,53.02 56.46,54.02 56.59,54.15 56.96,54.15 57.09,54.28 57.09,54.87 56.96,54.99 56.59,54.99 56.46,55.12 56.46,60.97 53.31,64.12 53.31,64.68 53.1,64.89 52.54,64.89 52.42,65.01 52.42,65.59 52.54,65.72 53.1,65.72 53.31,65.93 53.31,66.43 53.18,66.56 51.85,66.56 51.72,66.69 51.72,67.35 51.85,67.48 53.18,67.48 53.31,67.61 53.31,68.15 53.18,68.28 51.85,68.28 51.72,68.41 51.72,68.97 51.85,69.1 53.18,69.1 53.31,69.22 53.31,69.7 53.18,69.83 51.85,69.83 51.72,69.96 51.72,70.46 51.85,70.58 53.18,70.58 53.31,70.71 53.31,71.24 53.18,71.36 52.56,71.36 52.43,71.49 52.43,72.06 52.56,72.18 53.18,72.18 53.31,72.31 53.31,72.93 57.51,77.14
  BOTTOM w0.089: JCPU1.AD1 62.48,79.94 v2(62.04,79.5)
  BOTTOM w0.165: v2(57.8,53.5) 58.42,53.5 59.79,54.88 59.79,55.09 59.92,55.22 60.16,55.22 60.29,55.34 60.29,55.6 60.16,55.73 59.89,55.73 59.76,55.86 59.76,56.18 59.89,56.3 60.11,56.3 60.32,56.51 JDIMM1.79
DDR_A_CAS#: length 49.8
  IN1 w0.089: v2(70.04,86.41) 70.04,86.52 70.17,86.65 70.55,86.65 70.68,86.52 70.68,86.05 70.55,85.93 69.81,85.93 69.68,85.8 69.68,85.26 70,84.93 70.26,84.93 70.44,84.76 70.44,84.15 70.76,83.83 71.8,83.83 73.46,82.18 73.46,78.91 74.26,78.11 74.26,77.14
  IN1 w0.208: v2(72.33,53.25) 72.61,53.25 72.8,53.45 72.8,56.81 73.46,57.46 73.46,61.71 78.05,66.31 78.05,71.56 74.26,75.35 74.26,77.14
  BOTTOM w0.089: JCPU1.U8 69.51,86.94 v2(70.04,86.41)
  BOTTOM w0.165: v2(72.33,53.25) 72.33,53.26 71.95,53.26 71.79,53.1 71.79,52.39 71.66,52.26 71.24,52.26 71.11,52.39 JDIMM1.115
DDR_A_D0: length 64
  IN1 w0.089: v2(51.04,93.41) 51.04,93.14 50.91,93.01 48.24,93.01
  IN1 w0.127: v2(34.9,55.91) 34.59,55.91 33.58,56.92 33.4,56.92 32.93,56.45 32.75,56.45 32.57,56.63 32.57,56.81 33.16,57.4 33.16,57.58 32.98,57.76 32.8,57.76 32.21,57.17 32.03,57.17 31.85,57.35 31.85,57.53 32.48,58.16 32.48,58.34 32.3,58.52 32.12,58.52 31.49,57.89 31.31,57.89 31.13,58.07 31.13,58.25 31.6,58.72 31.6,58.9 31.42,59.08 31.24,59.08 30.95,58.79 30.77,58.79 30.59,58.97 30.59,59.15 30.88,59.44 30.88,59.62 30.59,59.91 30.59,83.79 39.59,92.78 47.75,92.78 47.98,93.01 48.24,93.01
  BOTTOM w0.089: JCPU1.AR15 51.51,93.88 v2(51.04,93.41)
  BOTTOM w0.102: v2(34.9,55.91) 35.52,55.91 35.71,56.1 JDIMM1.5
DDR_A_D1: length 63
  IN1 w0.089: 48.24,93.41 v2(49.44,93.41)
  IN1 w0.127: v2(34.9,54.39) 33.8,55.49 33.17,55.49 32.49,56.18 32.31,56.18 32.19,56.06 32.01,56.06 31.83,56.24 31.83,56.42 31.95,56.54 31.95,56.71 31.77,56.89 31.59,56.89 31.47,56.78 31.3,56.78 31.12,56.96 31.12,57.14 31.23,57.25 31.23,57.43 31.05,57.61 30.87,57.61 30.76,57.5 30.58,57.5 30.4,57.68 30.4,57.86 30.51,57.97 30.51,58.15 30.21,58.45 30.21,83.94 39.46,93.19 40.25,93.19 40.48,93.41 40.76,93.41 40.98,93.19 41.27,93.19 41.49,93.41 41.78,93.41 42,93.19 42.28,93.19 42.51,93.41 42.79,93.41 43.02,93.19 43.3,93.19 43.52,93.41 43.81,93.41 44.03,93.19 44.32,93.19 44.54,93.41 44.82,93.41 45.05,93.19 45.33,93.19 45.56,93.41 45.84,93.41 46.06,93.19 46.35,93.19 46.57,93.41 46.86,93.41 47.08,93.19 47.36,93.19 47.59,93.41 48.24,93.41
  BOTTOM w0.089: JCPU1.AT14 49.91,92.94 v2(49.44,93.41)
  BOTTOM w0.102: v2(34.9,54.39) 36.32,55.8 JDIMM1.7
DDR_A_D2: length 68.1
  IN1 w0.089: 48.24,90.52 48.54,90.81 52.42,90.81 52.64,91.03 52.64,92.67 52.85,92.89 53.57,92.89 v2(54.04,92.41)
  IN1 w0.127: v2(38.24,55.91) 37.96,55.91 37.83,55.78 37.83,55.22 37.7,55.1 37.15,55.1 37.03,55.22 37.03,55.53 37.28,55.78 37.28,56.04 37.03,56.29 37.03,56.54 37.15,56.67 37.48,56.67 37.61,56.8 37.61,57.05 37.48,57.18 37.15,57.18 37.03,57.3 37.03,57.63 32.68,61.98 32.68,82.92 37.54,87.78 39.5,89.74 39.77,89.74 39.9,89.87 39.9,90.14 40.03,90.27 40.28,90.27 40.41,90.14 40.41,89.87 40.53,89.74 40.79,89.74 40.91,89.87 40.91,90.57 41.04,90.7 41.3,90.7 41.42,90.57 41.42,89.87 41.55,89.74 41.8,89.74 41.93,89.87 41.93,90.57 42.06,90.7 42.31,90.7 42.44,90.57 42.44,89.87 42.57,89.74 42.82,89.74 42.95,89.87 42.95,90.57 43.07,90.7 43.33,90.7 43.45,90.57 43.45,89.87 43.58,89.74 43.84,89.74 43.96,89.87 43.96,89.96 44.09,90.09 44.34,90.09 44.47,89.96 44.47,89.87 44.6,89.74 44.85,89.74 44.98,89.87 44.98,89.96 45.11,90.09 45.36,90.09 45.49,89.96 45.49,89.87 45.61,89.74 47.46,89.74 48.24,90.52
  BOTTOM w0.089: JCPU1.AM14 54.51,92.88 v2(54.04,92.41)
  BOTTOM w0.102: JDIMM1.15 38.71,56.38 v2(38.24,55.91)
DDR_A_D3: length 67.1
  IN1 w0.089: 48.24,89.98 48.26,90 53.14,90 53.4,90.26 53.4,92.18 53.17,92.41 v2(53.04,92.41)
  IN1 w0.127: v2(38.24,54.39) 38.42,54.21 38.89,54.21 39,54.32 39,55.08 38.87,55.21 38.79,55.21 38.66,55.34 38.66,55.59 38.79,55.72 38.87,55.72 39,55.84 39,56.2 36.1,59.09 36.1,59.27 36.38,59.54 36.38,59.72 36.2,59.9 36.02,59.9 35.74,59.63 35.57,59.63 35.39,59.81 35.39,59.99 35.66,60.26 35.66,60.44 35.48,60.62 35.3,60.62 35.03,60.35 34.85,60.35 34.67,60.53 34.67,60.71 34.94,60.98 34.94,61.16 34.76,61.34 34.58,61.34 34.31,61.07 34.13,61.07 33.95,61.25 33.95,61.43 34.22,61.7 34.22,61.88 34.02,62.07 33.84,62.07 33.57,61.8 33.39,61.8 33.21,61.98 33.21,62.16 33.48,62.43 33.48,62.61 33.06,63.04 33.06,82.76 39.62,89.33 47.59,89.33 48.24,89.98
  BOTTOM w0.089: JCPU1.AN14 53.51,92.88 v2(53.04,92.41)
  BOTTOM w0.102: JDIMM1.17 39.32,54.46 39.24,54.39 v2(38.24,54.39)
DDR_A_D4: length 62.8
  IN1 w0.089: 48.24,93.82 49.67,93.82 v2(50.08,93.41)
  IN1 w0.127: 48.24,93.82 39.55,93.82 29.83,84.1 29.83,57.71 32.54,55 33.63,55 34.21,54.42 34.21,52.03 v2(34.9,51.34)
  BOTTOM w0.089: v2(50.08,93.41) 50.51,93.84 JCPU1.AT15
  BOTTOM w0.102: v2(34.9,51.34) 35.41,50.83 JDIMM1.4
DDR_A_D5: length 64.3
  IN1 w0.089: v2(51.04,92.41) 50.82,92.63 48.24,92.63
  IN1 w0.127: 48.24,92.63 48.01,92.4 39.75,92.4 30.97,83.63 30.97,60.73 31.21,60.5 31.21,60.32 31.06,60.18 31.06,60 31.24,59.82 31.42,59.82 31.57,59.96 31.74,59.96 31.92,59.78 31.92,59.6 31.78,59.46 31.78,59.28 31.96,59.1 32.14,59.1 32.28,59.24 32.46,59.24 32.85,58.86 32.85,58.43 33.29,57.99 33.72,57.99 33.93,57.77 33.93,57.6 33.75,57.42 33.75,57.28 33.98,57.06 34.11,57.06 34.29,57.24 34.47,57.24 34.65,57.06 34.65,56.88 34.47,56.7 34.47,56.57 34.7,56.34 34.83,56.34 35.01,56.52 35.19,56.52 35.32,56.38 35.32,53.09 35.1,52.86 v2(34.9,52.86)
  BOTTOM w0.089: v2(51.04,92.41) 51.51,92.88 JCPU1.AR14
  BOTTOM w0.102: v2(34.9,52.86) 36.02,51.75 JDIMM1.6
DDR_A_D6: length 67.2
  IN1 w0.089: v2(53.04,93.41) 52.46,92.83 52.46,91.13 52.32,90.99 48.24,90.99
  IN1 w0.127: 48.24,90.99 48.17,90.99 47.31,90.12 46.09,90.12 45.96,90.25 45.96,90.34 45.83,90.47 44.06,90.47 43.93,90.59 43.93,90.95 43.81,91.08 40.3,91.08 38.92,89.7 32.3,83.08 32.3,61.82 32.32,61.8 32.32,61.62 32.3,61.6 32.3,61.42 32.48,61.24 32.66,61.24 32.68,61.26 32.86,61.26 33.04,61.08 33.04,60.9 32.95,60.81 32.95,60.63 33.13,60.45 33.31,60.45 33.4,60.54 33.58,60.54 33.76,60.36 33.76,60.18 33.67,60.09 33.67,59.91 33.85,59.73 34.02,59.73 34.11,59.82 34.29,59.82 34.83,59.29 34.83,59.11 34.74,59.02 34.74,58.84 34.92,58.66 35.1,58.66 35.19,58.75 35.37,58.75 35.55,58.57 35.55,58.39 35.46,58.3 35.46,58.12 35.74,57.84 35.92,57.84 36,57.92 36.18,57.92 36.36,57.74 36.36,57.56 36.27,57.48 36.27,57.3 36.64,56.93 36.64,54.84 36.77,54.72 37.66,54.72 37.79,54.59 37.79,51.46 37.92,51.34 v2(38.24,51.34)
  BOTTOM w0.089: v2(53.04,93.41) 53.51,93.88 JCPU1.AN15
  BOTTOM w0.102: JDIMM1.16 39.02,50.56 v2(38.24,51.34)
DDR_A_D7: length 68.4
  IN1 w0.089: 48.24,89.44 48.62,89.82 54.31,89.82 54.63,90.14 54.63,93 v2(55.04,93.41)
  IN1 w0.127: 48.24,89.44 47.74,88.94 39.78,88.94 33.44,82.61 33.44,63.2 36.83,59.8 36.83,59.16 39.38,56.61 39.38,51.59 39.25,51.47 38.81,51.47 38.68,51.59 38.68,52.66 38.48,52.86 v2(38.24,52.86)
  BOTTOM w0.089: JCPU1.AM15 54.51,93.94 v2(55.04,93.41)
  BOTTOM w0.102: JDIMM1.18 39.62,51.49 v2(38.24,52.86)
DDR_A_D8: length 58.8
  IN1 w0.089: v2(54.04,87.41) 53.63,87.82 51.18,87.82 50.57,87.21 48.24,87.21
  IN1 w0.127: v2(40.91,54.39) 41.47,54.39 41.66,54.58 41.66,57.34 35.11,63.89 35.11,81.85 38.85,85.58 39.48,86.21 43.24,86.21 43.37,86.34 43.37,87.08 43.5,87.21 43.75,87.21 43.88,87.08 43.88,86.34 44.01,86.21 44.26,86.21 44.39,86.34 44.39,87.08 44.51,87.21 48.24,87.21
  BOTTOM w0.089: JCPU1.AM9 54.51,87.88 v2(54.04,87.41)
  BOTTOM w0.102: JDIMM1.21 40.52,56.42 40.3,56.21 40.3,54.99 v2(40.91,54.39)
DDR_A_D9: length 57.9
  IN1 w0.089: 48.24,87.59 50.63,87.59 51.04,88 52.93,88 53.04,88.11 v2(53.04,88.41)
  IN1 w0.127: v2(40.91,55.91) 41.16,55.91 41.28,56.04 41.28,57.19 34.73,63.73 34.73,82.01 39.32,86.59 39.7,86.59 39.83,86.72 39.83,87.1 39.96,87.23 40.21,87.23 40.34,87.1 40.34,86.72 40.46,86.59 40.72,86.59 40.84,86.72 40.84,87.46 40.97,87.59 41.23,87.59 41.35,87.46 41.35,86.72 41.48,86.59 41.73,86.59 41.86,86.72 41.86,87.46 41.99,87.59 42.24,87.59 42.37,87.46 42.37,86.72 42.5,86.59 42.75,86.59 42.88,86.72 42.88,87.46 43,87.59 48.24,87.59
  BOTTOM w0.089: JCPU1.AN9 53.51,87.94 v2(53.04,88.41)
  BOTTOM w0.102: v2(40.91,55.91) 41.23,55.91 41.36,56.04 41.36,56.35 41.11,56.59 JDIMM1.23
DDR_A_D10: length 56.9
  IN1 w0.089: 48.24,83.75 49.62,83.75 49.86,83.99 51.19,83.99 51.62,84.43 51.62,84.57 51.87,84.82 52.24,84.82 52.61,85.19 52.61,85.62 52.81,85.82 52.96,85.82 53.63,86.48 53.97,86.48 v2(54.04,86.41)
  IN1 w0.127: v2(44.25,54.39) 44.62,54.39 44.75,54.51 44.75,57.74 37.64,64.85 37.64,73.96 37.79,74.11 38.8,74.11 38.92,74.24 38.92,74.49 38.8,74.62 37.76,74.62 37.64,74.75 37.64,75 37.76,75.13 38.32,75.13 38.45,75.25 38.45,75.92 38.54,76.02 39.04,76.02 39.11,76.09 39.11,78.76 38.93,78.95 38.61,78.95 38.45,79.1 38.45,81.7 40.5,83.75 48.24,83.75
  BOTTOM w0.089: v2(54.04,86.41) 54.51,86.88 JCPU1.AM8
  BOTTOM w0.102: v2(44.25,54.39) 44.02,54.39 43.84,54.57 43.84,56.2 44.11,56.48 JDIMM1.33
DDR_A_D11: length 57.3
  IN1 w0.089: 48.24,84.13 48.59,84.13 49.32,84.86 50.49,84.86 50.63,85 52.17,85 52.43,85.26 52.43,85.8 v2(53.04,86.41)
  IN1 w0.127: v2(44.25,55.91) 44.25,57.7 37.26,64.7 37.26,75.38 37.38,75.51 37.94,75.51 38.07,75.63 38.07,75.89 37.94,76.02 37.38,76.02 37.26,76.14 37.26,76.4 37.38,76.52 38.61,76.52 38.73,76.65 38.73,76.9 38.61,77.03 37.38,77.03 37.26,77.16 37.26,77.41 37.38,77.54 38.61,77.54 38.73,77.67 38.73,77.92 38.61,78.05 37.38,78.05 37.26,78.17 37.26,78.43 37.38,78.56 37.98,78.56 38.11,78.68 38.11,78.94 37.98,79.06 37.38,79.06 37.26,79.19 37.26,79.44 37.38,79.57 37.94,79.57 38.07,79.7 38.07,81.86 40.34,84.13 48.24,84.13
  BOTTOM w0.089: JCPU1.AN8 53.51,86.88 v2(53.04,86.41)
  BOTTOM w0.102: JDIMM1.35 44.71,56.38 44.25,55.92 v2(44.25,55.91)
DDR_A_D12: length 56
  IN1 w0.089: v2(51.04,88.41) 50.6,87.97 48.24,87.97
  IN1 w0.127: v2(40.91,52.86) 40.56,52.86 40.29,53.13 40.29,56.99 37.75,59.54 37.75,60.18 34.35,63.58 34.35,82.16 40.16,87.97 48.24,87.97
  BOTTOM w0.089: JCPU1.AR9 51.51,87.94 v2(51.04,88.41)
  BOTTOM w0.102: JDIMM1.22 40.82,50.52 40.46,50.88 40.46,52.4 v2(40.91,52.86)
DDR_A_D13: length 55.3
  IN1 w0.089: 48.24,88.41 v2(49.45,88.41)
  IN1 w0.127: v2(40.91,51.34) 39.91,52.34 39.91,56.83 37.36,59.38 37.36,60.03 33.97,63.42 33.97,82.32 40.06,88.41 48.24,88.41
  BOTTOM w0.089: v2(49.45,88.41) 49.92,87.94 JCPU1.AT9
  BOTTOM w0.102: v2(40.91,51.34) 41.41,50.84 JDIMM1.24
DDR_A_D14: length 55.3
  IN1 w0.089: 48.24,84.69 48.79,85.24 50.16,85.24 50.9,85.99 51.63,85.99 v2(52.05,86.41)
  IN1 w0.127: 48.24,84.69 48.06,84.51 40.18,84.51 38.99,83.32 37.69,82.01 37.69,81.26 37.56,81.13 37,81.13 36.88,81 36.88,80.75 37,80.62 37.56,80.62 37.69,80.49 37.69,80.15 37.56,80.02 37,80.02 36.88,79.89 36.88,64.54 43.81,57.6 43.81,52.96 43.91,52.86 v2(44.25,52.86)
  BOTTOM w0.089: v2(52.05,86.41) 51.52,86.94 JCPU1.AR8
  BOTTOM w0.102: JDIMM1.34 44.41,50.49 43.81,51.09 43.81,52.42 v2(44.25,52.86)
DDR_A_D15: length 55
  IN1 w0.089: v2(51.05,86.41) 50.26,85.62 48.5,85.62 48.24,85.36
  IN1 w0.127: v2(44.25,51.34) 44.2,51.29 42.69,51.29 42.57,51.41 42.57,52.33 42.69,52.46 43.3,52.46 43.43,52.59 43.43,57.45 36.49,64.38 36.49,81.36 39.07,83.93 40.02,84.89 47.77,84.89 48.24,85.36
  BOTTOM w0.089: JCPU1.AT8 50.52,86.94 v2(51.05,86.41)
  BOTTOM w0.102: JDIMM1.36 45.02,50.57 v2(44.25,51.34)
DDR_A_D16: length 55.3
  IN1 w0.089: v2(57,88.41) 57,88.63 56.82,88.81 55.72,88.81 55.47,88.56 55.47,86.2 55.25,85.99 54.8,85.99 54.45,85.65 54.45,85.21 54.24,85 53.76,85 53.45,84.69 53.45,84.25 53.21,84.01 52.71,84.01 52.44,83.74 52.44,83.25 52.19,83 51.69,83 51.44,82.74 51.44,82.25 51.19,81.99 48.99,81.99 48.24,81.25
  IN1 w0.127: 48.24,81.25 38.93,71.94 38.93,66.71 39.06,66.58 39.24,66.58 39.37,66.46 39.37,66.03 39.24,65.91 39.06,65.91 38.93,65.78 38.93,65.39 46.11,58.22 46.11,54.56 46.28,54.39 v2(46.53,54.39)
  BOTTOM w0.089: v2(57,88.41) 57.47,87.94 JCPU1.AJ9
  BOTTOM w0.102: v2(46.53,54.39) 46.28,54.39 46.28,54.38 45.18,54.38 45.05,54.51 45.05,55.41 45.18,55.54 45.81,55.54 45.92,55.64 JDIMM1.39
DDR_A_D17: length 53.7
  IN1 w0.089: 48.24,80.71 49.35,81.82 51.26,81.82 51.62,82.17 51.62,82.67 51.77,82.82 52.26,82.82 52.62,83.17 52.62,83.67 52.78,83.83 53.28,83.83 53.63,84.18 53.63,84.62 53.83,84.82 54.31,84.82 54.63,85.14 54.63,85.57 54.87,85.81 55.33,85.81 55.66,86.14 55.66,88.27 55.74,88.35 v2(55.99,88.35)
  IN1 w0.127: 48.24,80.71 39.31,71.78 39.31,68.35 39.56,68.11 39.56,67.74 39.31,67.5 39.31,67.05 39.68,66.68 39.91,66.68 40.04,66.56 40.04,65.88 39.91,65.75 39.62,65.75 39.5,65.62 39.5,65.37 39.62,65.24 39.91,65.24 40.04,65.11 40.04,64.82 46.53,58.33 v2(46.53,55.91)
  BOTTOM w0.089: v2(55.99,88.35) 56.4,87.94 JCPU1.AK9
  BOTTOM w0.102: v2(46.53,55.91) 46.53,55.72 46.94,55.32 46.94,53.74 47.07,53.61 47.3,53.61 47.42,53.74 47.42,55.52 47.09,55.85 47.09,55.98 46.52,56.56 JDIMM1.41
DDR_A_D18: length 53.2
  IN1 w0.089: 48.24,77.77 50.13,79.66 51.85,79.66 53.44,81.24 53.44,81.74 53.71,82.01 54.21,82.01 54.44,82.25 54.44,82.74 55.71,84.01 56.91,84.01 57.04,84.14 v2(57.04,84.42)
  IN1 w0.127: 48.24,77.77 42.57,72.1 42.57,70.45 42.7,70.33 43.33,70.33 43.46,70.2 43.46,69.95 43.33,69.82 42.7,69.82 42.57,69.69 42.57,69.44 42.7,69.31 43.33,69.31 43.46,69.18 43.46,68.93 43.33,68.8 42.7,68.8 42.57,68.68 42.57,68.42 42.7,68.29 43.33,68.29 43.46,68.17 43.46,67.91 43.33,67.79 42.7,67.79 42.57,67.66 42.57,67.41 42.7,67.28 43.33,67.28 43.46,67.15 43.46,66.9 43.33,66.77 42.7,66.77 42.57,66.64 42.57,66.39 42.7,66.26 43.33,66.26 43.46,66.14 43.46,65.02 43.67,64.81 43.67,64.63 43.51,64.48 43.51,64.3 43.69,64.12 43.87,64.12 44.03,64.27 44.21,64.27 44.44,64.04 44.44,63.86 44.28,63.71 44.28,63.53 44.46,63.35 44.64,63.35 44.8,63.5 44.98,63.5 45.16,63.32 45.16,63.14 45,62.99 45,62.81 45.18,62.63 45.36,62.63 45.52,62.78 45.7,62.78 45.88,62.6 45.88,62.42 45.72,62.27 45.72,62.09 45.9,61.91 46.08,61.91 46.24,62.07 46.41,62.07 46.59,61.89 46.59,61.71 46.44,61.55 46.44,61.37 46.62,61.19 46.8,61.19 46.95,61.35 47.13,61.35 47.31,61.17 47.31,60.99 47.16,60.83 47.16,60.65 47.36,60.45 47.54,60.45 47.71,60.61 47.87,60.61 49.16,59.32 49.16,55.95 v2(49.2,55.91)
  BOTTOM w0.089: JCPU1.AJ6 57.51,84.9 v2(57.04,84.42)
  BOTTOM w0.102: v2(49.2,55.91) 49.2,55.66 49.33,55.53 49.68,55.53 49.81,55.66 49.81,56.28 49.52,56.58 JDIMM1.51
DDR_A_D19: length 52.1
  IN1 w0.089: v2(56.04,84.41) 56.04,84.41 56.46,84.83 57.2,84.83 57.44,84.59 57.44,84.26 57.02,83.83 55.78,83.83 54.62,82.67 54.62,82.17 54.28,81.83 53.78,81.83 53.62,81.67 53.62,81.17 51.93,79.48 50.49,79.48 48.24,77.23
  IN1 w0.127: 48.24,77.23 43.84,72.83 43.84,72.45 43.72,72.32 43.33,72.32 43.21,72.19 43.21,71.94 43.33,71.81 43.72,71.81 43.84,71.68 43.84,71.43 43.72,71.3 43.08,71.3 42.95,71.18 42.95,70.92 43.08,70.8 43.72,70.8 43.84,70.67 43.84,65.18 49.74,59.28 49.74,58.76 49.54,58.56 49.54,58.25 49.74,58.06 49.74,57.74 49.54,57.55 49.54,57.24 49.74,57.04 49.74,54.51 49.61,54.39 v2(49.2,54.39)
  BOTTOM w0.089: v2(56.04,84.41) 56.51,84.88 JCPU1.AK6
  BOTTOM w0.102: JDIMM1.53 50.11,55.39 50.22,55.29 50.84,55.29 50.97,55.16 50.97,54.14 50.84,54.01 49.33,54.01 49.2,54.14 v2(49.2,54.39)
DDR_A_D20: length 56.2
  IN1 w0.089: 48.24,82.33 48.91,82.99 51.19,82.99 51.44,83.25 51.44,83.67 51.78,84.01 52.21,84.01 52.46,84.26 52.46,84.72 52.74,84.99 53.25,84.99 53.46,85.21 53.46,85.67 53.79,86 54.29,86 54.45,86.16 54.45,89.48 54.87,89.9 56.52,89.9 v2(57,89.43)
  IN1 w0.127: 48.24,82.33 41.5,75.58 41.5,75.58 38.17,72.26 38.17,65.08 45.35,57.9 45.35,52.53 v2(46.53,51.34)
  BOTTOM w0.089: JCPU1.AJ10 57.48,88.94 v2(57,89.43)
  BOTTOM w0.102: v2(46.53,51.34) 46.22,51.02 JDIMM1.40
DDR_A_D21: length 54.6
  IN1 w0.089: 48.24,81.79 49.27,82.82 51.26,82.82 51.62,83.17 51.62,83.6 51.85,83.83 52.28,83.83 52.64,84.19 52.64,84.64 52.81,84.82 53.32,84.82 53.64,85.13 53.64,85.58 53.88,85.82 54.36,85.82 54.63,86.09 54.63,88.81 54.78,88.96 55.6,88.96 v2(55.99,89.35)
  IN1 w0.127: v2(46.53,52.86) 45.96,52.86 45.73,53.09 45.73,53.54 45.85,53.67 45.95,53.67 46.08,53.79 46.08,54.05 45.95,54.17 45.85,54.17 45.73,54.3 45.73,58.06 38.55,65.23 38.55,72.1 41.88,75.42 41.88,75.43 48.24,81.79
  BOTTOM w0.089: JCPU1.AK10 56.4,88.94 v2(55.99,89.35)
  BOTTOM w0.102: JDIMM1.42 46.81,50.45 46.95,50.59 46.95,52.45 v2(46.53,52.86)
DDR_A_D22: length 53.8
  IN1 w0.089: 48.24,78.3 49.77,79.83 51.28,79.83 51.62,80.17 51.62,80.52 51.94,80.83 52.28,80.83 52.62,81.17 52.62,81.54 52.91,81.83 53.28,81.83 53.63,82.18 53.63,82.64 53.82,82.83 54.28,82.83 55.63,84.19 55.63,84.58 56.07,85.01 56.85,85.01 57.04,85.2 v2(57.04,85.41)
  IN1 w0.127: 48.24,78.3 42.08,72.14 42.08,71.21 41.95,71.08 41.87,71.08 41.74,70.95 41.74,70.7 41.87,70.57 41.95,70.57 42.08,70.45 42.08,70.19 41.95,70.06 41.87,70.06 41.74,69.94 41.74,69.68 41.87,69.56 41.95,69.56 42.08,69.43 42.08,69.18 41.95,69.05 41.87,69.05 41.74,68.92 41.74,68.67 41.87,68.54 41.95,68.54 42.08,68.41 42.08,68.16 41.95,68.03 41.87,68.03 41.74,67.91 41.74,67.65 41.87,67.52 41.95,67.52 42.08,67.4 42.08,67.14 41.95,67.02 41.87,67.02 41.74,66.89 41.74,66.64 41.87,66.51 41.95,66.51 42.08,66.38 42.08,66.01 42.21,65.88 42.95,65.88 43.08,65.75 43.08,65.47 42.95,65.34 42.44,65.34 42.31,65.22 42.31,64.96 42.44,64.83 42.95,64.83 43.08,64.71 43.08,64.19 47.48,59.79 48.15,59.79 48.78,59.16 48.78,58.69 48.66,58.56 48.46,58.56 48.33,58.43 48.33,58.18 48.46,58.05 48.66,58.05 48.78,57.93 48.78,57.67 48.66,57.54 48.46,57.54 48.33,57.42 48.33,57.16 48.46,57.04 48.66,57.04 48.78,56.91 48.78,52.96 48.88,52.86 v2(49.2,52.86)
  BOTTOM w0.089: v2(57.04,85.41) 57.51,85.88 JCPU1.AJ7
  BOTTOM w0.102: JDIMM1.50 49.22,50.66 48.75,51.13 48.75,52.67 48.94,52.86 v2(49.2,52.86)
DDR_A_D23: length 53.3
  IN1 w0.089: v2(56.04,85.41) 56.04,85.24 55.46,84.66 55.46,84.26 54.21,83.01 53.75,83.01 53.45,82.71 53.45,82.25 53.21,82.01 52.81,82.01 52.44,81.64 52.44,81.24 52.21,81.01 51.84,81.01 51.44,80.62 51.44,80.25 51.21,80.01 49.41,80.01 48.24,78.84
  IN1 w0.127: v2(49.2,51.34) 48.91,51.04 47.38,51.04 47.25,51.17 47.25,51.55 47.38,51.68 48.27,51.68 48.4,51.81 48.4,52.06 48.27,52.19 47.35,52.19 47.22,52.32 47.22,52.57 47.35,52.7 48.27,52.7 48.4,52.82 48.4,56.25 48.31,56.34 48.05,56.34 47.95,56.44 47.95,58.78 41.36,65.37 41.36,71.96 44.18,74.78 48.24,78.84
  BOTTOM w0.089: JCPU1.AK7 56.51,85.88 v2(56.04,85.41)
  BOTTOM w0.102: v2(49.2,51.34) 49.81,50.72 JDIMM1.52
DDR_A_D24: length 47.6
  IN1 w0.089: 51.01,77.14 52.64,78.77 53.14,78.77 53.6,79.23 53.6,79.57 53.85,79.81 54.24,79.81 54.62,80.18 54.62,80.67 54.78,80.83 55.28,80.83 55.62,81.17 55.62,81.67 55.77,81.82 59.45,81.82 v2(60.04,82.41)
  IN1 w0.127: 51.01,77.14 50.86,76.98 50.37,76.98 50.14,76.76 50.14,76.58 50.21,76.51 50.21,76.33 50.03,76.15 49.85,76.15 49.78,76.22 49.6,76.22 49.42,76.04 49.42,75.86 49.49,75.79 49.49,75.61 49.31,75.43 49.13,75.43 49.06,75.5 48.88,75.5 48.7,75.32 48.7,75.14 48.77,75.07 48.77,74.9 48.59,74.72 48.41,74.72 48.35,74.78 48.17,74.78 47.99,74.6 47.99,74.42 48.05,74.36 48.05,74.18 47.87,74 47.69,74 47.63,74.06 47.45,74.06 47.27,73.88 47.27,73.7 47.33,73.64 47.33,73.46 47.15,73.28 46.97,73.28 46.91,73.34 46.73,73.34 46.55,73.16 46.55,72.71 46.42,72.58 45.97,72.58 45.84,72.45 45.84,72.2 45.97,72.07 46.42,72.07 46.55,71.95 46.55,71.69 46.42,71.56 45.65,71.56 45.52,71.44 45.52,71.18 45.65,71.06 46.42,71.06 46.55,70.93 46.55,70.68 46.42,70.55 45.65,70.55 45.52,70.42 45.52,70.17 45.65,70.04 46.42,70.04 46.55,69.91 46.55,67.72 46.42,67.6 45.98,67.6 45.85,67.47 45.85,65.56 45.98,65.43 46.42,65.43 46.55,65.3 46.55,64.84 51.42,59.97 51.42,55.98 v2(51.49,55.91)
  BOTTOM w0.089: v2(60.04,82.41) 60.51,82.88 JCPU1.AF4
  BOTTOM w0.102: v2(51.49,55.91) 51.32,56.08 JDIMM1.57
DDR_A_D25: length 47.9
  IN1 w0.089: v2(60.04,83.41) 59.63,83 59.63,82.49 59.15,82.01 55.71,82.01 55.44,81.74 55.44,81.24 55.21,81.01 54.71,81.01 54.44,80.74 54.44,80.26 54.17,79.99 53.77,79.99 53.42,79.64 53.42,79.3 53.06,78.94 52.57,78.94 51.04,77.41 50.26,77.41 49.98,77.14
  IN1 w0.127: 49.98,77.14 45.14,72.29 45.14,69.57 45.27,69.44 46.04,69.44 46.17,69.32 46.17,69.06 46.04,68.94 45.27,68.94 45.14,68.81 45.14,68.55 45.27,68.43 45.6,68.43 45.72,68.3 45.72,68.05 45.6,67.92 45.27,67.92 45.14,67.79 45.14,65.71 51.04,59.82 51.04,54.84 v2(51.49,54.39)
  BOTTOM w0.089: v2(60.04,83.41) 60.51,83.88 JCPU1.AF5
  BOTTOM w0.102: JDIMM1.59 51.92,54.99 51.49,54.57 v2(51.49,54.39)
DDR_A_D26: length 43.5
  IN1 w0.089: 54.96,77.14 56.38,78.56 59.72,78.56 60.18,79.02 60.18,79.27 v2(60.04,79.41)
  IN1 w0.127: v2(54.54,55.91) 54.65,56.02 54.65,56.42 54.55,56.52 54.1,56.52 53.98,56.65 53.98,56.91 54.1,57.03 54.53,57.03 54.66,57.16 54.66,57.41 54.53,57.54 54.1,57.54 53.98,57.67 53.98,57.92 54.1,58.05 54.53,58.05 54.66,58.18 54.66,58.43 54.53,58.56 54.1,58.56 53.98,58.68 53.98,58.94 54.1,59.06 54.53,59.06 54.66,59.19 54.66,60.22 49.92,64.96 49.92,65.28 49.79,65.41 49.47,65.41 49.35,65.53 49.35,65.79 49.47,65.91 49.79,65.91 49.92,66.04 49.92,66.29 49.79,66.42 49.14,66.42 49.01,66.55 49.01,66.8 49.14,66.93 49.79,66.93 49.92,67.06 49.92,67.31 49.79,67.44 49.14,67.44 49.01,67.56 49.01,67.82 49.14,67.95 49.79,67.95 49.92,68.07 49.92,68.33 49.79,68.45 49.14,68.45 49.01,68.58 49.01,68.83 49.14,68.96 49.79,68.96 49.92,69.09 49.92,69.34 49.79,69.47 49.58,69.47 49.46,69.6 49.46,69.85 49.58,69.98 49.79,69.98 49.92,70.1 49.92,72.09 54.96,77.14
  BOTTOM w0.089: JCPU1.AF1 60.51,79.88 v2(60.04,79.41)
  BOTTOM w0.102: JDIMM1.67 54.32,56.13 v2(54.54,55.91)
DDR_A_D27: length 44.5
  IN1 w0.089: 54.35,77.14 55.97,78.76 59.4,78.76 59.64,79 59.64,80.27 59.78,80.41 v2(60.04,80.41)
  IN1 w0.127: v2(54.54,54.39) 54.24,54.39 54.12,54.5 54.12,55.86 53.58,56.4 53.58,59.57 53.7,59.69 54.14,59.69 54.26,59.82 54.26,60.08 54.14,60.2 53.7,60.2 53.58,60.33 53.58,60.76 48.63,65.71 48.63,69.3 48.76,69.43 48.95,69.43 49.08,69.56 49.08,69.81 48.95,69.94 48.76,69.94 48.63,70.06 48.63,70.32 48.76,70.45 49.41,70.45 49.54,70.57 49.54,70.83 49.41,70.95 48.99,70.95 48.86,71.08 48.86,71.33 48.99,71.46 49.41,71.46 49.54,71.59 49.54,72.32 51.21,74 51.21,74.18 51.2,74.19 51.2,74.37 51.38,74.55 51.55,74.55 51.57,74.54 51.75,74.54 51.93,74.72 51.93,74.9 51.91,74.91 51.91,75.09 52.09,75.27 52.27,75.27 52.29,75.26 52.47,75.26 52.65,75.44 52.65,75.62 52.63,75.63 52.63,75.81 52.81,75.99 52.99,75.99 53.01,75.97 53.19,75.97 53.37,76.15 53.37,76.33 53.35,76.35 53.35,76.53 53.53,76.71 53.71,76.71 53.73,76.69 53.91,76.69 54.35,77.14
  BOTTOM w0.089: JCPU1.AF2 60.51,80.88 v2(60.04,80.41)
  BOTTOM w0.102: v2(54.54,54.39) 55.11,54.39 55.44,54.71 55.44,55.58 54.92,56.1 JDIMM1.69
DDR_A_D28: length 46
  IN1 w0.089: 49.45,77.14 51.43,79.12 52.07,79.12 53.78,80.83 54.28,80.83 54.62,81.17 54.62,81.67 54.78,81.83 55.28,81.83 55.62,82.17 55.62,82.55 55.89,82.83 58.62,82.83 v2(59.04,82.41)
  IN1 w0.127: 49.45,77.14 44.76,72.45 44.76,65.56 50.65,59.66 50.65,53.69 v2(51.49,52.86)
  BOTTOM w0.089: v2(59.04,82.41) 59.51,82.88 JCPU1.AG4
  BOTTOM w0.102: v2(51.49,52.86) 51.02,52.39 JDIMM1.56
DDR_A_D29: length 48.2
  IN1 w0.089: v2(59.04,83.41) 59.04,83.41 58.64,83.01 55.82,83.01 55.44,82.63 55.44,82.25 55.21,82.01 54.71,82.01 54.44,81.74 54.44,81.25 54.21,81.01 53.71,81.01 52,79.3 51.07,79.3 48.91,77.14
  IN1 w0.127: v2(51.49,51.34) 51.49,51.01 51.27,50.79 50.42,50.79 50.27,50.94 50.27,59.5 44.38,65.4 44.38,72.61 48.91,77.14
  BOTTOM w0.089: v2(59.04,83.41) 59.51,83.88 JCPU1.AG5
  BOTTOM w0.102: v2(51.49,51.34) 51.62,51.21 JDIMM1.58
DDR_A_D30: length 43
  IN1 w0.089: v2(59.04,79.41) 59.04,79.57 58.78,79.83 55.76,79.83 53.07,77.14 52.88,77.14
  IN1 w0.127: 52.88,77.14 49.38,73.64 49.38,73.46 49.4,73.44 49.4,73.27 49.22,73.09 49.04,73.09 49.02,73.1 48.84,73.1 48.66,72.92 48.66,72.74 48.68,72.73 48.68,72.55 48.5,72.37 48.32,72.37 48.31,72.38 48.13,72.38 47.87,72.13 47.87,65.39 52.81,60.45 52.81,56.09 53.36,55.54 53.36,50.99 53.54,50.82 54.4,50.82 54.54,50.96 v2(54.54,51.34)
  BOTTOM w0.089: JCPU1.AG1 59.51,79.88 v2(59.04,79.41)
  BOTTOM w0.102: JDIMM1.68 54.62,51.26 v2(54.54,51.34)
DDR_A_D31: length 43.4
  IN1 w0.089: 53.42,77.14 55.22,78.94 59.33,78.94 59.46,79.07 59.46,80.36 59.41,80.41 v2(59.04,80.41)
  IN1 w0.127: 53.42,77.14 50.76,74.48 50.76,74.09 50.51,73.84 50.33,73.84 50.32,73.86 50.14,73.86 49.96,73.68 49.96,73.5 49.98,73.48 49.98,73.3 48.25,71.58 48.25,65.55 50.72,63.08 50.72,63.08 53.19,60.61 53.19,56.25 53.74,55.7 53.74,52.68 53.87,52.55 54.41,52.55 54.54,52.68 v2(54.54,52.86)
  BOTTOM w0.089: v2(59.04,80.41) 59.51,80.88 JCPU1.AG2
  BOTTOM w0.102: JDIMM1.70 55.22,52.44 54.8,52.86 v2(54.54,52.86)
DDR_A_D32: length 42.3
  IN1 w0.089: v2(78.04,79.41) 78.04,78.89 78.9,78.03
  IN1 w0.127: 78.9,78.03 78.9,77.27 83.71,72.47 83.89,72.47 84.22,72.79 84.4,72.79 84.58,72.61 84.58,72.43 84.25,72.11 84.25,71.93 84.43,71.75 85.02,71.75 85.15,71.62 85.15,71.37 85.02,71.24 84.54,71.24 84.41,71.11 84.41,70.86 84.54,70.73 85.02,70.73 85.15,70.6 85.15,66.83 78.51,60.19 78.51,57.22 78.38,57.09 78.24,57.09 78.11,56.96 78.11,56.71 78.24,56.58 78.38,56.58 78.51,56.45 78.51,56.17 78.38,56.05 78.33,56.05 78.2,55.92 78.2,55.64 78.09,55.53 78.09,53.96 77.96,53.83 77.75,53.83 77.62,53.96 v2(77.62,54.08)
  BOTTOM w0.089: JCPU1.J1 77.51,79.94 v2(78.04,79.41)
  BOTTOM w0.102: v2(77.62,54.08) 77.47,54.08 77.35,53.96 77.35,53.62 77.22,53.49 76.42,53.49 76.29,53.62 76.29,55.74 76.18,55.85 75.83,55.85 75.32,56.37 JDIMM1.129
DDR_A_D33: length 43.6
  IN1 w0.089: 78.45,78.03 77.43,79.05 77.43,80.49 77.56,80.62 77.92,80.62 78.04,80.5 v2(78.04,80.41)
  IN1 w0.127: v2(77.62,55.61) 77.73,55.72 77.73,57.41 77.86,57.54 78,57.54 78.13,57.67 78.13,57.92 78,58.05 77.86,58.05 77.73,58.17 77.73,58.43 77.86,58.55 77.95,58.55 78.07,58.68 78.07,60.3 84.03,66.25 84.03,66.54 84.16,66.67 84.44,66.67 84.57,66.79 84.57,67.05 84.44,67.17 84.16,67.17 84.03,67.3 84.03,67.56 84.16,67.68 84.64,67.68 84.76,67.81 84.76,68.06 84.64,68.19 84.16,68.19 84.03,68.32 84.03,68.57 84.16,68.7 84.64,68.7 84.76,68.83 84.76,69.08 84.64,69.21 84.16,69.21 84.03,69.33 84.03,69.59 84.16,69.71 84.64,69.71 84.76,69.84 84.76,70.1 84.64,70.22 84.16,70.22 84.03,70.35 84.03,71.61 78.52,77.12 78.52,77.95 78.45,78.03
  BOTTOM w0.089: JCPU1.J2 77.51,80.94 v2(78.04,80.41)
  BOTTOM w0.102: JDIMM1.131 75.92,56.46 76.04,56.34 76.72,56.34 76.84,56.21 76.84,56.03 76.72,55.9 76.68,55.9 76.59,55.81 76.59,54.15 76.72,54.02 76.98,54.02 77.11,54.15 77.11,55.53 77.19,55.61 v2(77.62,55.61)
DDR_A_D34: length 46.5
  IN1 w0.089: 81.69,78.03 81.24,78.48 81.24,78.77 80.08,79.92 80.08,80.8 79.64,81.25 79.64,81.99 78.62,83 77.87,83 77.63,83.25 77.63,84.38 77.76,84.5 77.95,84.5 v2(78.04,84.41)
  IN1 w0.127: 81.69,78.03 83.51,76.21 84.47,76.21 84.71,75.97 84.89,75.97 85.2,76.28 85.38,76.28 85.56,76.1 85.56,75.92 85.25,75.61 85.25,75.43 85.43,75.25 85.61,75.25 85.88,75.53 86.06,75.53 87.61,73.98 87.61,65.81 81.24,59.44 81.24,53.85 81.11,53.72 80.88,53.72 80.75,53.85 v2(80.75,54.08)
  BOTTOM w0.089: JCPU1.J5 77.57,83.94 v2(78.04,84.41)
  BOTTOM w0.102: v2(80.75,54.08) 80.65,54.08 80.12,54.62 80.12,55.29 78.92,56.5 JDIMM1.141
DDR_A_D35: length 45.7
  IN1 w0.089: 81.15,78.03 81,78.18 81,78.76 79.85,79.9 79.85,80.78 79.44,81.19 79.44,81.92 78.59,82.76 77.85,82.76 77.45,83.16 77.45,84.46 77.76,84.77 78.38,84.77 78.56,84.59 78.56,83.98 78.69,83.85 79.32,83.85 79.45,83.98 79.45,84.28 79.32,84.41 v2(79.04,84.41)
  IN1 w0.127: v2(80.75,55.61) 80.75,59.49 87.23,65.97 87.23,72.91 86.77,73.36 86.77,73.54 87.05,73.82 87.05,74 86.87,74.18 86.69,74.18 86.42,73.9 86.24,73.9 86.06,74.08 86.06,74.26 86.33,74.54 86.33,74.72 86.15,74.9 85.97,74.9 85.7,74.62 85.52,74.62 84.31,75.83 83.35,75.83 81.15,78.03
  BOTTOM w0.089: v2(79.04,84.41) 78.57,83.94 JCPU1.H5
  BOTTOM w0.102: JDIMM1.143 79.51,56.33 80.23,55.61 v2(80.75,55.61)
DDR_A_D36: length 43
  IN1 w0.089: 79.29,78.03 79.29,78.2 78.59,78.89 78.59,80.52 78.68,80.6 78.95,80.6 79.04,80.52 v2(79.04,80.41)
  IN1 w0.127: v2(77.62,52.55) 77.62,52.41 77.75,52.28 78.34,52.28 78.47,52.41 78.47,52.6 78.34,52.72 78.11,52.72 77.98,52.85 77.98,53.09 78.11,53.22 78.34,53.22 78.47,53.34 78.47,55.37 78.89,55.79 78.89,60.03 85.53,66.67 85.53,72.2 84.31,73.42 84.13,73.42 83.8,73.1 83.62,73.1 83.44,73.28 83.44,73.46 83.75,73.76 83.75,73.94 83.57,74.12 83.39,74.12 83.08,73.82 82.9,73.82 79.29,77.43 79.29,78.03
  BOTTOM w0.089: v2(79.04,80.41) 78.51,80.94 JCPU1.H2
  BOTTOM w0.102: JDIMM1.130 75.62,50.47 77.62,52.48 v2(77.62,52.55)
DDR_A_D37: length 42
  IN1 w0.089: v2(79.04,79.41) 79.04,79.32 79.67,78.7 79.67,78.03
  IN1 w0.127: 79.67,78.03 79.67,77.63 82.79,74.51 83.77,74.51 85.91,72.36 85.91,66.52 79.27,59.88 79.27,55.64 78.85,55.22 78.85,52.25 78.35,51.75 78.35,49.62 78.22,49.49 77.75,49.49 77.62,49.62 v2(77.62,51.02)
  BOTTOM w0.089: JCPU1.H1 78.51,79.94 v2(79.04,79.41)
  BOTTOM w0.102: v2(77.62,51.02) 76.82,51.02 76.21,50.41 JDIMM1.132
DDR_A_D38: length 45.8
  IN1 w0.089: 82.37,78.03 81.08,79.32 80.94,79.32 80.26,80 80.26,81.06 80.45,81.25 80.45,81.57 80.21,81.81 80.07,81.81 78.47,83.41 78.04,83.41 v2(78.04,83.41)
  IN1 w0.127: 82.37,78.03 83.12,77.27 83.67,77.27 83.79,77.14 83.79,76.71 83.92,76.59 84.18,76.59 84.3,76.71 84.3,77.14 84.43,77.27 84.71,77.27 84.84,77.14 84.84,76.86 84.97,76.72 85.47,76.72 87.99,74.21 87.99,65.65 81.62,59.28 81.62,53.42 v2(80.75,52.56)
  BOTTOM w0.089: v2(78.04,83.41) 77.57,82.94 JCPU1.J4
  BOTTOM w0.102: JDIMM1.140 78.62,50.7 80.47,52.56 v2(80.75,52.56)
DDR_A_D39: length 45.5
  IN1 w0.089: 82.91,78.03 81.35,79.58 80.92,79.58 80.46,80.05 80.46,81.01 80.63,81.18 80.63,82.47 79.69,83.41 v2(79.04,83.41)
  IN1 w0.127: 82.91,78.03 83.28,77.65 85.08,77.65 88.37,74.36 88.37,65.49 82,59.12 82,51.4 81.64,51.04 v2(80.75,51.04)
  BOTTOM w0.089: JCPU1.H4 78.57,82.94 v2(79.04,83.41)
  BOTTOM w0.102: JDIMM1.142 79.21,50.76 79.49,51.04 v2(80.75,51.04)
DDR_A_D40: length 51.5
  IN1 w0.089: v2(81.04,81.41) 81.04,81.3 80.64,80.9 80.64,80.24 81,79.89 81.78,79.89 83.49,78.17 85.32,78.17 85.46,78.03
  IN1 w0.127: v2(83,54.06) 82.53,54.54 82.53,58.9 88.9,65.27 88.9,65.79 89.03,65.92 89.55,65.92 89.67,66.04 89.67,66.3 89.55,66.42 89.03,66.42 88.9,66.55 88.9,66.8 89.03,66.93 90.56,66.93 90.69,67.06 90.69,67.31 90.56,67.44 89.03,67.44 88.9,67.57 88.9,67.83 89.03,67.96 90.56,67.96 90.69,68.09 90.69,68.34 90.56,68.47 89.03,68.47 88.9,68.59 88.9,68.85 89.03,68.97 90.56,68.97 90.69,69.1 90.69,69.36 90.56,69.48 89.03,69.48 88.9,69.61 88.9,74.59 85.46,78.03
  BOTTOM w0.089: JCPU1.F2 80.57,80.94 v2(81.04,81.41)
  BOTTOM w0.102: JDIMM1.147 80.72,56.35 v2(83,54.06)
DDR_A_D41: length 50.7
  IN1 w0.089: 86,78.03 85.69,78.34 83.57,78.34 81.85,80.06 81.6,80.06 81.47,80.19 81.47,80.94 81.34,81.07 81.17,81.07 81.04,80.94 v2(81.04,80.41)
  IN1 w0.127: 86,78.03 89.29,74.74 89.29,73.19 89.41,73.06 90.9,73.06 91.03,72.94 91.03,72.68 90.9,72.56 89.41,72.56 89.29,72.43 89.29,72.15 89.41,72.02 90.94,72.02 91.07,71.9 91.07,71.64 90.94,71.51 89.41,71.51 89.29,71.39 89.29,71.13 89.41,71.01 90.94,71.01 91.07,70.88 91.07,70.63 90.94,70.5 89.41,70.5 89.29,70.37 89.29,70.12 89.41,69.99 90.94,69.99 91.07,69.86 91.07,66.9 83,58.83 v2(83,55.59)
  BOTTOM w0.089: v2(81.04,80.41) 80.57,79.94 JCPU1.F1
  BOTTOM w0.102: v2(83,55.59) 82.82,55.59 82.69,55.46 82.69,55.25 82.56,55.13 82.37,55.13 82.25,55.25 82.25,56.27 82.12,56.4 81.44,56.4 81.32,56.53 JDIMM1.149
DDR_A_D42: length 51
  IN1 w0.089: 87.23,80 85.02,80 84.11,80.91 83.92,80.91 83.4,81.42 v2(83.04,81.42)
  IN1 w0.127: 87.23,80 87.85,80 93.15,74.69 93.15,70.29 93.28,70.16 94.1,70.16 94.23,70.03 94.23,69.78 94.1,69.65 93.28,69.65 93.15,69.52 93.15,69.27 93.28,69.14 94.1,69.14 94.23,69.02 94.23,68.76 94.1,68.63 93.28,68.63 93.15,68.51 93.15,68.25 93.28,68.13 94.1,68.13 94.23,68 94.23,67.75 94.1,67.62 93.28,67.62 93.15,67.49 93.15,67.24 93.28,67.11 93.86,67.11 93.99,66.98 93.99,66.73 93.86,66.6 93.28,66.6 93.15,66.48 93.15,65.9 87.6,60.34 87.6,59.38 86.63,58.42 86.45,58.42 86.08,58.79 85.9,58.79 85.72,58.61 85.72,58.43 86.09,58.06 86.09,57.88 85.92,57.7 85.74,57.7 85.57,57.87 85.39,57.87 85.24,57.72 85.24,57.54 85.41,57.36 85.41,57.2 85.24,57.03 v2(85.24,55.59)
  BOTTOM w0.089: JCPU1.D2 82.56,80.94 v2(83.04,81.42)
  BOTTOM w0.102: v2(85.24,55.59) 84.71,55.59 84.58,55.46 84.58,54.18 84.45,54.06 84.25,54.06 84.13,54.18 84.13,55.96 83.72,56.37 JDIMM1.157
DDR_A_D43: length 51.4
  IN1 w0.089: 87.23,80.38 85.02,80.38 84.44,80.96 84.44,81.58 84.19,81.82 83.63,81.82 v2(83.04,82.41)
  IN1 w0.127: v2(85.24,54.06) 85.66,54.48 85.66,56.91 87.98,59.22 87.98,60.19 94.61,66.81 94.61,70.53 94.48,70.65 93.66,70.65 93.54,70.78 93.54,71.03 93.66,71.16 94.48,71.16 94.61,71.29 94.61,71.54 94.48,71.67 93.66,71.67 93.54,71.8 93.54,72.05 93.66,72.18 94.48,72.18 94.61,72.3 94.61,72.56 94.48,72.68 93.66,72.68 93.54,72.81 93.54,74.85 88.01,80.38 87.23,80.38
  BOTTOM w0.089: v2(83.04,82.41) 82.57,81.94 JCPU1.D3
  BOTTOM w0.102: v2(85.24,54.06) 85.53,54.06 85.66,53.94 85.66,53.13 85.79,53 86,53 86.13,53.13 86.13,55.28 85.42,55.99 84.81,55.99 84.32,56.49 JDIMM1.159
DDR_A_D44: length 49.4
  IN1 w0.089: 86.54,78.03 85.91,78.66 83.76,78.66 v2(83.02,79.41)
  IN1 w0.127: v2(83.02,52.54) 83.02,52.3 83.15,52.18 83.41,52.18 83.54,52.3 83.54,58.83 91.45,66.74 91.45,73.05 91.21,73.29 91.21,73.49 91.45,73.73 91.45,73.91 91.26,74.11 91.08,74.11 90.41,73.44 90.23,73.44 90.05,73.62 90.05,73.8 90.73,74.48 90.73,74.66 90.55,74.84 90.37,74.84 90.03,74.5 89.85,74.5 89.67,74.68 89.67,74.86 90.01,75.2 90.01,75.38 89.82,75.57 89.64,75.57 89.41,75.34 89.23,75.34 89.05,75.52 89.05,75.7 89.28,75.93 89.28,76.11 89.1,76.29 88.92,76.29 88.69,76.06 88.51,76.06 87.23,77.34 86.54,78.03
  BOTTOM w0.089: JCPU1.D1 82.51,79.91 v2(83.02,79.41)
  BOTTOM w0.102: v2(83.02,52.54) 82.71,52.54 82.59,52.67 82.59,53.89 82.46,54.01 82.29,54.01 82.17,53.89 82.17,51.87 80.74,50.45 80.55,50.45 80.42,50.31 JDIMM1.146
DDR_A_D45: length 52.5
  IN1 w0.089: 87.23,78.63 86.88,78.63 86.54,78.97 84.09,78.97 82.23,80.83 81.93,80.83 81.4,81.36 81.4,82.04 v2(81.04,82.4)
  IN1 w0.127: v2(83.02,51.02) 83.28,51.02 83.41,50.89 83.41,50.5 83.28,50.37 81.64,50.37 81.51,50.24 81.51,49.99 81.64,49.86 83.28,49.86 83.41,49.73 83.41,49.42 83.54,49.3 83.79,49.3 83.92,49.42 83.92,58.67 91.83,66.58 91.83,74.1 87.3,78.63 87.23,78.63
  BOTTOM w0.089: v2(81.04,82.4) 80.58,81.94 JCPU1.F3
  BOTTOM w0.102: v2(83.02,51.02) 81.74,51.02 81.02,50.29 JDIMM1.148
DDR_A_D46: length 51.2
  IN1 w0.089: 87.23,80.76 84.89,80.76 84.62,81.03 84.62,81.75 v2(84.02,82.35)
  IN1 w0.127: 87.23,80.76 88.17,80.76 93.92,75.01 93.92,74.21 94.04,74.08 94.85,74.08 94.97,73.95 94.97,73.7 94.85,73.57 94.04,73.57 93.92,73.45 93.92,73.19 94.04,73.07 94.86,73.07 94.99,72.94 94.99,66.65 88.36,60.03 88.36,59.07 86.04,56.75 86.04,52.13 85.92,52 85.61,52 85.48,52.13 85.48,52.41 85.36,52.54 v2(85.25,52.54)
  BOTTOM w0.089: v2(84.02,82.35) 83.61,81.94 JCPU1.C3
  BOTTOM w0.102: v2(85.25,52.54) 84.97,52.54 84.84,52.67 84.84,53.62 84.71,53.75 84.14,53.75 84.02,53.62 JDIMM1.158
DDR_A_D47: length 50.1
  IN1 w0.089: 87.23,81.14 86.24,81.14 86.04,81.34 v2(85.02,81.34)
  IN1 w0.127: v2(85.25,51.02) 85.76,51.02 85.88,50.89 85.88,49.97 86.01,49.84 86.3,49.84 86.43,49.97 86.43,56.59 88.74,58.91 88.74,59.87 95.37,66.5 95.37,74.1 88.33,81.14 87.23,81.14
  BOTTOM w0.089: v2(85.02,81.34) 84.51,81.85 JCPU1.B3
  BOTTOM w0.102: v2(85.25,51.02) 85.25,50.8 85.12,50.67 84.91,50.67 84.78,50.8 84.78,52.29 84.65,52.42 84.45,52.42 84.32,52.29 84.32,50.7 84.62,50.4 JDIMM1.160
DDR_A_D48: length 57.2
  IN1 w0.089: 87.23,83.03 85.4,83.03 v2(85.02,83.41)
  IN1 w0.127: v2(87.78,54.11) 88.36,54.11 88.5,54.26 88.5,56.29 91.19,58.99 91.19,59.95 97.92,66.68 97.92,70.53 97.79,70.66 97.17,70.66 97.05,70.79 97.05,71.04 97.17,71.17 97.79,71.17 97.92,71.3 97.92,71.55 97.79,71.68 97.17,71.68 97.05,71.8 97.05,72.06 97.17,72.18 97.79,72.18 97.92,72.31 97.92,72.57 97.79,72.69 97.17,72.69 97.05,72.82 97.05,73.07 97.17,73.2 97.79,73.2 97.92,73.33 97.92,82.32 95.23,85.01 89.82,85.01 87.84,83.03 87.23,83.03
  BOTTOM w0.089: v2(85.02,83.41) 84.51,83.92 JCPU1.B5
  BOTTOM w0.102: v2(87.78,54.11) 87.31,54.59 87.31,54.82 85.51,56.61 JDIMM1.163
DDR_A_D49: length 58.9
  IN1 w0.089: 87.23,82.65 87.04,82.65 86.9,82.79 85.03,82.79 84.51,83.3 84.51,83.59 84.27,83.83 83.94,83.83 83.5,84.27 83.5,84.59 83.11,84.99 82.46,84.99 v2(82.04,85.41)
  IN1 w0.127: v2(87.78,55.63) 87.78,56.12 90.04,58.37 90.04,59.33 96.66,65.96 96.66,66.47 96.79,66.6 97.3,66.6 97.43,66.72 97.43,66.98 97.3,67.1 96.79,67.1 96.66,67.23 96.66,67.49 96.79,67.61 97.41,67.61 97.54,67.74 97.54,67.99 97.41,68.12 96.79,68.12 96.66,68.25 96.66,68.5 96.79,68.63 97.41,68.63 97.54,68.76 97.54,69.01 97.41,69.14 96.79,69.14 96.66,69.26 96.66,69.52 96.79,69.64 97.41,69.64 97.54,69.77 97.54,70.03 97.41,70.15 96.79,70.15 96.66,70.28 96.66,73.23 97.54,74.11 97.54,82.16 95.08,84.63 89.98,84.63 88,82.65 87.23,82.65
  BOTTOM w0.089: JCPU1.E6 81.57,84.94 v2(82.04,85.41)
  BOTTOM w0.102: JDIMM1.165 86.12,56.44 86.93,55.63 v2(87.78,55.63)
DDR_A_D50: length 56.2
  IN1 w0.089: v2(86.04,84.41) 86.92,84.41 87.23,84.72
  IN1 w0.127: 87.23,84.72 88.85,86.34 95.77,86.34 99.24,82.87 99.24,71.27 99.37,71.14 99.93,71.14 100.06,71.02 100.06,70.76 99.93,70.63 99.37,70.63 99.24,70.51 99.24,70.25 99.37,70.13 99.93,70.13 100.06,70 100.06,69.75 99.93,69.62 99.37,69.62 99.24,69.49 99.24,69.24 99.37,69.11 99.93,69.11 100.06,68.98 100.06,68.73 99.93,68.6 99.37,68.6 99.24,68.48 99.24,68.16 99.37,68.03 99.93,68.03 100.06,67.9 100.06,67.65 99.93,67.52 99.37,67.52 99.24,67.39 99.24,67.14 99.37,67.01 99.82,67.01 99.95,66.89 99.95,66.63 99.82,66.51 99.37,66.51 99.24,66.38 99.24,65.92 93.76,60.44 93.76,59.68 90.32,56.25 v2(90.32,55.63)
  BOTTOM w0.089: JCPU1.A5 85.57,83.94 v2(86.04,84.41)
  BOTTOM w0.102: JDIMM1.175 89.12,56.52 89.22,56.41 89.54,56.41 v2(90.32,55.63)
