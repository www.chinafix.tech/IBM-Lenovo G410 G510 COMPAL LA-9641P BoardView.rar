# Allegro board IBM-Lenovo G410 G510 COMPAL LA-9641P BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SPI_CS#: length 49.4
  TOP w0.102: v2(111.42,95.29) 111.15,95.56 111.15,98.73 111.44,99.02 v3(111.44,102.32) v2(110.81,102.94) ; U4.AJ7 123.65,91.51 123.41,91.51 v2(123.25,91.35)
  IN1 w0.127: v2(109.9,86.45) 109.9,93.76 v2(111.42,95.29)
  BOTTOM w0.089: v2(123.25,91.35) 122.89,91.35 122.74,91.5 122.74,93.42 122.66,93.49 122.66,94.79
  BOTTOM w0.102: v2(109.9,86.45) 109.07,86.45 108.85,86.67 U8.1 ; v2(111.42,95.29) 111.06,95.29 110.01,94.24 110.01,92.36 110.32,92.06 RP2.4 ; 122.66,94.79 122.66,95.36 122.99,95.69 122.99,96.67 122.37,97.29 122.37,99.48 122.24,99.61 122.24,102.88 121.93,103.2 119.08,103.2 118.97,103.31 115.55,103.31 115.07,103.79 112.3,103.79 111.45,102.94 v2(110.81,102.94)
SPI_HOLD#: length 13.3
  TOP w0.102: v2(108.02,104.3) v3(108.02,103.5) 108.02,102.78 109.24,101.56 109.24,100.68 108.44,99.88 108.44,96.61 108.35,96.52 v2(108.35,96.14)
  BOTTOM w0.102: v2(108.02,104.3) 108.03,104.32 109.06,104.32 109.88,105.13 R245.1 ; U8.7 107.58,95.36 v2(108.35,96.14)
SPI_IO2: length 40.6
  TOP w0.089: U4.AJ4 123.56,92.51 123.28,92.24 v2(123.28,91.98)
  IN1 w0.089: v2(123.28,91.98) 123.49,92.18 123.49,92.76 121.76,94.48 121.76,94.79
  IN1 w0.127: 121.76,94.79 121.76,95.25 121.55,95.47 121.55,98.27 122.39,99.12 122.39,99.83 122.97,100.42 122.97,101.35 123.92,102.29 123.92,103.56 123.25,104.23 122.26,104.23 v2(121.55,104.94)
  IN2 w0.127: v2(121.55,104.94) 118.77,104.94 114.72,100.89 113.74,100.89 113.47,100.61 113.05,100.61 111.63,102.03 111.63,103.53 111.97,103.87 111.97,106.79 v2(112.07,106.89)
  BOTTOM w0.102: v2(112.07,106.89) 111.84,107.12 107.87,107.12 107.59,106.84 R229.2 R246.2
SPI_IO3: length 30.4
  TOP w0.089: v2(123.54,94.97) 123.44,94.87 123.44,93.95 123.58,93.81 U4.AJ2
  IN1 w0.127: v2(123.54,94.97) 123.54,96.26 123.41,96.39 122.84,96.39 122.71,96.52 122.71,96.82 122.84,96.95 123.41,96.95 123.54,97.08 123.54,97.43 123.41,97.56 122.84,97.56 122.71,97.69 122.71,97.97 122.84,98.09 123.52,98.09 123.65,98.22 123.65,99.55 124.34,100.24 124.34,101.06 124.94,101.66 124.94,104.81 123.41,106.33 111.68,106.33 v2(111.49,106.52)
  BOTTOM w0.102: v2(111.49,106.52) R230.2 R245.2
SPI_SB_CS1#: length 0.6
  TOP w0.089: v2(122.27,91.97) 122.64,91.6 U4.AL7
SPI_SI: length 53.4
  TOP w0.089: U4.AH1 124.21,94.38 124.21,96.14 123.55,96.81 123.55,97.07
  TOP w0.102: v2(122.97,104.87) 122.46,104.37 v1(122.46,103.81) 122.46,103.16 122.83,102.79 122.83,98.97 123.55,98.24 123.55,97.07 ; v2(107.8,101.24) 107.6,101.04 107.6,100.33 106.56,99.29 106.56,90.33 v2(107.42,89.47)
  BOTTOM w0.102: v2(107.8,101.24) 107.8,101.97 110.48,104.65 120.61,104.65 121.11,104.14 122.6,104.14 122.97,104.51 v2(122.97,104.87) ; RP2.2 109.12,91.06 107.53,89.47 v2(107.42,89.47) 105.73,89.47 105.04,90.17 U8.5
SPI_SO: length 50.1
  TOP w0.089: U4.AH3 123.96,93.72 123.68,94.01 123.68,94.47 123.96,94.75 123.96,96.14 123.25,96.86 123.25,97.07
  TOP w0.102: v2(107.17,101.24) 107.17,100.33 106.26,99.41 106.26,89.33 106.93,88.66 v2(108.11,88.66) ; 123.25,97.07 123.25,97.97 122.49,98.72 v1(122.49,99.67) 122.49,102.63 122.13,102.99 122.13,104.76 v2(122.27,104.9)
  BOTTOM w0.102: v2(107.17,101.24) 107.17,102.49 108.19,103.5 108.68,103.5 110.14,104.96 120.84,104.96 121.33,104.47 122.08,104.47 122.27,104.66 v2(122.27,104.9) ; RP2.1 109.2,90.56 108.34,89.7 108.34,88.88 v2(108.11,88.66) 107.58,88.12 U8.2
SPI_WP#: length 27.6
  TOP w0.102: v2(108.08,84.4) 108.22,84.4 108.86,85.04 108.86,88.97 v3(107.7,90.13) 106.87,90.97 106.87,99.12 107.91,100.16 107.91,100.64 108.21,100.95 108.21,102.26 107.58,102.9 107.58,104.44 v2(108.03,104.9)
  BOTTOM w0.102: v2(108.08,84.4) 106.31,86.18 U8.3 ; v2(108.03,104.9) 108.5,105.37 R246.1
SPK_L1-: length 96.4
  TOP w0.203: v2(157.39,52.66) 157.05,52.32 UA1.14
  TOP w0.508: v2(185.95,123.71) 185.59,123.71 185.47,123.58 v1(182.47,123.58) 181.44,123.58 180.13,124.89 180.13,125.28 LA3.1
  IN1 w0.508: v2(185.95,123.71) 185.61,123.71 182.72,120.82 182.72,97.79 183.26,97.25 183.26,82.15 182.37,81.26 182.37,79.05 181.87,78.56 181.87,76.67 181.41,76.21 181.41,74.43 170.43,63.44 170.43,59.47 168.47,57.51 161.27,57.51 159.65,55.88 159.65,55.35 157.58,53.28 157.58,52.85 v2(157.39,52.66)
SPK_L1-_CONN: length 6.8
  TOP w0.508: LA3.2 180.19,127.63 CA39.1 180.19,128.89 179.71,129.37 v1(179.71,129.72) 180.16,130.16 DA3.3 181.36,130.16 181.67,129.85 v2(181.67,129.49)
  BOTTOM w0.508: v2(181.67,129.49) 181.43,129.73 JSPK1.3
SPK_L2+: length 96.5
  TOP w0.203: UA1.12 157.85,52.02 158.31,52.49 v2(158.31,52.64)
  TOP w0.508: v2(185.97,123.07) 185.85,122.95 v1(184.78,122.95) 181.18,122.95 179.5,124.63 179.5,125.27 LA4.1
  IN1 w0.508: v2(158.31,52.64) 158.21,52.74 158.21,53.02 160.28,55.09 160.28,55.62 161.53,56.87 168.73,56.87 171.06,59.2 171.06,63.18 182.05,74.16 182.05,75.95 182.51,76.4 182.51,78.3 183,78.79 183,81 183.89,81.89 183.89,97.52 183.36,98.05 183.36,120.55 185.86,123.06 185.95,123.06 185.97,123.07 v2(185.97,123.07)
SPK_L2+_CONN: length 10.7
  TOP w0.508: LA4.2 179.31,127.5 CA38.1 179.31,128.78 179.04,129.04 179.04,129.68 178.66,130.06 178.66,131.1 v1(179.36,131.8) 179.62,132.06 DA3.1 181.36,132.06 v2(181.8,132.5)
  BOTTOM w0.508: JSPK1.4 180.18,131.3 181.38,132.5 v2(181.8,132.5)
SPK_R1-: length 90.5
  TOP w0.203: UA1.15 156.65,52.54 v2(156.6,52.59)
  TOP w0.508: v2(185.03,124.56) 185.03,124.91 185.54,125.41 LA1.1
  IN1 w0.508: v2(185.03,124.56) 185.03,124.22 181.96,121.14 181.96,97.09 182.4,96.64 182.4,92.67 181.96,92.22 181.96,82.66 181.58,82.28 181.58,79.48 181.06,78.96 181.06,77.1 180.32,76.37 180.32,74.41 169.65,63.74 169.65,61.92 166,58.27 159.38,58.27 157.5,56.39 157.5,54.53 156.42,53.45 156.42,52.77 v2(156.6,52.59)
SPK_R1-_CONN: length 11.1
  TOP w0.508: LA1.2 185.18,127.52 CA43.1 185.18,130.44 185.52,130.78 185.52,131.56 185.01,132.06 v1(184.59,132.06) DA3.6 182.57,132.06 v2(182.24,131.73)
  BOTTOM w0.508: JSPK1.1 183.93,131.58 183.59,131.92 182.43,131.92 v2(182.24,131.73)
SPK_R2+: length 90.5
  TOP w0.203: UA1.17 155.85,52.38 v2(155.65,52.58)
  TOP w0.508: LA2.1 183.95,125.4 184.4,124.95 v2(184.4,124.56)
  IN1 w0.508: v2(184.4,124.56) 184.4,124.48 181.33,121.41 181.33,96.83 181.77,96.38 181.77,92.93 181.33,92.49 181.33,82.92 180.94,82.54 180.94,79.74 180.42,79.22 180.42,77.37 179.69,76.63 179.69,74.68 169.02,64.01 169.02,62.19 165.74,58.9 159.12,58.9 156.87,56.65 156.87,54.8 155.81,53.74 155.81,52.74 v2(155.65,52.58)
SPK_R2+_CONN: length 6.6
  TOP w0.508: v2(182.44,129.54) 182.44,129.82 182.79,130.16 DA3.4 183.94,130.16 184.42,129.68 v1(184.42,129.38) 184.42,128.56 CA40.1 184.27,127.47 LA2.2
  BOTTOM w0.508: JSPK1.2 182.68,129.77 v2(182.44,129.54)
SRN: length 26.2
  TOP w0.102: v1(190.18,171.93) 189.77,172.34 PC305.1
  TOP w0.254: v2(173.41,167.4) 173.34,167.32 173.01,167.32 171.95,168.38 170.42,168.38 170.15,168.65 PR324.3 ; PR317.2 187.98,172.33 PC306.2 ; PC306.2 v4(187.97,173.07) ; PC306.2 188.92,172.34 PC305.1
  IN2 w0.254: v4(187.97,173.07) 187.46,173.58 186.81,173.58 185.02,171.79 183.79,171.79 179.89,167.89 175.01,167.89 174.43,167.31 173.5,167.31 v2(173.41,167.4)
SRP: length 25
  TOP w0.102: v1(185,171.49) 185.85,172.34 PC309.1
  TOP w0.254: v2(173.43,166.81) 173.34,166.9 172.89,166.9 171.79,168 170.33,168 170.15,167.82 PR324.2 ; PR318.2 187.09,172.31 PC306.1 ; PC306.1 186.17,172.34 PC309.1 ; PC306.1 v4(187.06,173.02)
  IN2 w0.254: v2(173.43,166.81) 173.54,166.93 174.62,166.93 175.19,167.5 180.08,167.5 183.91,171.33 185.12,171.33 186.81,173.02 v4(187.06,173.02)
SUS_STAT#: length 1.2
  TOP w0.102: v2(128.76,91.94) 128.41,91.6 U4.U7
  BOTTOM w0.089: v2(128.76,91.94) 128.92,91.94 T20.1
SUSACK#: length 48.9
  TOP w0.102: U31.70 159.39,86.96 v2(158.74,86.31)
  IN1 w0.089: 136.76,92.63 136.72,92.63 136.29,93.06 136.29,93.35 135.91,93.74 v2(135.91,94.03)
  IN1 w0.127: v2(158.74,86.31) 157.55,85.11 146.84,85.11 140.82,91.13 139.24,91.13 137.74,92.63 136.76,92.63
  BOTTOM w0.089: v2(135.91,94.03) 135.74,94.19 134.65,94.19 R136.1
  BOTTOM w0.102: v1(159.62,102.88) 159.62,102.19 158.96,101.53 158.96,91.04 158.41,90.49 158.41,86.64 v2(158.74,86.31)
SUSACK#_R: length 7.3
  TOP w0.102: U4.R6 129.33,92.19 v2(129.65,92.51)
  IN1 w0.089: 131.33,94.79 129.65,93.11 v2(129.65,92.51)
  IN1 w0.127: 131.33,94.79 131.33,94.84 v2(131.45,94.97)
  BOTTOM w0.089: R136.2 133.25,94.79
  BOTTOM w0.102: 133.25,94.79 133.25,95.06 133,95.31 132.6,95.31 v1(132.35,95.55) ; v2(131.45,94.97) 131.95,94.48 R169.2 133.06,94.48 R136.2
SUSCLK: length 78.1
  TOP w0.102: v2(127.76,92.57) 127.66,92.57 U4.Y6 ; C93.1 R740.1 172.47,72.33 172.17,72.63 v1(172.17,73.23) 172.17,73.3 172.42,73.56 172.42,73.92 172.39,73.96 U31.122 172.39,76 v2(172.08,76.31)
  IN2 w0.089: v2(127.76,92.57) 128.08,92.89 129.78,92.89 130.2,92.47 130.2,90.04 129.95,89.79 129.95,88.88 130.28,88.55 130.28,85.06 130.88,84.46 130.88,82.97 131.43,82.42 132.14,82.42 134.25,80.31 134.25,79.18 133.87,78.8 132.16,78.8 v2(131.83,78.47)
  IN2 w0.127: v2(148.58,77.49) 148.81,77.26 157.05,77.26 158.02,76.3 158.99,76.3 160.64,77.95 162.52,77.95 163.85,76.62 167.88,76.62 168.64,77.38 169.29,77.38 169.9,76.77 171.62,76.77 v2(172.08,76.31)
  BOTTOM w0.089: 132.16,74.85 132.15,74.86 132.15,75.07 131.83,75.38 v2(131.83,78.47)
  BOTTOM w0.102: v2(148.58,77.49) 148.58,77.04 143.11,71.56 137.89,71.56 137.31,72.15 133.92,72.15 133.6,72.46 133.6,73.86 133.47,73.99 133.03,73.99 132.16,74.85
SUSP: length 305.5
  TOP w0.254: v2(121.72,16.89) 122.85,18.02 122.85,44.75 119.05,48.55 111.24,48.55 110.67,49.13 Q116.2 v2(110.67,52.15) 107.41,52.15 106.15,53.42 106.15,56.57 98.2,64.52 v3(98.2,75.79) 98.2,85.65 96.97,86.88 92.05,86.88 91.61,87.32 Q1.2 ; v2(157.31,68.31) Q117.1 157.31,71.29 157.77,71.76 R653.2 157.77,72.35 R652.1 ; Q111.2 70.29,16.98 69.65,16.34 68.68,16.34 68.3,15.96 Q108.2 68.3,13.94 v2(68.32,13.92)
  IN1 w0.254: v2(121.72,16.89) 121.7,16.89 130.66,7.92 134.96,7.92 v2(136.78,6.1) ; v2(110.67,52.15) 110.67,52.66 111.13,53.12 123.78,53.12 129.7,59.04 134.02,59.04 141.26,66.28 151.94,66.28 154.4,68.74 156.87,68.74 v2(157.31,68.31)
  IN2 w0.254: v2(121.72,16.89) 120.7,17.92 97.48,17.92 93.34,13.78 68.45,13.78 v2(68.32,13.92) ; v2(187.76,6.14) 187.79,6.1 v2(136.78,6.1)
  BOTTOM w0.254: Q113.2 193.31,12.48 193.05,12.21 192.37,12.21 191.88,11.73 188.96,11.73 187.76,10.53 v2(187.76,6.14) ; Q107.2 142.5,4.51 142.31,4.69 140.85,4.69 140.25,5.3 Q110.2 137.01,5.3 136.78,5.52 v2(136.78,6.1)
SUSP#: length 288
  TOP w0.203: U31.116 169.99,73.92 v2(169.78,73.71)
  TOP w0.254: v2(200.17,13.7) 199.7,14.17 PR601.1 ; Q117.2 156.34,67.87 157.15,67.06 v3(157.15,64.7) 158.55,64.7 160.95,62.3 160.95,61.82 v2(163,59.77) ; v2(27.69,9.8) 27.7,9.81 PR502.1 ; PR701.1 v2(97.99,31.71)
  IN1 w0.254: v2(163,59.77) 163,59.83 166.83,63.66 166.83,65.54 169.51,68.22 169.51,73.44 v2(169.78,73.71) ; v2(94.72,14.18) 94.72,28.05 97.99,31.32 v2(97.99,31.71)
  IN2 w0.254: v2(27.69,9.8) 27.69,10.66 29.32,12.29 31.9,12.29 33.93,14.33 42.15,14.33 43.95,16.13 49.27,16.13 49.75,16.61 64.75,16.61 68.1,13.26 93.8,13.26 v2(94.72,14.18) 97.89,17.35 120.07,17.35 122.17,15.25 v2(179.86,15.25) 187.8,15.25 188.87,14.18 199.69,14.18 v2(200.17,13.7)
  BOTTOM w0.254: v2(179.86,15.25) 181.34,16.72 181.34,40.41 176.21,45.54 176.21,52.61 173.99,54.82 167.79,54.82 163,59.61 v2(163,59.77)
SUSWARN#: length 34.1
  TOP w0.102: v2(155.13,90.24) v1(155.13,89.42) 155.13,88.73 155.03,88.64 155.03,85.87 155.76,85.14 158.82,85.14 159.84,86.16 U31.72
  IN1 w0.127: v2(155.13,90.24) 155,90.37 147.6,90.37 145.29,92.68 140.01,92.68 138.34,94.36 136.57,94.36 v2(136.46,94.26)
  BOTTOM w0.089: v2(136.46,94.26) 136.44,94.23 136.44,93.91 136.13,93.6 134.78,93.6 134.61,93.77 R148.1
SUSWARN#_R: length 9.9
  TOP w0.089: U4.J4 132.03,92.79 v2(132.16,92.67)
  IN1 w0.089: 132.92,94.79 132.78,94.66 132.78,94.27 131.97,93.46 131.97,92.83 132.15,92.65 v2(132.16,92.67)
  IN1 w0.127: 132.92,94.79 133.69,95.56 133.69,96.19 v2(133.59,96.29)
  BOTTOM w0.089: v1(132.37,92.2) 132.37,92.45 v2(132.16,92.67)
  BOTTOM w0.102: v2(132.16,92.67) 132,92.83 132,93.26 R169.1 132.68,93.57 132.88,93.77 R148.2 ; RP10.5 132.81,96.34 132.99,96.16 133.46,96.16 v2(133.59,96.29)
SW1:
  vias: v1(37.15,125.98) v4(32.3,119.29) v4(32.34,118.65) v4(32.32,117.99) v4(32.32,117.35) v4(33.05,119.28) v4(33.04,117.97) v4(33.02,117.34) v4(33.06,118.64) v4(33.77,119.29) v4(33.81,118.64) v4(33.79,117.98) v4(33.81,117.33) v4(34.2,116.75) v4(34.51,119.28) v4(34.52,118.63) v4(34.5,117.96) v4(34.51,117.31) v4(34.91,116.74) v4(35.22,119.27) v4(35.23,118.61) v4(35.24,117.98) v4(35.26,117.32) v4(35.93,119.65) v4(35.93,119.01) v4(35.92,118.33) v4(35.93,117.68)
SW1_VGA:
  vias: v1(171.58,146.35) v2(171.24,146.9)
SW2:
  vias: v1(39.69,102.4) v4(32.15,92.48) v4(32.86,92.47) v4(39.1,100.38) v4(39.1,99.68) v4(39.8,100.38) v4(39.8,99.68) v4(40.49,100.38) v4(40.49,99.68) v4(41.19,103.87) v4(41.19,103.17) v4(41.19,102.47) v4(41.19,101.78) v4(41.19,101.08) v4(41.19,100.38) v4(41.89,103.87) v4(41.89,103.17) v4(41.89,102.47) v4(41.89,101.78) v4(41.89,101.08) v4(41.89,100.38) v4(42.59,103.87) v4(42.59,103.17) v4(42.59,102.47) v4(42.59,101.78) v4(42.59,101.08) v4(42.59,100.38)
SW2_VGA:
  vias: v1(167.89,140.52) v4(170.84,138.35)
SW3: length 15.7
  TOP w0.508: PC913.2 26.8,118.87 27.03,119.11 v4(27.56,119.11)
  IN1 w1.016: 22.14,110.21 27.25,110.21 29.74,112.7 29.74,118.26 29.49,118.51
  vias: v1(25.59,108.32) v4(18.63,105.5) v4(18.64,104.09) v4(18.65,104.8) v4(18.67,103.38) v4(18.68,102.68) v4(18.68,102) v4(19.38,105.49) v4(19.4,104.78) v4(19.38,104.07) v4(19.42,103.37) v4(19.44,102.67) v4(19.43,101.99) v4(20.99,105.2) v4(20.99,104.24) v4(20.98,103.34) v4(21.67,107.29) v4(21.72,104.72) v4(21.75,103.83) v4(21.75,102.93) v4(21.81,109.17) v4(22.33,107.27) v4(22.45,109.15) v4(22.45,105.18) v4(22.45,104.3) v4(22.45,103.43) v4(22.99,107.27) v4(23.26,104.75) v4(23.26,103.91) v4(23.27,102.97) v4(23.65,107.26) v4(28.2,119.09)
SWN1: length 26.2
  TOP w0.254: v2(38.03,119.71) 37.93,119.61 37.93,117.35 33.13,112.56 v1(32.56,112.56) 30.07,112.56 29.47,111.96 25.81,111.96 v2(25.78,112) 25.77,112 PR931.1
  BOTTOM w0.254: v2(25.78,112) 26.13,112.36 PR920.2 ; v2(38.03,119.71) 37.89,119.57 37.23,119.57 36.98,119.82 36.98,121.46 36.73,121.71 PL902.2
SWN2: length 36.1
  TOP w0.254: v2(22.57,113.64) PR930.1
  IN2 w0.254: v2(37.03,117.84) 37.84,117.03 37.84,110.01 38.29,109.56 v2(38.29,107.39)
  BOTTOM w0.254: v2(38.29,107.39) 38.34,107.34 PL903.2 ; v2(37.03,117.84) 37.27,117.6 37.27,116.65 33.5,112.87 27.73,112.87 26.33,111.48 24.72,111.48 22.57,113.63 v2(22.57,113.64) 23.04,114.11 PR919.2
SWN3: length 14.3
  TOP w0.102: v2(19.69,113.71) 19.16,113.71 v1(18.9,113.46)
  TOP w0.254: PR929.1 v2(19.69,113.71)
  BOTTOM w0.254: PL904.2 23.43,108.06 24.11,108.74 24.11,109.63 21.21,112.52 21.21,113.78 PR918.2 20.1,114.12 v2(19.69,113.71)
SYS_PWROK: length 140.9
  TOP w0.102: R32.1 95.26,89.93 95.93,90.6 v2(95.93,91.97) ; v2(123.6,104.9) 124.16,104.34 127.13,104.34 128.09,103.39 129.08,103.39 129.14,103.32 142.51,103.32 145.02,100.81 148.57,100.81 151.99,97.39 153.68,97.39 155.4,95.67 156.06,95.67 162.9,88.83 166.95,88.83 171.11,84.67 171.11,80.48 v2(171.27,80.32) ; U4.AD7 125.59,91.6 v2(125.21,91.98) ; U31.86 159.86,80.56 159.47,80.95 v2(158.95,80.95)
  IN1 w0.089: 122.71,94.79 122.71,94.36 123.88,93.19 123.88,92.21 124.11,91.98 v2(125.21,91.98)
  IN1 w0.127: v2(158.95,80.95) 159.84,80.95 161.14,79.64 163.61,79.64 165.11,78.14 170.07,78.14 171.27,79.33 v2(171.27,80.32) ; v2(96.96,102.64) 99.38,102.64 101.59,104.85 103.37,104.85 103.92,104.3 v2(104.07,104.3) ; 122.71,94.79 122.71,95.8 122.28,96.24 v2(122.05,96.24) 122.05,98.06 123.14,99.15 123.14,99.76 123.83,100.45 123.83,101.49 124.43,102.08 124.43,104.08 v2(123.6,104.9)
  BOTTOM w0.102: v2(95.93,91.97) 95.93,92.81 95.19,93.55 95.19,95.74 94.75,96.19 v1(94.75,97.27) 94.75,98.75 96.96,100.97 v2(96.96,102.64) ; v2(104.07,104.3) 104.22,104.3 107.53,107.6 112.75,107.6 114.88,105.47 123.03,105.47 v2(123.6,104.9) ; v2(122.05,96.24) 121.76,96.24 R157.1 121.35,96.65 U6.4
SYS_RST#: length 7.9
  TOP w0.089: U4.AM1 122.34,94.28 122.62,94.56 122.62,95.06 122.47,95.21 121.86,95.21
  TOP w0.102: R138.1 120.72,99.81 120.72,96.72 v1(121.25,96.19) 121.67,95.77 121.67,95.39 121.86,95.21
SYSON: length 187
  TOP w0.102: 27.76,7.07 27.72,7.07 v2(27.71,7.06) ; v2(95.51,13.99) v3(96.2,13.99) ; C492.1 158.91,76.98 v2(158.94,76.96) U31.95
  TOP w0.254: PR505.1 27.76,7.07
  IN1 w0.127: v2(158.94,76.96) 158.25,76.27 158.25,73.28 151.57,66.6 141.05,66.6 133.9,59.45 129.66,59.45 123.65,53.44 107.04,53.44 103.55,49.95 103.55,45.16 102.02,43.63 102.02,39.56 100.71,38.25 100.71,30.07 95.53,24.9 95.53,13.98 95.51,13.96 v2(95.51,13.99)
  IN2 w0.254: v2(95.51,13.99) 95.51,13.96 94.31,12.76 68.1,12.76 67.99,12.88 67.94,12.88 64.6,16.21 49.89,16.21 49.43,15.75 44.42,15.75 42.24,13.56 39.35,13.56 38.42,12.63 32.77,12.63 32.05,11.91 29.48,11.91 28.21,10.64 28.21,7.56 v2(27.71,7.06)
TESTEN: length 20.3
  TOP w0.102: v1(129.01,125.31) 129.93,124.4 RV18.2 131.2,124.49 RV19.2 131.2,125.49 131.68,125.97 v2(131.68,126.16)
  IN1 w0.102: v2(131.68,126.16) 137.71,126.16 139.62,128.07 139.62,133.8 v2(139.25,134.17)
  BOTTOM w0.102: v2(139.25,134.17) 139.75,134.67 UV1.AD28
THERM_D+: length 83.8
  TOP w0.254: v2(147.17,135.71) 146.93,135.47 145.9,135.47 144.68,134.24 144.68,133.62 144.15,133.09 143.72,133.09 143.16,133.65 141.71,133.65 v2(141.52,133.46) ; v2(150.83,70.39) 150.83,70.48 151.58,71.23 152.92,71.23 153.19,71.51 153.19,72.06 153.03,72.22 152.88,72.22 RV16.2
  IN2 w0.254: v2(147.17,135.71) 147.03,135.57 146.37,135.57 146.02,135.21 146.02,133.88 147.2,132.7 147.2,131.29 149.42,129.07 149.42,128.74 153.6,124.56 153.6,122.71 v2(153.56,122.67)
  BOTTOM w0.254: UV1.AF29 141.11,133.87 v2(141.52,133.46) ; v2(150.83,70.39) 150.91,70.47 150.91,75.26 151.74,76.09 151.74,87.01 151.28,87.47 151.28,98.64 154.55,101.92 154.55,121.25 153.56,122.24 v2(153.56,122.67)
THERM_D-: length 82.9
  TOP w0.254: RV17.2 152.85,72.81 153.36,72.81 153.7,72.46 153.7,71.3 153.13,70.72 151.8,70.72 v2(151.44,70.37) ; v2(142.86,133.08) 142.97,133.08 143.47,132.59 144.41,132.59 145.19,133.37 145.19,134.02 146.13,134.96 146.71,134.96 v2(147,134.67)
  IN2 w0.254: v2(147,134.67) 147.06,134.74 147.06,134.97 146.95,135.09 146.63,135.09 146.54,135 146.54,134.11 147.71,132.94 147.71,131.57 149.97,129.31 149.97,128.93 154.11,124.79 154.11,122.71 v2(154.15,122.67)
  BOTTOM w0.254: UV1.AG29 142.25,133.68 v2(142.86,133.08) ; v2(154.15,122.67) 154.15,122.39 155.06,121.47 155.06,101.67 151.79,98.4 151.79,87.69 152.25,87.22 152.25,75.82 151.42,74.99 151.42,70.39 v2(151.44,70.37)
THM_ALERT#: length 18.3
  TOP w0.102: v2(133.59,123.62) 133.59,123.3 133.46,123.18 RV6.2 ; v2(141.5,132.66) 141.76,132.66 v1(142.2,133.09)
  IN2 w0.102: 135.62,124.77 135.62,127.87 136.95,129.21 136.95,129.52 137.27,129.84 138.03,129.84 138.6,130.41 138.6,131.81 139.45,132.66 v2(141.5,132.66)
  IN2 w0.127: v2(133.59,123.62) 134.16,123.05 134.79,123.05 135.62,123.87 135.62,124.77
  BOTTOM w0.102: v2(141.5,132.66) 141.91,133.07 UV1.AG30
TL_ENVDD: length 11.7
  TOP w0.254: v2(87.47,126.62) 87,127.09 UT2.15
  IN1 w1.524: 93.62,136.66 93.62,126.26
  vias: v1(90.99,138.07) v2(88.01,126.33) v2(88.56,126.54) v2(92.76,138.2) v2(93.3,138.5) v2(93.28,137.88)
TL_HPD: length 46.9
  TOP w0.102: R458.1 v2(94.64,102.85) ; UT2.32 84,133.29 83.81,133.47 79.98,133.47 77.53,131.02 77.53,124.47 v1(78.8,123.2) 82.58,119.42 85,119.42 v2(87.85,116.56)
  IN1 w0.127: v2(94.64,102.85) 92.22,102.85 91.14,103.93 91.14,108.7 90.37,109.47 90.37,114.04 v2(87.85,116.56)
TL_INVT_PWM: length 36.9
  TOP w0.102: UT2.14 86.5,126.94 87.66,125.79 88.54,125.79 v2(88.7,125.95) ; R441.1 100.57,145.97 101.16,145.38 101.16,137.97 v1(98.09,134.9) 97.98,134.79 v2(97.98,125.95)
  IN2 w0.127: v2(88.7,125.95) v2(97.98,125.95)
TMDS_B_CLK#_PCH: length 160.9
  IN1 w0.089: v2(68.97,110.42) 68.97,110.22 69.07,110.12 69.27,110.12 69.62,109.78 69.62,109.28 69.86,109.04 71.39,109.04 71.55,109.19 72.53,109.19 72.78,108.94 73.38,108.94 76.72,105.6 76.72,101.67 79.7,98.69 79.7,96.99 80.67,96.02 86.27,96.02 87.05,96.8 87.23,96.8
  IN1 w0.127: v2(99.7,95.78) 99.58,95.91 99.58,96.99 98.2,98.36 91.89,98.36 90.33,96.8 87.23,96.8
  IN2 w0.127: v2(99.7,95.78) 99.7,95.21 107.58,87.34 107.58,66.05 107.96,65.67 107.96,64.86 v2(108.05,64.77)
  BOTTOM w0.089: v2(68.97,110.42) 69.45,109.94 JCPU1.U31
  BOTTOM w0.102: v2(108.05,64.77) 107.93,64.88 107.93,65.33 106.09,67.17 86.72,67.17 86.06,66.51 28.35,66.51 28.24,66.62 27.47,66.62 C46.2
TMDS_B_CLK_PCH: length 160.8
  IN1 w0.089: v2(68.97,109.47) 68.97,109.81 69.06,109.9 69.18,109.9 69.4,109.69 69.4,109.19 69.77,108.82 71.48,108.82 71.64,108.98 72.44,108.98 72.69,108.72 73.29,108.72 76.5,105.51 76.5,101.58 79.48,98.6 79.48,96.9 80.58,95.8 86.36,95.8 87.12,96.56 87.2,96.56 87.22,96.54 87.23,96.54
  IN1 w0.127: v2(99.12,95.78) 99.32,95.99 99.32,96.88 98.1,98.1 91.99,98.1 90.43,96.54 87.23,96.54
  IN2 w0.127: v2(99.12,95.78) 99.12,95.77 99.45,95.44 99.45,95.11 107.32,87.23 107.32,65.94 107.7,65.56 107.7,65.01 v2(107.46,64.77)
  BOTTOM w0.089: JCPU1.V31 68.51,109.93 v2(68.97,109.47)
  BOTTOM w0.102: C47.2 27.23,66.34 27.29,66.4 28.15,66.4 28.26,66.29 86.15,66.29 86.81,66.95 106,66.95 107.72,65.24 107.72,65 107.48,64.77 v2(107.46,64.77)
TMDS_B_DATA0#_PCH: length 158.8
  IN1 w0.089: v2(69.01,108.44) 69.26,108.19 71.65,108.19 72.63,107.22 72.63,101.7 74,100.33 77.33,100.33 78.93,98.73 78.93,96.8 80.72,95 86.28,95 86.85,95.56 87.23,95.56
  IN1 w0.127: 87.23,95.56 87.23,95.56 90.2,95.56 92.14,97.51 97.81,97.51 98.39,96.93 v2(98.39,95.79)
  IN2 w0.127: v2(107.21,62.53) 107.12,62.62 107.12,64.22 106.81,64.52 106.81,87.02 98.39,95.44 v2(98.39,95.79)
  BOTTOM w0.089: v2(69.01,108.44) 69.51,107.94 JCPU1.U29
  BOTTOM w0.102: C44.2 31.02,61.34 31.15,61.34 34.2,64.39 90.52,64.39 91.2,65.07 103.18,65.07 105.04,63.22 106.89,63.22 107.11,63 107.11,62.63 v2(107.21,62.53)
TMDS_B_DATA0_PCH: length 158.9
  IN1 w0.089: 87.23,95.31 86.9,95.31 86.37,94.78 80.63,94.78 78.71,96.71 78.71,98.64 77.24,100.11 73.91,100.11 72.41,101.61 72.41,107.13 71.56,107.98 69.1,107.98 68.96,107.83 68.96,107.47 v2(69.01,107.43)
  IN1 w0.127: v2(97.81,95.79) 97.81,95.8 98.14,96.13 98.14,96.82 97.71,97.25 92.25,97.25 90.3,95.31 87.23,95.31
  IN2 w0.127: v2(97.81,95.79) 97.81,95.77 98.14,95.44 98.14,95.34 106.56,86.92 106.56,64.41 106.86,64.11 106.86,62.77 v2(106.62,62.53)
  BOTTOM w0.089: JCPU1.V29 68.51,107.92 v2(69.01,107.43)
  BOTTOM w0.102: C45.2 30.7,60.79 31.03,61.12 31.24,61.12 34.29,64.17 90.61,64.17 91.29,64.86 103.09,64.86 104.95,63 106.8,63 106.89,62.91 106.89,62.8 v2(106.62,62.53)
TMDS_B_DATA1#_PCH: length 161.8
  IN1 w0.089: v2(71.01,109.51) 71.01,109.42 70.89,109.29 70.71,109.29 70.58,109.42 70.58,109.78 70.86,110.06 71.74,110.06 71.93,109.86 73.22,109.86 76.26,106.83 76.87,106.83 77.36,106.33 77.36,101.56 80.17,98.75 80.17,97.35 80.75,96.77 85.19,96.77 86.56,98.14 87.11,98.14 87.13,98.12 87.2,98.12 87.22,98.11 87.23,98.11
  IN1 w0.127: v2(100.31,95.85) 100.31,95.88 100.64,96.21 100.64,96.98 98.75,98.87 91.68,98.87 90.91,98.11 87.23,98.11
  IN2 w0.127: v2(108.41,64.18) 108.66,64.42 108.66,65.81 108.2,66.27 108.2,80.9 108.53,81.23 108.53,87.11 100.56,95.08 100.56,95.59 v2(100.31,95.85)
  BOTTOM w0.089: v2(71.01,109.51) 70.51,109.01 JCPU1.T30
  BOTTOM w0.102: v2(108.41,64.18) 108.63,63.97 108.63,63.78 108.53,63.68 107.53,63.68 104.73,66.47 90.62,66.47 89.94,65.79 30.57,65.79 29.81,65.03 29.15,65.03 29.03,65.16 C42.2
TMDS_B_DATA1_PCH: length 161.9
  IN1 w0.089: 87.23,98.36 86.48,98.36 85.1,96.99 80.84,96.99 80.39,97.44 80.39,98.84 77.58,101.65 77.58,106.42 76.96,107.05 76.35,107.05 73.31,110.08 72.02,110.08 71.83,110.27 70.77,110.27 70.37,109.87 70.37,109.66 70.23,109.52 v2(70.02,109.52)
  IN1 w0.127: 87.23,98.36 90.81,98.36 91.57,99.12 98.86,99.12 100.89,97.09 v2(100.89,95.87)
  IN2 w0.127: v2(100.89,95.87) 100.81,95.79 100.81,95.18 108.78,87.21 108.78,81.12 108.45,80.79 108.45,66.37 108.91,65.91 108.91,64.27 v2(109,64.18)
  BOTTOM w0.089: JCPU1.U30 69.51,109.01 v2(70.02,109.52)
  BOTTOM w0.102: C43.2 29.27,64.82 29.9,64.82 30.66,65.57 90.03,65.57 90.71,66.25 104.64,66.25 107.44,63.46 108.62,63.46 108.85,63.69 108.85,64.03 v2(109,64.18)
TMDS_B_DATA2#_PCH: length 152.2
  IN1 w0.089: 87.23,94.62 86.86,94.62 86.25,94.02 80.78,94.02 78.01,96.78 78.01,97.43 75.71,99.73 73.63,99.73 71.65,101.71 71.65,106.64 71.24,107.05 70.82,107.05 70.62,107.25 70.13,107.25 v2(69.96,107.43)
  IN1 w0.127: 87.23,94.62 90.38,94.62 92.51,96.75 96.62,96.75 96.95,96.42 96.95,96.13 v2(97.09,95.98)
  IN2 w0.127: v2(106.22,63.7) 106.05,63.86 106.05,86.71 97.01,95.75 97.01,95.89 v2(97.09,95.98)
  BOTTOM w0.089: JCPU1.T28 70.44,106.94 v2(69.96,107.43)
  BOTTOM w0.102: C48.2 31.04,63.24 31.96,63.24 33.81,65.09 90.23,65.09 90.91,65.77 104.44,65.77 106.04,64.17 106.04,63.88 v2(106.22,63.7)
TMDS_B_DATA2_PCH: length 152.2
  IN1 w0.089: 87.23,94.37 87.22,94.37 87.2,94.39 87.13,94.39 87.11,94.41 86.95,94.41 86.34,93.8 80.69,93.8 77.79,96.7 77.79,97.34 75.62,99.51 73.54,99.51 71.43,101.62 71.43,106.55 71.15,106.83 70.73,106.83 70.53,107.04 69.82,107.04 69.7,106.92 69.7,106.64 69.83,106.51 v2(69.96,106.51)
  IN1 w0.127: v2(96.51,95.98) 96.69,96.17 96.69,96.31 96.51,96.49 92.61,96.49 90.49,94.37 87.23,94.37
  IN2 w0.127: v2(96.51,95.98) 96.63,95.86 96.75,95.74 96.75,95.65 105.8,86.6 105.8,63.86 v2(105.63,63.7)
  BOTTOM w0.089: v2(69.96,106.51) 69.53,106.94 JCPU1.U28
  BOTTOM w0.102: C41.2 31.04,63.03 32.05,63.03 33.9,64.87 90.32,64.87 91,65.55 104.35,65.55 105.82,64.08 105.82,63.89 v2(105.63,63.7)
TMDS_B_HPD: length 127.1
  TOP w0.089: v2(133.13,73.19) 133.13,73.48 131.68,74.93 131.68,75.55 131.96,75.83 131.96,76.13 131.19,76.9 U4.K40
  TOP w0.102: Q93.3 26.16,62.86 R485.1 27.58,61.44 v2(27.58,59.57)
  IN2 w0.127: v2(132.37,68.54) 131.9,69.01 131.9,70.89 133.13,72.12 v2(133.13,73.19)
  BOTTOM w0.102: v2(27.58,59.57) 30.44,59.57 33.62,62.75 v1(35.17,62.75) 94.23,62.75 95.66,64.17 99.23,64.17 101.36,62.05 107.41,62.05 108.32,62.96 127.9,62.96 132.37,67.43 v2(132.37,68.54)
TP_1: length 118.4
  TOP w0.102: v2(182.6,87.06) 182.69,86.96 R619.1 183.53,86.38 192.5,95.34 JTP1.1 ; SW7.1 SW7.2 181.34,6.65 184.66,9.97 v3(184.66,14.08) v2(184.66,18.06)
  BOTTOM w0.102: v2(182.6,87.06) 182.6,86.31 181.55,85.27 181.55,75.06 179.74,73.24 179.74,69.14 178.64,68.04 178.64,58.79 179.38,58.05 179.38,48.16 184.04,43.5 184.04,42.77 184.04,35.85 185.31,34.58 185.31,18.71 v2(184.66,18.06)
TP_2: length 164.8
  TOP w0.102: SW6.1 SW6.2 118.55,7.79 124.7,13.94 166.78,13.94 168.28,15.45 170.75,15.45 SW5.1 SW5.2 177.21,15.45 178.61,16.85 v2(184.21,16.85) ; JTP1.2 191.5,95.41 184.24,88.16 v3(182.99,88.16) 181.69,88.16 180.7,87.17 v2(180.7,86.8)
  BOTTOM w0.102: v2(180.7,86.8) 181.33,86.18 181.33,75.16 179.51,73.34 179.51,69.23 178.41,68.13 178.41,58.7 179.15,57.95 179.15,48.07 183.81,43.41 183.81,42.87 183.81,35.75 185.08,34.48 185.08,19.08 184.21,18.2 v2(184.21,16.85)
TP_3: length 144
  TOP w0.102: JTP1.3 190.5,95.31 185.13,89.95 v3(183.01,89.95) R627.1 181.28,89.48 181.28,88.07 180.3,87.09 v2(180.3,86.13) ; SW4.1 SW4.2 135.51,16.85 167.45,16.85 169.85,19.25 v2(184.67,19.25)
  BOTTOM w0.102: v2(184.67,19.25) 184.86,19.43 184.86,34.39 183.59,35.66 183.59,43.31 178.92,47.97 178.92,57.86 178.18,58.6 178.18,68.22 179.28,69.33 179.28,73.43 181.1,75.25 181.1,85.33 v2(180.3,86.13)
TP_CLK: length 57.5
  TOP w0.102: JTP1.5 188.5,95.37 v2(188.75,95.12) ; U31.87 159.38,80.16 v2(159.17,80.36) 159.1,80.44 R603.1
  IN1 w0.127: v2(186.08,81.75) 186.57,81.25 186.82,81.25 190.51,84.93 190.51,89.83 188.75,91.59 v2(188.75,95.12)
  IN2 w0.127: v2(186.08,81.75) 185.36,81.04 185.07,81.04 184.54,80.5 184.54,79.44 184.28,79.17 182.93,79.17 181.06,81.04 179.69,81.04 179.53,81.19 176.5,81.19 175.22,79.91 171,79.91 170.54,80.36 v2(159.17,80.36)
  BOTTOM w0.102: v2(188.75,95.12) 188.93,94.94 188.93,93.95 189.26,93.61 190.77,93.61 192.25,92.13 192.25,91.81 192.08,91.64 D15.3
TP_DATA: length 59.9
  TOP w0.102: v1(156.69,78.62) 157.12,79.05 157.82,79.05 158.24,79.47 R598.1 158.44,79.76 U31.88 162.97,79.76 164.58,78.15 v2(164.58,77.87) ; JTP1.4 189.5,95.28 v2(189.33,95.12)
  IN1 w0.127: v2(189.33,95.12) 189.33,91.59 190.79,90.13 190.79,83.73 189.91,82.85 v2(189.91,80.45)
  IN2 w0.127: v2(164.58,77.87) 164.83,78.13 167.9,78.13 168.26,78.48 169.62,78.48 170.32,77.78 172.28,77.78 172.72,78.23 176.83,78.23 177.24,77.82 179.04,77.82 179.63,78.41 184.83,78.41 186.88,80.45 v2(189.91,80.45)
  BOTTOM w0.102: v2(189.33,95.12) 189.15,94.94 189.15,94.04 189.36,93.84 190.86,93.84 192.47,92.23 192.47,91.78 192.62,91.64 D15.2
TS_RST#: length 4.4
  TOP w0.102: JTS1.1 205.06,146.31 204.11,147.26 v1(203.49,147.26) R722.2
TSENSE: length 5.5
  TOP w0.102: v2(25.85,125.35) v1(25.85,125.98)
  TOP w0.254: v2(25.85,125.35) 25.17,124.67 PC912.2
  BOTTOM w0.203: v2(25.85,125.35) 25.53,125.35 24.69,124.5 PU901.8
  BOTTOM w0.254: v2(25.85,125.35) 25.85,125.84 25.73,125.96 PR942.1
TURBO_V: length 53.1
  TOP w0.102: v2(161.97,71.17) v1(161.54,71.6) 161.54,72.82 161.71,72.98 164.11,72.98 164.39,73.26 U31.102
  TOP w0.254: PR232.2 191.96,81.11 191.29,80.45 v2(191.17,80.45) 190.72,80.45 190.06,81.11 PR229.2 PR225.2 PR230.2 PR227.1 PR233.2
  IN2 w0.127: v2(161.97,71.17) 162.99,70.15 174.73,70.15 176.6,72.02 186.54,72.02 188.34,73.81 190.53,73.81 191.17,74.44 v2(191.17,80.45)
U2DN1: length 16
  IN2 w0.127: v2(17.21,40.95) 17.34,41.08 17.66,41.08 17.93,41.36 17.93,42.02 17,42.95 17,47.14 15.83,48.32 14.99,48.32 14.8,48.51 JUSB2.2
  BOTTOM w0.102: v2(17.21,40.95) 17.34,40.82 17.34,40.1 17.48,39.95 D22.3 17.49,39.95 17.66,40.13 17.66,40.87 17.92,41.12 20.05,41.12 20.35,40.83 L51.2
U2DN2: length 15.6
  IN2 w0.127: v2(19.57,20.17) 19.76,20.37 20.02,20.37 20.39,20.73 20.39,21.55 19.89,22.05 18.73,22.05 17.96,22.82 17.96,25.36 15.91,27.41 15.02,27.41 14.8,27.63 JUSB1.2
  BOTTOM w0.102: L55.2 21.13,20.02 20.84,20.31 20.17,20.31 20.01,20.15 20.01,19.41 19.82,19.22 D31.4 19.66,19.38 19.66,20.09 v2(19.57,20.17)
U2DP1: length 15.9
  IN2 w0.127: JUSB2.3 14.42,47.44 14.42,47.87 14.61,48.06 15.73,48.06 16.75,47.04 16.75,42.84 17.68,41.91 17.68,41.46 17.55,41.34 17.38,41.34 v2(17.18,41.53)
  BOTTOM w0.102: L51.3 20.35,41.63 20.06,41.34 17.82,41.34 17.66,41.5 17.66,42.28 17.49,42.45 D22.4 17.34,42.3 17.34,41.68 v2(17.18,41.53)
U2DP2: length 15.5
  IN2 w0.127: JUSB1.3 14.55,26.31 14.55,26.93 14.78,27.16 15.8,27.16 17.71,25.25 17.71,22.72 18.63,21.8 19.78,21.8 20.13,21.44 20.13,20.84 19.92,20.62 19.73,20.62 v2(19.56,20.78)
  BOTTOM w0.102: v2(19.56,20.78) 19.64,20.86 19.64,21.54 D31.3 19.82,21.72 19.99,21.54 19.99,20.79 20.25,20.53 20.86,20.53 21.15,20.82 L55.3
U3RXDN1: length 8.3
  BOTTOM w0.102: L50.2 19.7,44.41 19.38,44.73 19.09,44.73 18.93,44.89 18.74,44.89 18.6,44.75 D27.9 D27.1 16.8,44.75 16.64,44.91 v4(16.21,44.91) 15.86,44.91 15.21,45.55 14.37,45.55 13.81,44.99 13.51,44.99 13.3,44.78 JUSB2.5
U3RXDN2: length 9.1
  BOTTOM w0.102: L54.2 20.53,23.34 20.25,23.63 19.77,23.63 19.66,23.74 19.26,23.74 19.12,23.6 D30.9 D30.1 17.26,23.6 17.12,23.74 16.95,23.74 16.94,23.72 16.33,23.72 16.31,23.74 16.14,23.74 15.34,24.54 14.37,24.54 13.74,23.91 13.42,23.91 13.3,23.79 JUSB1.5
U3RXDP1: length 8.2
  BOTTOM w0.102: L50.3 19.7,45.21 19.43,44.95 19.18,44.95 19.02,45.1 18.74,45.1 18.6,45.25 D27.8 D27.2 16.84,45.25 16.74,45.15 15.93,45.15 15.3,45.77 14.28,45.77 13.72,45.2 13.44,45.2 13.3,45.34 JUSB2.6
U3RXDP2: length 9.2
  BOTTOM w0.102: L54.3 20.56,24.14 20.26,23.84 19.86,23.84 19.75,23.96 19.26,23.96 19.12,24.1 D30.8 D30.2 17.27,24.1 17.12,23.95 v4(16.59,23.95) 16.23,23.95 15.43,24.76 14.28,24.76 13.65,24.13 13.47,24.13 13.3,24.3 JUSB1.6
U3TXDN1: length 11.2
  BOTTOM w0.102: L49.2 19.6,46.3 19.3,46.59 19.12,46.59 18.92,46.39 18.65,46.39 18.51,46.25 D27.7 D27.4 16.89,46.25 16.75,46.39 16.55,46.39 16.24,46.69 v4(16.24,47.67) 16.24,49.35 15.95,49.65 15.95,49.67 15.27,50.35 14.39,50.35 13.78,50.95 13.46,50.95 13.3,50.79 JUSB2.8
U3TXDN1_L: length 1.8
  BOTTOM w0.102: L49.1 22.16,46.3 22.45,46.59 22.76,46.59 C849.2
U3TXDN2: length 12.2
  BOTTOM w0.102: JUSB1.8 13.3,29.85 13.39,29.94 13.78,29.94 14.49,29.23 15.69,29.23 16.16,28.76 16.41,28.51 16.41,28.38 16.38,28.36 16.38,27.8 16.41,27.77 v4(16.41,26.51) 16.41,25.77 16.93,25.24 17.12,25.24 17.27,25.1 D30.4 D30.7 19.12,25.1 19.24,25.21 19.61,25.21 19.61,25.22 19.77,25.37 20.24,25.37 20.53,25.08 L53.2
U3TXDN2_L: length 1.7
  BOTTOM w0.102: L53.1 22.76,25.08 23.05,25.38 23.61,25.38 C850.2
U3TXDP1: length 11.2
  BOTTOM w0.102: L49.3 19.65,47.1 19.36,46.81 19.03,46.81 18.83,46.6 18.65,46.6 18.5,46.75 D27.6 D27.5 16.9,46.75 16.76,46.6 16.64,46.6 16.46,46.78 16.46,47.28 16.48,47.3 16.48,48.02 16.46,48.04 16.46,49.46 v4(16.31,49.61) 15.36,50.56 14.48,50.56 13.87,51.17 13.45,51.17 13.3,51.32 JUSB2.9
U3TXDP1_L: length 1.7
  BOTTOM w0.102: L49.4 22.13,47.1 22.42,46.8 22.81,46.8 C847.2
U3TXDP2: length 12.2
  BOTTOM w0.102: L53.3 20.53,25.88 20.24,25.59 19.68,25.59 19.51,25.43 19.29,25.43 19.12,25.6 D30.6 D30.5 17.27,25.6 17.12,25.46 17.02,25.46 16.62,25.86 16.62,26.16 16.64,26.18 16.64,26.78 16.62,26.8 v4(16.62,28.1) 16.62,28.6 15.78,29.44 14.58,29.44 13.87,30.15 13.38,30.15 13.3,30.23 JUSB1.9
U3TXDP2_L: length 1.7
  BOTTOM w0.102: C848.2 23.59,25.59 23.04,25.59 22.74,25.88 L53.4
UG_1.35V: length 11.1
  IN2 w1.016: 46.41,6.61 45.79,6 41.59,6 39.6,7.99 36.41,7.99
  vias: v1(47.7,7.16) v4(35.21,7.18) v4(35.85,7.2) v4(46.57,8.3) v4(46.57,7.6)
UGATE1_VGA: length 10.8
  IN2 w0.508: v2(181.36,146.94) 181.36,145.6 182.93,144.04 182.93,142.99 v4(184.22,141.69)
  BOTTOM w0.508: v2(181.36,146.94) v1(180.93,146.5) 180.61,146.19 178.83,146.19 178.66,146.35 PQ802.2
UGATE2_VGA: length 7.1
  BOTTOM w0.508: PQ801.2 179.22,138.22 v1(180.07,137.38) 181.29,136.15 183.21,136.15 v4(183.44,136.38)
USB3_RX1_N: length 132.8
  TOP w0.102: v2(120.74,83.08) 121,83.35 U4.AR26
  IN2 w0.089: v2(120.74,83.08) 120.87,83.08 121.01,83.21 121.01,83.41 120.89,83.53 118.31,83.53 117.72,82.93 115.56,82.93 115.54,82.92 115.53,82.92
  IN2 w0.127: 115.53,82.92 114.69,82.92 110.27,78.49 110.27,67.07 111.08,66.26 111.08,63.75 110.19,62.85 110.19,62.56 v2(110.43,62.32)
  BOTTOM w0.102: L50.1 21.86,44.41 22.25,44.79 24.13,44.79 26.99,47.66 26.99,53.79 34.3,61.1 94.91,61.1 96.34,62.52 98.55,62.52 100.67,60.4 108.99,60.4 110.1,61.51 110.1,61.99 v2(110.43,62.32)
USB3_RX1_P: length 132.8
  TOP w0.102: v2(121.34,83.08) 121.6,83.34 U4.AP26
  IN2 w0.089: v2(121.34,83.08) 121.22,83.19 121.22,83.49 120.98,83.74 118.22,83.74 117.63,83.15 115.63,83.15 115.56,83.15 115.54,83.17 115.53,83.17
  IN2 w0.127: 115.53,83.17 114.58,83.17 110.01,78.6 110.01,66.96 110.83,66.15 110.83,63.86 109.93,62.96 109.93,62.41 v2(109.84,62.32)
  BOTTOM w0.102: v2(109.84,62.32) 109.88,62.28 109.88,61.6 108.9,60.61 100.76,60.61 98.64,62.74 96.25,62.74 94.83,61.31 34.21,61.31 26.78,53.88 26.78,47.75 24.04,45.01 22.07,45.01 21.86,45.21 L50.4
USB3_RX2_N: length 162.7
  TOP w0.102: v2(118.89,83.09) 119.21,83.41 U4.AW26
  IN2 w0.089: v2(118.89,83.09) 119.01,82.98 119.01,82.66 118.59,82.24 117.36,82.24 115.69,80.57 115.68,80.57 115.64,80.53 115.61,80.53 115.6,80.52 115.3,80.21
  IN2 w0.127: 115.3,80.21 114.66,79.58 114.66,72.49 115.87,71.28 115.87,66.81 121.13,61.55 121.13,31.39 113.96,24.22 46.28,24.22 45.54,23.48 44.39,23.48 44.27,23.6 43.34,23.6 v2(43.17,23.77)
  BOTTOM w0.102: L54.1 22.74,23.34 22.91,23.51 v4(24.56,23.51) 25.45,23.51 26.07,24.13 33.89,24.13 34.92,23.1 40.94,23.1 41.47,22.57 43.59,22.57 43.86,22.83 43.86,23.35 43.58,23.63 43.31,23.63 v2(43.17,23.77)
USB3_RX2_P: length 162.7
  TOP w0.102: v2(119.53,83.08) 119.81,83.35 U4.AV26
  IN2 w0.089: 115.78,80.34 115.8,80.35 115.8,80.38 115.8,80.38 117.45,82.03 118.68,82.03 119.22,82.57 119.22,82.94 119.36,83.08 v2(119.53,83.08)
  IN2 w0.127: 115.78,80.34 114.92,79.47 114.92,72.59 116.12,71.39 116.12,66.91 121.38,61.66 121.38,31.28 114.06,23.96 46.38,23.96 45.64,23.22 44.29,23.22 44.16,23.35 43.34,23.35 v2(43.17,23.19)
  BOTTOM w0.102: v2(43.17,23.19) 43.4,23.42 43.49,23.42 43.64,23.26 43.64,22.92 43.5,22.78 41.56,22.78 41.03,23.31 35.01,23.31 33.98,24.34 25.98,24.34 25.36,23.72 24.9,23.72 24.87,23.75 24.17,23.75 24.15,23.72 23.16,23.72 22.74,24.14 L54.4
USB3_TX1_N: length 128.4
  TOP w0.089: U4.BE24 114.35,84.41 113.96,84.8
  TOP w0.102: 113.96,84.8 110.57,84.8 v2(110.38,84.6)
  IN2 w0.127: v2(109.16,62.32) 109,62.48 109,62.92 110.04,63.97 110.04,66.04 109.38,66.7 109.38,80.38 109.67,80.68 109.67,84.53 109.9,84.76 110.22,84.76 v2(110.38,84.6)
  BOTTOM w0.102: v2(109.16,62.32) 108.97,62.14 108.97,61.8 108.4,61.22 101.01,61.22 98.89,63.35 96,63.35 94.57,61.92 33.96,61.92 26.17,54.13 26.17,48 24.82,46.66 23.87,46.66 23.81,46.59 23.81,46.45 C849.1
USB3_TX1_P: length 128.4
  TOP w0.089: U4.BD23 117.05,84.71 116.53,84.71 116.44,84.61 114.45,84.61 114.05,85.01 113.96,85.01
  TOP w0.102: 113.96,85.01 110.55,85.01 v2(110.38,85.19)
  IN2 w0.127: v2(108.57,62.32) 108.74,62.5 108.74,63.03 109.79,64.07 109.79,65.94 109.13,66.6 109.13,80.49 109.42,80.78 109.42,84.64 109.79,85.01 110.21,85.01 v2(110.38,85.19)
  BOTTOM w0.102: C847.1 24.27,46.87 24.73,46.87 25.95,48.09 25.95,54.22 33.87,62.14 94.48,62.14 95.91,63.56 98.98,63.56 101.1,61.44 108.31,61.44 108.76,61.89 108.76,62.14 v2(108.57,62.32)
USB3_TX2_N: length 157.6
  TOP w0.089: U4.BD25 117.02,83.91 115.55,83.91 115.25,83.6 115.25,82.55 v2(115.53,82.27)
  IN2 w0.127: v2(44.25,24.24) 44.48,24.47 45.45,24.47 45.87,24.89 113.73,24.89 120.47,31.62 120.47,61.31 114.57,67.21 114.57,70.99 114.03,71.54 114.03,79.88 115.36,81.21 115.36,82.1 v2(115.53,82.27)
  BOTTOM w0.102: v2(44.25,24.24) 44.01,24.48 43.01,24.48 42.58,24.91 42.08,24.91 41.31,24.14 35.04,24.14 34.22,24.97 26.37,24.97 25.85,25.49 24.96,25.49 24.85,25.37 C850.1
USB3_TX2_P: length 157.6
  TOP w0.089: v2(114.94,82.27) 115.04,82.37 115.04,83.69 115.47,84.11 116.81,84.11 117.11,84.41 U4.BC24
  IN2 w0.127: v2(44.25,24.83) 44.36,24.72 45.34,24.72 45.76,25.14 113.63,25.14 120.21,31.73 120.21,61.21 114.32,67.1 114.32,70.88 113.77,71.43 113.77,79.99 115.11,81.32 115.11,82.1 v2(114.94,82.27)
  BOTTOM w0.102: v2(44.25,24.83) 44.13,24.7 43.1,24.7 42.67,25.13 41.99,25.13 41.22,24.36 35.13,24.36 34.31,25.18 26.46,25.18 25.94,25.7 25.11,25.7 C848.1
USB20_N0: length 146.3
  TOP w0.089: U4.B37 135,79.25 135.5,79.25 136.24,78.5 136.24,78.29 136.83,77.71 137.17,77.71 v2(137.36,77.9)
  IN2 w0.127: v2(137.36,77.9) 137.6,77.65 138.11,77.65 138.89,76.87 138.89,71.76 127.77,60.63 v2(127.77,60.42)
  BOTTOM w0.102: L51.1 23.16,40.83 23.54,41.21 23.91,41.21 24.3,41.6 24.3,43.8 27.82,47.32 27.82,53.44 34.65,60.27 95.26,60.27 96.68,61.7 98.21,61.7 100.33,59.57 126.56,59.57 127.4,60.42 v2(127.77,60.42)
USB20_N1: length 164.6
  TOP w0.089: U4.A38 135.31,78.6 135.82,78.09 135.82,77.34 136.75,76.41 137.13,76.41 v2(137.38,76.67)
  IN2 w0.127: v2(137.38,76.67) 137.6,76.45 137.89,76.45 138.12,76.22 138.12,73.64 137.46,72.98 137.46,72.19 124.01,58.74 124.01,30.19 115.05,21.23 47.62,21.23 46.98,20.6 42.2,20.6 40.81,19.2 40.81,18.27 39.99,17.45 28.34,17.45 25.53,20.25 24.24,20.25 v2(24.1,20.12)
  BOTTOM w0.102: v2(24.1,20.12) 23.92,20.3 23.69,20.3 23.41,20.02 L55.1
USB20_N2: length 138.2
  TOP w0.089: U4.A36 135.39,79.62 135.51,79.62 136.28,78.84 136.51,78.84 v2(136.81,78.54)
  TOP w0.102: JTS1.4 205.43,143.91 205.33,144.01 205.33,144.31 205.23,144.42 204.91,144.42 204.68,144.65 204.68,144.71 v2(204.31,145.08)
  IN2 w0.127: v2(190.02,74.82) 190.02,74.85 190.35,75.18 190.35,75.41 190.23,75.54 167.38,75.54 167.11,75.8 163.49,75.8 162.46,76.83 160.6,76.83 159.31,75.54 157.7,75.54 156.74,76.5 148.46,76.5 147.84,77.12 143.96,77.12 141.65,79.44 139.82,79.44 139.12,78.74 137.58,78.74 137.55,78.71 136.97,78.71 v2(136.81,78.54)
  BOTTOM w0.102: v2(204.31,145.08) 204.68,144.71 204.68,143.94 204.45,143.71 204.45,139.23 201.8,136.57 201.8,110.6 200.58,109.38 200.58,99.39 195.42,94.23 195.42,89.48 190.33,84.39 190.33,75.13 v2(190.02,74.82)
USB20_N3: length 138.8
  TOP w0.089: v2(137.3,80.05) 137,79.75 136.43,79.75 135.92,80.26 135.73,80.26 135.64,80.35 135.64,80.53 135.53,80.64 135.38,80.64 135.31,80.57 U4.A34
  IN2 w0.127: v2(96.78,123.79) 97.01,124.03 97.01,124.33 97.37,124.69 103.49,124.69 104.11,124.06 105.5,124.06 109.41,120.16 129.9,120.16 132.79,117.27 142.02,117.27 142.4,116.89 150.07,116.89 151.85,118.67 152.85,118.67 153.03,118.85 153.03,119.12 v2(152.79,119.36) ; v2(137.3,80.05) 137.31,80.05 137.6,79.76 138.68,79.76 139.72,80.79 141.77,80.79 144.42,78.14 147.26,78.14 147.59,78.47 v2(147.6,78.47)
  BOTTOM w0.102: R684.2 95.4,139.62 L58.1 95.81,139.31 96,139.36 96.15,139.56 96.38,139.56 96.42,139.51 96.43,139.49 96.71,139.31 96.82,139.25 97.07,139 97.07,124.09 v2(96.78,123.79) ; v2(152.79,119.36) 153.07,119.08 153.07,116.16 151.99,115.08 151.99,109.43 150.45,107.89 150.45,102.21 148.41,100.17 148.41,94.89 147.67,94.16 147.67,80.32 148.42,79.58 148.42,78.32 148.2,78.1 147.97,78.1 v2(147.6,78.47)
USB20_N3_R: length 3.2
  TOP w0.102: v2(93.19,140.97) 93.19,141.12 92.84,141.47 92.47,141.47 JLVDS1.28
  BOTTOM w0.102: R684.1 94.18,140.3 L58.2 93.8,140.61 93.8,140.78 93.61,140.97 v2(93.19,140.97)
USB20_N9: length 134
  TOP w0.089: v2(136.91,81.24) 136.91,81.17 136.61,80.86 136.31,80.86 135.31,81.85 U4.A30
  TOP w0.102: v2(199.48,149.34) 199.57,149.25 199.66,149.25 199.83,149.41 199.83,149.51 200.01,149.7 200.01,150.95 199.92,151.04 199.64,151.04 199.55,151.13 L66.4 199.55,152.02 R868.2
  IN2 w0.127: v2(184.99,83.5) 184.82,83.67 176.63,83.67 175.12,82.15 149.33,82.15 148.77,81.59 146.6,81.59 146.03,82.15 141.65,82.15 141.4,82.41 139.24,82.41 139.06,82.23 138.12,82.23 137.42,82.93 136.66,82.93 136.28,82.55 136.28,81.18 136.46,81 136.67,81 v2(136.91,81.24)
  BOTTOM w0.102: v2(199.48,149.34) 199.55,149.41 199.67,149.41 199.82,149.26 199.82,148.63 199.54,148.35 197.97,148.35 195.63,146.01 195.63,143.31 195.16,142.83 195.16,137.59 194.04,136.48 194.04,134.51 187.78,128.24 187.78,122.38 189.16,121 189.16,117.59 188.36,116.79 188.36,109.78 186.51,107.92 186.51,100.49 185.12,99.11 185.12,87.93 183.98,86.79 183.98,84.23 184.37,83.85 184.64,83.85 v2(184.99,83.5)
USB20_N9_C: length 18.1
  TOP w0.102: R868.1 199.55,153.02 L66.3 199.55,153.58 199.85,153.88 199.85,156.04 199,156.89 199,157.35 198.88,157.47 D25.3 198.13,158.19 198.42,158.48 198.7,158.48 198.81,158.59 198.81,159 199.21,159.39 v4(199.73,159.39) 201.62,159.39 201.65,159.42 202.43,159.42 202.46,159.39 204.22,159.39 204.86,158.76 204.86,156.54 204.62,156.3 JUSB3.3
USB20_N10: length 143.6
  TOP w0.089: U4.B29 134.4,82.36 134.08,82.67 134.08,83.12 v2(134.08,83.12)
  IN2 w0.089: 136.76,86.9 136.74,86.9 136.72,86.92 135.55,86.92 134.98,86.36 134.98,84.93 133.84,83.79 133.84,83.36 v2(134.08,83.12)
  IN2 w0.127: v2(184.92,84.89) 184.74,85.07 183.37,85.07 183.09,84.8 175.45,84.8 175.17,85.07 166.73,85.07 165.59,86.22 164.66,86.22 164.38,86.5 163.89,86.5 163.61,86.22 160.17,86.22 159.69,86.7 158.91,86.7 158.71,86.9 136.76,86.9
  BOTTOM w0.102: JWLN1.36 206.27,157.6 206.06,157.82 204.82,157.82 204.45,157.45 204.45,150.31 201.57,147.43 198.42,147.43 196.55,145.56 196.55,142.87 196.25,142.57 196.25,137.39 194.96,136.1 194.96,134.13 188.7,127.86 188.7,122.76 190.08,121.38 190.08,117.04 189.28,116.24 189.28,109.29 187.42,107.44 187.42,100.07 186.14,98.79 v4(186.14,91.17) 186.14,85.73 185.48,85.07 185.1,85.07 v2(184.92,84.89)
USB20_N11: length 120.6
  TOP w0.089: U4.A28 135.31,82.67 135.94,82.04 136.62,82.04 v2(137,82.42)
  IN2 w0.127: v2(137,82.42) 137.05,82.42 137.37,82.1 137.51,82.1 137.92,81.7 139.53,81.7 139.72,81.89 141.12,81.89 141.37,81.65 145.54,81.65 146.15,81.03 148.94,81.03 149.55,81.65 175.33,81.65 176.33,82.65 186.94,82.65 188.31,81.28 191.47,81.28 192.11,80.64 192.11,62.54 190.84,61.27 190.84,42.04 191.46,41.42 191.78,41.42 192.11,41.75 v2(192.13,41.75)
  BOTTOM w0.102: v2(192.13,41.75) 192.43,41.45 197.99,41.45 200.5,38.94 200.5,29.62 200.79,29.33 L67.1 200.79,28.44 R687.2
USB20_N11_R: length 15.4
  TOP w0.102: v2(207.32,23.95) 207.18,24.09 204.88,24.09 204.55,23.75 JCR1.2
  BOTTOM w0.102: R687.1 200.79,27.46 L67.2 200.79,26.64 200.46,26.31 200.46,26.1 200.67,25.89 v4(202.67,25.89) 207.55,25.89 208.32,25.13 208.32,24.36 207.96,24 207.37,24 v2(207.32,23.95)
USB20_P0: length 146.4
  TOP w0.089: U4.D37 134.43,79.13 134.74,78.82 134.98,78.82 135.2,79.04 135.41,79.04 136.04,78.42 136.04,78.21 136.74,77.5 137.17,77.5 v2(137.36,77.31)
  IN2 w0.127: v2(127.36,60.83) 127.59,60.83 127.61,60.83 138.64,71.86 138.64,76.76 138,77.4 137.45,77.4 v2(137.36,77.31)
  BOTTOM w0.102: L51.4 23.21,41.63 23.42,41.43 23.82,41.43 24.09,41.69 24.09,43.89 27.6,47.41 27.6,53.53 34.56,60.49 95.17,60.49 96.59,61.91 98.29,61.91 100.42,59.79 126.47,59.79 127.36,60.67 v2(127.36,60.83)
USB20_P1: length 164.6
  TOP w0.089: U4.C38 134.48,78.64 134.98,78.64 135.62,78 135.62,77.26 136.66,76.21 137.25,76.21 v2(137.38,76.08)
  IN2 w0.127: v2(137.38,76.08) 137.49,76.2 137.79,76.2 137.87,76.12 137.87,73.75 137.21,73.09 137.21,72.3 123.76,58.85 123.76,30.3 114.94,21.49 47.51,21.49 46.88,20.85 42.1,20.85 40.55,19.31 40.55,18.37 39.88,17.7 28.44,17.7 25.64,20.51 24.3,20.51 v2(24.1,20.7)
  BOTTOM w0.102: v2(24.1,20.7) 23.92,20.52 23.67,20.52 23.36,20.82 L55.4
USB20_P2: length 138.3
  TOP w0.089: v2(136.81,79.13) 136.72,79.04 136.37,79.04 135.59,79.82 135.19,79.82 134.9,79.53 U4.C36
  TOP w0.102: v2(204.89,145.08) 204.89,144.74 205,144.64 205.3,144.64 205.38,144.71 JTS1.3
  IN2 w0.127: v2(136.81,79.13) 136.92,79.01 136.97,78.96 137.45,78.96 137.48,78.99 139.02,78.99 139.72,79.69 141.76,79.69 144.07,77.38 147.95,77.38 148.57,76.76 156.84,76.76 157.81,75.79 159.2,75.79 160.5,77.09 162.57,77.09 163.6,76.06 167.22,76.06 167.48,75.79 190.33,75.79 190.61,75.52 v2(190.61,74.82)
  BOTTOM w0.102: v2(204.89,145.08) 204.89,143.85 204.67,143.62 204.67,139.14 202.01,136.48 202.01,110.51 200.79,109.29 200.79,99.3 195.64,94.14 195.64,89.39 190.55,84.3 190.55,74.89 v2(190.61,74.82)
USB20_P3: length 138.8
  TOP w0.089: v2(137.3,79.47) 137.22,79.55 136.35,79.55 135.84,80.06 135.17,80.06 134.89,80.35 U4.C34
  IN2 w0.127: v2(153.37,119.36) 153.28,119.27 153.28,118.74 152.95,118.41 151.95,118.41 150.17,116.63 142.3,116.63 141.92,117.02 132.68,117.02 129.8,119.9 109.3,119.9 105.4,123.81 104,123.81 103.38,124.43 97.47,124.43 97.26,124.22 97.26,123.89 v2(97.36,123.79) ; v2(147.6,77.89) 144.31,77.89 141.66,80.54 139.82,80.54 138.79,79.5 137.34,79.5 v2(137.3,79.47)
  BOTTOM w0.102: v2(147.6,77.89) 147.6,77.89 148.29,77.89 148.64,78.23 148.64,79.67 147.89,80.41 147.89,94.07 148.62,94.8 148.62,100.08 150.67,102.12 150.67,107.81 152.2,109.34 152.2,114.99 153.28,116.07 153.28,119.27 v2(153.37,119.36) ; v2(97.36,123.79) 97.29,123.86 97.29,139.08 96.95,139.42 96.82,139.5 96.61,139.63 96.57,139.8 96.43,139.88 96.42,139.88 L58.4 95.89,140.14 R688.2
USB20_P3_R: length 3.2
  TOP w0.102: v2(93.52,141.48) 93.43,141.39 93.26,141.39 92.95,141.7 92.95,141.84 JLVDS1.27
  BOTTOM w0.102: R688.1 94.7,140.99 L58.3 93.89,140.99 93.52,141.36 v2(93.52,141.48)
USB20_P9: length 133.9
  TOP w0.089: U4.C30 134.9,81.97 136.22,80.65 v2(136.91,80.65)
  TOP w0.102: v2(200.23,149.34) 200.23,151.28 200.35,151.41 L66.1 200.35,152.02 R869.2
  IN2 w0.127: v2(136.91,80.65) 136.83,80.74 136.35,80.74 136.02,81.07 136.02,82.65 136.55,83.18 137.52,83.18 138.22,82.48 138.95,82.48 139.13,82.66 141.5,82.66 141.76,82.41 146.14,82.41 146.7,81.85 148.66,81.85 149.22,82.41 175.01,82.41 176.53,83.92 184.82,83.92 v2(184.99,84.09)
  BOTTOM w0.102: v2(184.99,84.09) 184.97,84.07 184.46,84.07 184.2,84.32 184.2,86.7 185.34,87.84 185.34,99.02 186.72,100.4 186.72,107.83 188.58,109.69 188.58,116.7 189.38,117.5 189.38,121.09 188,122.47 188,128.15 194.26,134.42 194.26,136.39 195.37,137.5 195.37,142.74 195.85,143.22 195.85,145.92 198.06,148.13 199.63,148.13 200.04,148.54 200.04,149.15 v2(200.23,149.34)
USB20_P9_C: length 18
  TOP w0.102: JUSB3.2 203.87,157.3 204.01,157.16 204.01,156.62 204.11,156.51 204.53,156.51 204.64,156.63 204.64,158.67 204.13,159.18 v4(202.01,159.18) 200.01,159.18 199.99,159.17 199.46,159.17 199.45,159.18 199.3,159.18 199.03,158.91 199.03,158.57 199.18,158.42 199.94,158.42 200.06,158.3 D25.2 199.34,157.47 199.22,157.35 199.22,156.98 200.07,156.13 200.07,153.91 200.35,153.63 L66.2 200.35,153.01 R869.1
USB20_P10: length 143.6
  TOP w0.089: v2(133.49,83.08) 133.47,83.05 133.47,82.88 U4.D29
  IN2 w0.089: 136.76,87.15 136.75,87.15 136.73,87.14 135.46,87.14 134.77,86.45 134.77,85.02 133.63,83.88 133.63,83.27 133.63,83.27 133.63,83.21 v2(133.49,83.08)
  IN2 w0.127: v2(184.92,85.47) 184.77,85.33 183.26,85.33 182.99,85.05 175.55,85.05 175.27,85.33 166.84,85.33 165.69,86.47 164.76,86.47 164.49,86.75 163.78,86.75 163.5,86.47 160.28,86.47 159.8,86.95 159.02,86.95 158.81,87.15 136.76,87.15
  BOTTOM w0.102: v2(184.92,85.47) 185.11,85.29 185.39,85.29 185.92,85.82 185.92,90.89 185.91,90.9 185.91,91.44 185.92,91.45 185.92,98.88 187.21,100.16 187.21,107.53 189.06,109.38 189.06,116.33 189.86,117.13 189.86,121.29 188.48,122.67 188.48,127.95 194.74,134.22 194.74,136.19 196.03,137.48 196.03,142.66 196.33,142.96 196.33,145.65 198.33,147.65 201.48,147.65 204.24,150.4 204.24,157.54 204.73,158.03 205.91,158.03 206.28,158.4 JWLN1.38
USB20_P11: length 120.6
  TOP w0.089: U4.C28 134.85,82.78 135.13,82.5 135.19,82.5 135.85,81.84 v2(137,81.84)
  IN2 w0.127: v2(137,81.84) 137.01,81.85 137.4,81.85 137.81,81.44 139.63,81.44 139.83,81.64 141.02,81.64 141.27,81.39 145.43,81.39 146.04,80.78 149.05,80.78 149.66,81.39 175.44,81.39 176.44,82.39 186.84,82.39 188.21,81.02 191.37,81.02 191.85,80.54 191.85,62.64 190.59,61.38 190.59,41.93 191.36,41.16 v2(192.13,41.16)
  BOTTOM w0.102: v2(192.13,41.16) 192.2,41.23 197.9,41.23 200.29,38.85 200.29,29.62 199.99,29.33 L67.4 199.99,28.43 R683.2
USB20_P11_R: length 15.3
  TOP w0.102: JCR1.3 204.45,24.75 204.58,24.63 204.58,24.47 204.75,24.3 207.08,24.3 v2(207.32,24.53)
  BOTTOM w0.102: R683.1 199.99,27.46 L67.3 199.99,26.6 200.25,26.35 200.25,25.99 v4(200.39,25.85) 200.57,25.68 202.4,25.68 202.41,25.66 202.94,25.66 202.95,25.68 207.46,25.68 208.1,25.04 208.1,24.45 207.88,24.22 207.63,24.22 v2(207.32,24.53)
USB_OC0#: length 193.1
  TOP w0.089: 131.05,96.85 130.71,96.85 130.17,96.31 v2(129.64,96.31) 130.03,95.92 130.03,94.6 129.94,94.52 129.94,93.98 129.65,93.69 U4.P3
  TOP w0.102: RP14.1 131.43,97.69 131.55,97.56 131.55,97.36 131.05,96.85 ; v2(106.78,56.11) 106.78,58.32 104.86,60.23 104.86,105.45 v2(104.67,105.64) ; U35.5 21.25,34.15 21.53,34.44 v1(24.59,34.44) 25.24,34.44 v2(27.78,36.98)
  IN1 w0.127: v2(129.64,96.31) 129.24,96.71 129.24,102.71 128.12,103.83 128.12,106.06 126.69,107.5 109.34,107.5 108.2,106.35 105.39,106.35 v2(104.67,105.64) ; v2(106.78,56.11) 106.77,56.11 101.65,50.98 101.65,45.95 98.54,42.85 98.54,40.19 94.15,35.8 28.95,35.8 v2(27.78,36.98)
