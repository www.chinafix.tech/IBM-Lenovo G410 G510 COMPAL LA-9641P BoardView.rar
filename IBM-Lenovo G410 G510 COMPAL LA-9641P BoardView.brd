# Allegro board IBM-Lenovo G410 G510 COMPAL LA-9641P BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_MA4: length 70.2
  IN2 w0.089: 63.49,77.75 63.49,78.35 64.45,79.3 64.45,81.67 64.45,81.67 64.45,81.99 64.62,82.17 64.62,82.67 65.21,83.26 65.21,83.7 65.76,84.25 66.32,84.25 66.58,84 67.24,84 67.46,84.21 67.46,85.07 v2(67.04,85.49)
  IN2 w0.208: 63.49,77.75 63.49,69.33 63.02,68.85 63.02,66.55 62.89,66.42 61.01,66.42 60.88,66.29 60.88,58.31 61.55,57.64 61.55,54.21 62.11,53.65 62.11,40.58 63.18,39.51 63.18,30.63 63.3,30.5 64.15,30.5 64.28,30.63 64.28,31.27 64.49,31.48 64.89,31.48 65.02,31.6 65.02,32.18 64.89,32.31 64.49,32.31 64.28,32.52 64.28,33.16 v2(63.73,33.7)
  BOTTOM w0.089: v2(67.04,85.49) 66.58,85.94 JCPU1.Y7
  BOTTOM w0.165: JDIMM2.92 64.22,34.18 v2(63.73,33.7)
DDR_B_MA5: length 69.1
  IN2 w0.089: v2(66.04,85.41) 66.04,85.4 64.82,85.4 64.41,85 63.89,85 63.62,84.73 63.62,83.16 63.27,82.8 63.27,81.02 62.63,80.39 62.63,78.85 61.62,77.84 61.62,77.14
  IN2 w0.208: 61.62,77.14 61.62,70.06 57.61,66.05 57.61,58.8 59.49,56.92 59.49,53.66 60.26,52.9 60.26,50.26 60.13,50.14 59.99,50.14 59.87,50.01 59.87,49.6 59.99,49.48 60.13,49.48 60.26,49.35 60.26,48.91 60.13,48.79 59.74,48.79 59.62,48.66 59.62,44.66 59.41,44.45 59.26,44.45 59.05,44.24 59.05,43.83 59.26,43.62 59.41,43.62 59.62,43.41 59.62,40.62 59.74,40.49 60.32,40.49 60.45,40.37 60.45,37.21 60.57,37.08 61.82,37.08 61.95,37.21 61.95,39 61.18,39.77 v2(60.91,39.77)
  BOTTOM w0.089: v2(66.04,85.41) 65.58,84.94 JCPU1.AA6
  BOTTOM w0.165: v2(60.91,39.77) 62.96,39.77 63.21,40.01 63.21,40.45 63.33,40.58 63.79,40.58 63.92,40.71 JDIMM2.91
DDR_B_MA6: length 72.7
  IN2 w0.089: 62.87,77.14 62.87,78.41 63.63,79.17 63.63,82.67 63.79,82.83 64.53,82.83 65.03,83.33 65.03,83.78 65.83,84.58 66.86,84.58 v2(67.04,84.4)
  IN2 w0.208: v2(61.26,32.18) 60.93,32.18 60.8,32.05 60.8,29.64 60.93,29.51 62.44,29.51 62.56,29.64 62.56,39.26 61.86,39.96 61.49,40.33 61.49,41 61.5,41.01 61.5,41.57 61.49,41.58 61.49,53.4 60.94,53.95 60.94,57.27 60.27,57.94 60.27,66.97 60.93,67.64 61.23,67.64 61.81,67.05 61.99,67.05 62.4,67.46 62.4,67.64 61.82,68.23 61.82,68.52 62.86,69.57 62.86,72.25 62.87,72.26 62.87,77.14
  BOTTOM w0.089: v2(67.04,84.4) 66.51,84.93 JCPU1.Y6
  BOTTOM w0.165: v2(61.26,32.18) 61.44,32.18 63.27,34.01 63.27,34.82 63.62,35.17 JDIMM2.90
DDR_B_MA7: length 67.4
  IN2 w0.089: v2(66.04,86.41) 65.44,85.81 63.93,85.81 63.44,85.33 63.44,83.23 62.81,82.6 62.81,82.08 62.45,81.72 62.45,79.21 60.99,77.75 60.99,77.14
  IN2 w0.208: 60.99,77.14 60.99,70.31 56.99,66.31 56.99,58.55 58.87,56.67 58.87,53.41 59.64,52.64 59.64,50.65 59,50.01 59,45.3 58.43,44.73 58.43,43.57 59,43 59,40.01 59.13,39.88 59.7,39.88 59.83,39.75 59.83,36.6 59.96,36.47 61.63,36.47 61.76,36.34 61.76,35.75 61.63,35.62 60.89,35.62 60.77,35.49 60.77,35.05 60.89,34.92 61.6,34.92 61.73,34.8 61.73,34.17 v2(61.26,33.7)
  BOTTOM w0.089: v2(66.04,86.41) 65.57,85.94 JCPU1.AA7
  BOTTOM w0.165: v2(61.26,33.7) 62.42,34.86 JDIMM2.86
DDR_B_MA8: length 72.3
  IN2 w0.089: v2(67.04,86.41) 67.04,86.94 66.91,87.07 66.57,87.07 66.44,86.94 66.44,85.23 66.21,85 64.91,85 64.62,84.71 64.62,83.18 64.45,83 63.72,83 63.46,82.74 63.46,79.26 62.25,78.05 62.25,77.14
  IN2 w0.208: 62.25,77.14 62.25,69.82 59.65,67.23 59.65,66.58 59.45,66.37 58.8,66.37 58.67,66.25 58.67,65.67 58.8,65.54 59.53,65.54 59.65,65.41 59.65,64.76 59.53,64.64 58.35,64.64 58.22,64.51 58.22,63.93 58.35,63.8 59.53,63.8 59.65,63.68 59.65,63.1 59.53,62.97 58.35,62.97 58.22,62.84 58.22,62.26 58.35,62.14 59.53,62.14 59.65,62.01 59.65,61.43 59.53,61.3 58.35,61.3 58.22,61.18 58.22,60.6 58.35,60.47 59.53,60.47 59.65,60.34 59.65,59.76 59.53,59.64 58.48,59.64 58.35,59.51 58.35,58.93 58.48,58.8 59.45,58.8 59.65,58.6 59.65,57.66 60.32,56.99 60.32,53.7 60.87,53.15 60.87,48.66 60.23,48.02 60.23,41.31 60.45,41.09 60.71,41.09 v2(60.91,41.29)
  BOTTOM w0.089: JCPU1.Y8 66.51,86.94 v2(67.04,86.41)
  BOTTOM w0.165: v2(60.91,41.29) 60.91,41.31 61.03,41.43 61.73,41.43 61.85,41.31 61.85,40.42 61.98,40.29 62.58,40.29 62.71,40.42 62.71,41.06 62.92,41.27 63.12,41.27 63.32,41.47 JDIMM2.89
DDR_B_MA9: length 67.9
  IN2 w0.089: 59.1,77.14 59.1,77.28 60.64,78.81 60.64,86.59 61.09,87.04 65.12,87.04 66.04,87.95 v2(66.04,88.41)
  IN2 w0.208: 59.1,77.14 59.1,73.51 55.15,69.56 55.15,57.78 56.56,56.37 56.56,50.75 55.92,50.11 55.92,46.97 56.56,46.34 56.56,38.61 56.69,38.49 57.18,38.49 57.3,38.61 57.3,39.57 57.51,39.77 v2(57.84,39.77)
  BOTTOM w0.089: JCPU1.AA10 65.51,88.94 v2(66.04,88.41)
  BOTTOM w0.165: JDIMM2.85 62.11,43.36 61.41,42.66 60.78,42.66 57.88,39.77 v2(57.84,39.77)
DDR_B_MA10: length 75.5
  IN2 w0.089: v2(72.04,87.41) 72.04,87.94 72.17,88.07 72.43,88.07 72.56,87.94 72.56,86.19 72.26,85.89 69.82,85.89 69.45,85.52 69.45,84.24 68.22,83 67.77,83 67.63,82.86 67.63,78.85 68.46,78.03
  IN2 w0.208: v2(69.62,40.53) 69.29,40.53 69.17,40.4 69.17,39.09 69.04,38.97 68.64,38.97 68.51,39.09 68.51,45.26 68.64,45.39 68.93,45.39 69.06,45.51 69.06,46.48 69.19,46.6 69.65,46.6 69.78,46.73 69.78,48.17 69.5,48.45 68.21,48.45 68.08,48.58 68.08,49.13 68.21,49.26 69.94,49.26 70.07,49.38 70.07,49.98 69.94,50.1 68.11,50.1 67.98,50.23 67.98,50.81 68.11,50.94 69.26,50.94 69.38,51.06 69.38,51.64 69.26,51.77 68.11,51.77 67.98,51.9 67.98,52.48 68.11,52.6 69.26,52.6 69.38,52.73 69.38,53.31 69.26,53.44 68.5,53.44 68.37,53.56 68.37,54.14 68.5,54.27 68.93,54.27 69.14,54.48 69.14,56.12 71.4,58.38 71.4,69.51 68.46,72.45 68.46,78.03
  BOTTOM w0.089: JCPU1.R9 71.51,87.94 v2(72.04,87.41)
  BOTTOM w0.165: JDIMM2.107 68.72,43.47 68.63,43.38 68.63,41.53 v2(69.62,40.53)
DDR_B_MA11: length 69.4
  IN2 w0.089: v2(67.04,87.41) 66.53,87.41 65.11,85.99 63.11,85.99 62.67,85.55 62.67,84.57 61.63,83.53 61.63,79 60.37,77.75 60.37,77.14
  IN2 w0.208: 60.37,77.14 60.37,70.55 56.38,66.56 56.38,58.29 58.26,56.41 58.26,48.93 57.82,48.49 57.82,42.9 58.39,42.33 58.39,36.24 59.98,34.65 59.98,32.77 v2(59.38,32.18)
  BOTTOM w0.089: JCPU1.Y9 66.51,87.94 v2(67.04,87.41)
  BOTTOM w0.165: v2(59.38,32.18) 60.56,33.36 60.56,34.43 61.06,34.93 61.39,34.93 61.81,35.35 JDIMM2.84
DDR_B_MA12: length 66.7
  IN2 w0.089: v2(61.04,86.41) 61.45,86 61.45,79.08 59.75,77.38 59.75,77.14
  IN2 w0.208: 59.75,77.14 59.75,73.28 58.95,72.49 58.95,71.92 59.76,71.12 59.76,70.94 59.33,70.51 59.15,70.51 58.15,71.51 57.97,71.51 57.57,71.1 57.57,70.92 58.57,69.92 58.57,69.62 58.28,69.33 57.98,69.33 56.98,70.33 56.8,70.33 56.39,69.92 56.39,69.74 57.39,68.74 57.39,68.44 57.1,68.15 56.8,68.15 56.35,68.6 56.17,68.6 55.77,68.19 55.77,68.01 56.21,67.56 56.21,67.26 55.77,66.82 55.77,58.04 57.2,56.61 57.2,52.42 57.32,52.29 57.52,52.29 57.64,52.16 57.64,51.53 57.52,51.4 57.3,51.4 57.18,51.27 57.18,50.8 57.3,50.67 57.52,50.67 57.64,50.55 57.64,49.9 57.52,49.78 56.66,49.78 56.54,49.65 56.54,49.07 56.66,48.94 57.08,48.94 57.2,48.82 57.2,48.24 57.08,48.11 56.66,48.11 56.54,47.98 56.54,47.4 56.66,47.28 56.99,47.28 57.2,47.07 57.2,41.93 v2(57.84,41.29)
  BOTTOM w0.089: JCPU1.AF7 60.57,85.94 v2(61.04,86.41)
  BOTTOM w0.165: v2(57.84,41.29) 57.84,41.29 58.63,41.29 60.57,43.23 61.28,43.23 61.51,43.46 JDIMM2.83
DDR_B_MA13: length 78.1
  IN2 w0.089: v2(73.04,87.4) 73.63,86.81 73.63,84.17 73.45,84 72.88,84 72.45,83.57 72.45,82.23 72.21,81.99 72.11,81.99 71.68,81.56 71.68,80.12 73.39,78.4 73.39,77.38 73.64,77.14
  IN2 w0.208: 73.64,77.14 76.6,74.18 77.81,74.18 82.16,69.82 82.16,62.54 81.09,61.46 81.09,60.67 76.29,55.87 76.29,45.34 75.11,44.15 75.11,42.09 74.53,41.51 74.53,39.7 74.74,39.49 74.98,39.49 75.11,39.36 75.11,38.78 74.98,38.66 74.48,38.66 74.35,38.53 74.35,34.06 74.22,33.93 73.48,33.93 73.35,34.06 73.35,40.34 v2(73.93,40.91)
  BOTTOM w0.089: v2(73.04,87.4) 72.51,87.93 JCPU1.P9
  BOTTOM w0.165: v2(73.93,40.91) 72.62,40.91 72.49,41.04 72.49,43.36 72.32,43.54 JDIMM2.119
DDR_B_MA14: length 73.3
  IN2 w0.089: v2(65.04,87.47) 65.51,87.94 65.51,88.69 65.21,89 59.84,89 59.46,88.62 59.46,79.24 59.16,78.94 58.85,78.94 57.2,77.29 57.2,77.14
  IN2 w0.208: 57.2,77.14 57.2,76.53 53.31,72.65 53.31,66.83 52.62,66.15 52.62,57.7 54.07,56.25 54.07,45.49 54.32,45.24 54.32,39.06 58.41,34.97 58.41,33.58 58.62,33.37 59.05,33.37 v2(59.38,33.7)
  BOTTOM w0.089: v2(65.04,87.47) 65.51,87 JCPU1.AA8
  BOTTOM w0.165: JDIMM2.80 60.62,35.24 60,34.62 60,34.32 v2(59.38,33.7)
DDR_B_MA15: length 65.2
  IN2 w0.089: v2(59.04,85.41) 59.04,85.41 58.63,85 58.63,79.55 56.61,77.53
  IN2 w0.208: 56.61,77.53 56.5,77.42 56.5,76.7 52.01,72.22 52.01,57.45 53.45,56.01 53.45,45.24 53.7,44.99 53.7,38.79 57.78,34.71 57.78,32.88 v2(57.08,32.18)
  BOTTOM w0.089: JCPU1.AG7 59.51,85.88 v2(59.04,85.41)
  BOTTOM w0.165: v2(57.08,32.18) 57.56,32.66 57.56,33.34 59.28,35.07 59.66,35.07 60.02,35.43 JDIMM2.78
DDR_B_RAS#: length 72.9
  IN2 w0.089: 69.7,78.03 68.63,79.11 68.63,82.91 69.73,84.01 70.52,84.01 70.92,84.41 v2(71.04,84.41)
  IN2 w0.208: v2(69.92,33.7) 69.92,33.59 69.24,32.91 69.24,31.58 69.12,31.46 68.62,31.46 68.5,31.58 68.5,33.11 68.97,33.58 68.97,35.01 69.1,35.14 70.12,35.14 70.25,35.27 70.25,35.85 70.12,35.98 69.35,35.98 69.23,36.11 69.23,36.62 69.35,36.75 70.12,36.75 70.25,36.87 70.25,37.44 70.12,37.56 68.93,37.56 68.8,37.69 68.8,38.22 68.93,38.35 70.12,38.35 70.25,38.48 70.25,44.71 71.39,45.85 71.39,50.39 70.94,50.85 70.94,55.73 74.7,59.5 74.7,68.04 73.89,68.85 73.59,68.85 73.27,68.53 73.09,68.53 72.68,68.94 72.68,69.12 73,69.44 73,69.74 69.7,73.04 69.7,78.03
  BOTTOM w0.089: v2(71.04,84.41) 71.51,84.88 JCPU1.R6
  BOTTOM w0.165: JDIMM2.110 69.62,34.97 69.38,34.73 69.38,34.37 69.92,33.82 v2(69.92,33.7)
DDR_B_WE#: length 73.7
  IN2 w0.089: v2(73.04,84.41) 73.04,84.78 72.91,84.9 72.71,84.9 72.59,84.78 72.59,83.96 71.44,82.81 70.76,82.81 70.44,82.5 70.44,78.94 71.55,77.83
  IN2 w0.208: v2(71.98,40.91) 72.6,41.53 72.6,44.25 73.67,45.33 73.67,55.86 76.54,58.73 76.54,60.2 77.17,60.83 78.64,60.83 78.92,61.11 78.92,68.49 77.3,70.11 77.01,70.11 76.53,69.63 76.35,69.63 75.94,70.04 75.94,70.22 76.86,71.13 76.86,71.31 76.45,71.72 76.27,71.72 75.04,70.49 74.86,70.49 74.45,70.9 74.45,71.08 75.68,72.31 75.68,72.49 75.27,72.9 75.09,72.9 73.86,71.67 73.68,71.67 73.27,72.08 73.27,72.26 74.5,73.49 74.5,73.67 74.09,74.08 73.91,74.08 72.68,72.85 72.5,72.85 72.09,73.26 72.09,73.44 73.32,74.67 73.32,74.85 72.93,75.24 72.75,75.24 72.05,74.53 71.87,74.53 71.55,74.85 71.55,75.03 72.08,75.56 72.08,76.09 71.95,76.22 71.68,76.22 71.55,76.35 71.55,77.83
  BOTTOM w0.089: JCPU1.P6 72.51,84.94 v2(73.04,84.41)
  BOTTOM w0.165: JDIMM2.113 70.52,42.32 71.93,40.91 v2(71.98,40.91)
DDR_CKE0_DIMMA: length 53.1
  IN1 w0.089: 58.48,77.14 59.02,77.68 60.35,77.68 61.81,79.14 62.19,79.14 62.46,79.41 62.46,79.59 62.68,79.82 62.68,80.58 61.68,81.58 61.68,82.75 60.62,83.8 60.62,86.51 60.96,86.84 62.09,86.84 62.39,86.54 62.39,86.05 62.52,85.92 63.34,85.92 63.45,86.03 63.45,86.67 63.32,86.8 62.83,86.8 62.71,86.93 62.71,87.27 62.58,87.4 v2(62.04,87.4)
  IN1 w0.208: v2(57.8,55.03) 57.07,55.76 57.07,61.23 53.92,64.38 53.92,72.58 58.48,77.14
  BOTTOM w0.089: JCPU1.AD9 62.51,87.87 v2(62.04,87.4)
  BOTTOM w0.165: v2(57.8,55.03) 57.25,55.03 57.03,55.25 57.03,58.96 57.16,59.09 58.39,59.09 58.51,58.96 JDIMM1.73
DDR_CKE1_DIMMA: length 54.3
  IN1 w0.089: v2(63.04,87.41) 62.69,87.76 61.89,87.76 61.15,87.02 60.88,87.02 60.45,86.58 60.45,83.73 61.5,82.68 61.5,81.51 62.35,80.66 62.35,80.34 62.14,80.13 61.93,80.13 59.91,78.11 57.62,78.11 56.64,77.14
  IN1 w0.208: v2(58.28,48.3) 57.2,48.3 55.84,49.66 55.84,60.72 51.11,65.45 51.11,71.6 56.64,77.14
  BOTTOM w0.089: JCPU1.AC9 63.51,87.88 v2(63.04,87.41)
  BOTTOM w0.165: JDIMM1.74 58.81,48.48 58.63,48.3 v2(58.28,48.3)
DDR_CKE2_DIMMB: length 65.3
  IN2 w0.089: 58.47,77.14 58.47,77.24 60.46,79.23 60.46,87.73 60.64,87.91 60.64,88.52 60.51,88.64 60.2,88.64 60.07,88.52 v2(60.07,88.41)
  IN2 w0.208: v2(56.04,42.05) 55.54,42.54 55.54,43.16 55.67,43.29 55.82,43.29 55.95,43.42 55.95,43.99 55.82,44.12 55.67,44.12 55.54,44.25 55.54,44.83 55.67,44.95 55.82,44.95 55.94,45.08 55.94,46.08 55.31,46.72 55.31,50.37 55.94,51 55.94,56.12 54.54,57.53 54.54,58.05 54.33,58.26 54.06,58.26 53.85,58.47 53.85,58.89 54.06,59.09 54.33,59.09 54.54,59.3 54.54,59.72 54.33,59.93 54.06,59.93 53.85,60.13 53.85,60.55 54.06,60.76 54.33,60.76 54.54,60.97 54.54,61.38 54.33,61.59 54.06,61.59 53.85,61.8 53.85,62.22 54.06,62.43 54.33,62.43 54.54,62.63 54.54,63.05 54.33,63.26 54.06,63.26 53.85,63.47 53.85,63.88 54.06,64.09 54.33,64.09 54.54,64.3 54.54,69.81 55.29,70.57 55.29,70.86 54.54,71.62 54.54,71.8 54.95,72.21 55.13,72.21 55.94,71.39 56.12,71.39 56.53,71.8 56.53,71.98 55.84,72.67 55.84,72.85 56.25,73.26 56.43,73.26 57.12,72.57 57.3,72.57 57.77,73.04 57.77,73.26 57.6,73.42 57.6,73.81 58.49,74.69 58.49,74.87 58.03,75.33 58.03,75.63 58.47,76.06 58.47,77.14
  BOTTOM w0.089: JCPU1.AF10 60.51,88.85 v2(60.07,88.41)
  BOTTOM w0.165: JDIMM2.73 58.51,43.56 58.22,43.27 57.63,43.27 56.41,42.05 v2(56.04,42.05)
DDR_CKE3_DIMMB: length 64.5
  IN2 w0.089: 55.87,77.14 57.04,78.31 57.14,78.31 57.96,79.13 58.45,79.63 58.45,87.91 59.05,88.5 v2(59.05,88.51)
  IN2 w0.208: 55.87,77.14 55.87,76.95 51.39,72.47 51.39,57.19 52.3,56.29 52.3,50.85 52.83,50.32 52.83,44.98 53.09,44.73 53.09,37.69 v2(57.08,33.7)
  BOTTOM w0.089: v2(59.05,88.51) 59.48,88.94 JCPU1.AG10
  BOTTOM w0.165: JDIMM2.74 58.81,35.41 57.11,33.7 v2(57.08,33.7)
DDR_CS0_DIMMA#: length 57.3
  IN1 w0.089: v2(75.03,85.44) 75.61,85.44 76.46,84.59 76.46,84.2 76.46,79.22 77.34,78.35 77.34,77.14
  IN1 w0.208: v2(72.59,45.99) 73.04,45.99 73.17,45.86 73.17,44.39 73.29,44.26 73.85,44.26 73.98,44.39 73.98,48.06 74.11,48.19 76.1,48.19 76.23,48.32 76.23,55.88 76.53,56.18 76.53,60.44 80.1,64.01 81.27,65.18 82.04,65.95 82.04,67.01 82.84,67.81 82.84,71.12 77.34,76.62 77.34,77.14
  BOTTOM w0.089: v2(75.03,85.44) 74.54,85.94 JCPU1.M7
  BOTTOM w0.165: v2(72.59,45.99) 71.99,46.58 71.99,47.15 70.81,48.33 JDIMM1.114
DDR_CS1_DIMMA#: length 57.5
  IN1 w0.089: v2(76.04,87.43) 76.57,87.43 76.7,87.3 76.7,86.87 76.57,86.75 75.58,86.75 75.45,86.87 75.45,87.86 75.33,87.98 74.57,87.98 74.44,87.86 74.44,85.11 74.73,84.82 75.2,84.82 75.46,84.56 75.46,79.13 76.11,78.49 76.11,77.14
  IN1 w0.208: v2(75.14,54.81) 74.94,54.81 74.68,55.06 74.68,56.08 75.3,56.69 75.3,60.95 79.9,65.54 79.9,66.32 80.11,66.53 80.68,66.53 80.8,66.65 80.8,67.23 80.68,67.36 80.11,67.36 79.9,67.57 79.9,67.98 80.11,68.19 81.48,68.19 81.61,68.32 81.61,68.9 81.48,69.03 80.11,69.03 79.9,69.23 79.9,69.65 80.11,69.86 81.37,69.86 81.5,69.99 81.5,70.56 81.37,70.69 80.11,70.69 79.9,70.9 79.9,72.32 76.11,76.11 76.11,77.14
  BOTTOM w0.089: JCPU1.L9 75.52,87.94 v2(76.04,87.43)
  BOTTOM w0.165: v2(75.14,54.81) 74.91,54.81 74.59,54.49 74.59,53.67 74.46,53.54 73.64,53.54 73.52,53.67 73.52,55.16 72.92,55.77 JDIMM1.121
DDR_CS2_DIMMB#: length 69.5
  IN2 w0.089: 75.38,77.14 74.62,77.89 74.62,78.71 73.54,79.79 73.54,83.42 73.41,83.55 73.17,83.55 73.04,83.42 v2(73.04,83.41)
  IN2 w0.208: 75.38,77.14 77.11,75.4 78.32,75.4 83.76,69.96 83.76,62.4 82.32,60.95 82.32,60.16 78.08,55.93 78.08,50.83 77.53,50.28 77.53,44.84 76.34,43.64 76.34,35.52 75.74,34.93 75.74,32.17 75.37,31.8 v2(72.66,31.8)
  BOTTOM w0.089: v2(73.04,83.41) 72.57,82.94 JCPU1.P4
  BOTTOM w0.165: JDIMM2.114 70.81,33.64 v2(72.66,31.8)
DDR_CS3_DIMMB#: length 66.4
  IN2 w0.089: 72,78.65 71.5,79.16 71.5,80.99 71.37,81.11 71.17,81.11 71.04,80.99 v2(71.04,80.58)
  IN2 w0.208: v2(73.93,42.43) 74.18,42.18 74.33,42.18 74.49,42.34 74.49,44.41 75.68,45.59 75.68,56.13 80.15,60.6 80.15,62.02 80.36,62.23 80.99,62.23 81.11,62.36 81.11,62.94 80.99,63.06 80.36,63.06 80.15,63.27 80.15,63.69 80.36,63.9 81.42,63.9 81.55,64.02 81.55,64.6 81.42,64.73 80.36,64.73 80.15,64.94 80.15,65.36 80.36,65.56 81.42,65.56 81.55,65.69 81.55,66.27 81.42,66.4 80.36,66.4 80.15,66.61 80.15,67.02 80.36,67.23 81.42,67.23 81.55,67.36 81.55,67.94 81.42,68.06 80.36,68.06 80.15,68.27 80.15,68.68 80.36,68.89 81.4,68.89 81.52,69.02 81.52,69.59 81.4,69.72 80.31,69.72 79.88,70.15 79.88,70.34 80.24,70.7 80.24,70.88 79.8,71.32 79.62,71.32 79.19,70.89 79.02,70.89 78.61,71.3 78.61,71.48 78.88,71.76 78.88,71.94 78.47,72.35 78.29,72.35 78.02,72.07 77.84,72.07 77.43,72.48 77.43,72.66 77.77,73.01 77.77,73.19 77.4,73.56 77.22,73.56 76.87,73.21 76.7,73.21 72.78,77.13 72.78,77.88 72,78.65
  BOTTOM w0.089: JCPU1.R2 71.41,80.94 v2(71.04,80.58)
  BOTTOM w0.165: JDIMM2.121 72.92,41.62 73.04,41.49 73.33,41.49 73.46,41.62 73.46,42.26 73.64,42.43 v2(73.93,42.43)
DGPU_HOLD_RST#: length 69.8
  TOP w0.089: 137.93,89.49 137.92,89.49 v2(137.58,89.15) 137.44,89.29 U4.A12
  TOP w0.102: v2(143.3,90.28) 142.54,91.04 141.52,91.04 140.88,90.4 139.47,90.4 139.03,89.96 R167.2 137.93,89.49 ; v2(134.1,129.09) 133.97,128.95 133.97,126.4 134.67,125.7 134.67,125.17 134.45,124.96 UV2.2
  IN1 w0.102: 132.86,123.75 131.07,125.54 131.07,127.12 133.03,129.09 v2(134.1,129.09)
  IN1 w0.127: 132.86,123.75 135.49,121.12 142.02,121.12 144.34,118.79 v2(144.34,117.52)
  BOTTOM w0.102: v2(137.58,89.15) 135.69,89.15 R168.2 ; v2(143.3,90.28) 143.85,90.83 143.85,91.97 143.35,92.47 142.77,92.47 142.48,92.76 142.48,94.35 v1(142.72,94.59) 143.31,95.18 143.31,96.26 143.81,96.76 143.81,108.65 143.56,108.91 143.56,116.74 v2(144.34,117.52)
DGPU_PWR_EN: length 275
  TOP w0.089: U4.C12 134.88,89.29 135.2,88.96 135.94,88.96 136.09,89.11 137.08,89.11 137.44,88.75 137.96,88.75
  TOP w0.102: 137.96,88.75 138.19,88.75 v2(138.26,88.83) ; U31.123 172.79,76.14 172.6,76.32 172.6,77.35 172.33,77.62 170.77,77.62 168.54,79.85 168.54,85.92 167.48,86.98 v2(165.05,86.98) ; v2(156.02,120.11) 156.02,120.42 159.33,123.72 159.85,123.72 160.14,123.43 v2(160.51,123.43) QV9.2 160.51,125.59 160.38,125.71 156.7,125.71 156.44,125.46 QV6.2
  TOP w0.254: v2(186.21,131.11) 187.03,131.11 188.68,132.77 PR813.1 ; v2(169.41,132.03) 169.45,131.99 PR612.1 ; v2(115.78,175.22) 115.68,175.12 PR626.2
  IN1 w0.127: v2(115.78,175.22) 116.19,174.81 117.63,174.81 120.23,177.4 157.86,177.4 161.11,174.15 161.11,169.97 v2(161.46,169.62) ; v2(155.95,86.22) 156.94,86.22 157.75,87.04 160.8,87.04 161.42,87.66 163.49,87.66 164.17,86.98 v2(165.05,86.98) ; v2(155.43,133.65) 157.64,133.65 158.86,132.43 158.86,125.97 160.17,124.66 160.72,124.66 161.12,124.25 170.8,124.25 172,125.46 172,127.75 172.38,128.13 172.38,130.1 171.88,130.6 169.58,130.6 169.41,130.78 v2(169.41,132.03)
  IN1 w0.254: v2(186.21,131.11) 185.55,130.45 183.79,130.45 183.31,130.93 180.97,130.93 180.37,130.33 178.05,130.33 176.35,132.03 v2(169.41,132.03)
  IN2 w0.127: v2(160.51,123.43) 158.16,125.78 158.16,133.06 157.56,133.65 v2(155.43,133.65) 155.43,134.22 156.19,134.99 156.19,144.7 156.55,145.06 156.55,147.03 158.29,148.77 158.29,151.94 159.87,153.53 163.5,153.53 165.73,155.75 165.73,159.42 161.21,163.94 161.21,169.36 v2(161.46,169.62) ; v2(155.95,86.22) 155.34,85.61 144.08,85.61 v2(143.48,86.2)
  BOTTOM w0.102: v2(143.48,86.2) 143.48,86.48 v1(143.02,86.93) 142.69,87.27 139.73,87.27 ; v2(156.02,120.11) 156.02,119.14 157.84,117.32 157.84,97.84 156.07,96.07 156.07,95.67 155.3,94.9 155.3,90.7 155.53,90.47 155.53,90 155.81,89.73 155.81,86.36 v2(155.95,86.22) ; RP13.8 139.72,87.26 139.73,87.27 ; 139.73,87.27 138.33,87.27 138,87.61 138,88.56 v2(138.26,88.83)
  BOTTOM w0.254: v2(115.78,175.22) 115.15,175.22 114.35,174.42 PD601.1
DGPU_PWR_EN#: length 49.9
  TOP w0.102: QV9.1 159.54,121.32 159.05,120.82 QV7.2 159.05,118.97 159.34,118.68 v2(159.99,118.68) 160.22,118.68 160.76,118.14 RV35.2
  TOP w0.254: QV1.2 128.13,107.74 128.75,107.12 QV2.2 132.39,107.12 132.63,107.36 132.63,108.51 v2(132.16,108.98)
  IN1 w0.127: v2(159.99,112.04) 159.57,111.62 145.81,111.62 143.09,108.9 132.24,108.9 v2(132.16,108.98)
  BOTTOM w0.102: v2(132.16,108.98) v1(132.16,109.55) ; v2(159.99,118.68) v2(159.99,112.04)
DGPU_PWROK: length 116.4
  TOP w0.089: 137.96,86.65 v2(137.76,86.45) 137.71,86.5 137.71,86.59 137.05,87.25 135.75,87.25 135.66,87.34 135.16,87.34 134.4,88.09 U4.C14
  TOP w0.102: 137.96,86.65 138.54,87.22 R259.2 ; v2(179.53,112.48) v3(179.53,113.4)
  IN1 w0.127: v2(179.53,112.48) 179.5,112.44 179.5,111.77 179.79,111.47 179.79,88.79 178.46,87.45 178.46,84.4 175.78,81.73 167.08,81.73 165.75,80.4 161.53,80.4 159.77,82.16 141.41,82.16 138.07,85.5 138.07,85.86 137.76,86.17 v2(137.76,86.45)
  BOTTOM w0.254: PR832.1 189.87,133 187.79,130.92 187.79,130.27 187.35,129.84 184.73,129.84 183.34,128.46 183.34,123.7 186.4,120.64 188.08,120.64 188.36,120.36 188.36,117.9 186.29,115.83 186.29,113.83 184.29,111.83 179.98,111.83 179.53,112.28 v2(179.53,112.48)
DH_1.05VSP: length 9.2
  IN1 w0.762: 103.21,36.55 107.53,36.55 109.7,34.38 109.7,33.14
  BOTTOM w0.102: v4(110.05,32.29) v1(110.62,32.29)
  vias: v2(103.03,35.68) v2(109.39,32.32) v4(103.03,35.06)
DH_CHG: length 11.8
  IN2 w1.016: 182.7,164.18 182.7,162.09 179.42,158.82 179.42,157.34 177.52,155.43
  BOTTOM w0.102: v4(176.5,155.79) 176.5,156.21 v1(176.17,156.54)
  vias: v2(182.4,165.05) v2(183.05,165.03) v4(175.85,155.76)
DH_CHG-1:
  vias: v1(185.15,166.76)
DISCHG_G: length 24.4
  TOP w0.254: PR321.2 162.88,167.86 PR322.1 v2(163.49,167.86)
  IN2 w0.254: v2(163.49,167.86) 164.28,167.07 164.28,163.13 165.88,161.53 179.93,161.53 v4(180.42,162.02)
  BOTTOM w0.102: v2(163.49,167.86) v1(162.68,167.86)
DISCHG_G-1: length 2.6
  TOP w0.102: v1(160.86,168.79) PR321.1
  TOP w0.254: PQ311.1 162.42,169.24 PR321.1
DL_1.05VSP: length 17.4
  IN2 w1.016: 116.14,43.08 114.78,41.71 114.78,37.89 113.75,36.86 104.23,36.86
  BOTTOM w0.102: v4(117.85,44.13) v1(118.5,44.13)
  vias: v4(103.85,35.7) v4(103.83,35.06) v4(117.86,43.47)
DL_CHG: length 22.4
  IN2 w1.016: 185.34,169 183.95,169 177.25,162.29 166.36,162.29
  BOTTOM w0.102: v1(185.82,169.48) 186.17,169.48 v4(186.38,169.27)
  vias: v4(165.68,163.25) v4(166.38,163.27) v4(186.39,168.61)
DMI_CRX_PTX_N0: length 50.4
  TOP w0.089: 113.96,86.42 114.06,86.42 114.06,86.41 114.5,86.41 115.33,85.59 116.36,85.59 116.48,85.71 116.76,85.71 117.03,85.98 117.24,85.98 117.37,85.85 117.37,85.71 117.31,85.65 U4.BD21
  TOP w0.102: v2(111.25,94.32) 111.08,94.15 111.08,88.83 113.49,86.42 113.51,86.42 113.96,86.42
  IN2 w0.089: v2(81.95,100.33) 81.95,100.14 82.03,100.06 82.3,100.06 82.38,100.14 82.38,101.53 83.47,102.61 86.19,102.61 86.96,103.38 87.2,103.38 87.22,103.4 87.23,103.4
  IN2 w0.127: 87.23,103.4 91.6,103.4 93.01,101.99 103.33,101.99 106.11,99.21 106.42,99.21 109.25,96.38 109.25,95.83 110.76,94.32 v2(111.25,94.32)
  BOTTOM w0.089: JCPU1.D21 82.23,99.94 81.95,100.22 v2(81.95,100.33)
DMI_CRX_PTX_N1: length 47.7
  TOP w0.089: U4.BE20 116.6,86.12 115.19,86.12 114.47,86.83 113.98,86.83 113.98,86.83 113.96,86.83
  TOP w0.102: v2(113.03,92.17) 113.03,92.05 112.97,92 112.86,92 112.65,91.79 112.46,91.79 111.79,91.12 111.79,88.72 112.95,87.56 112.95,87.54 113.43,87.06 113.45,87.06 113.68,86.83 113.96,86.83
  IN2 w0.089: 87.23,102.72 87.22,102.72 87.2,102.7 87.13,102.7 87.11,102.68 87.04,102.68 86.44,102.08 83.87,102.08 83.38,101.59 83.38,100.14 83.26,100.02 83.13,100.02 82.96,100.18 v2(82.96,100.4)
  IN2 w0.127: v2(113.03,92.17) 112.88,92.02 111.78,92.02 102.52,101.28 91.89,101.28 90.46,102.72 87.23,102.72
  BOTTOM w0.089: v2(82.96,100.4) 83.42,99.94 JCPU1.C21
DMI_CRX_PTX_N2: length 43.9
  TOP w0.089: 113.96,90.68 114.3,90.68 114.85,90.13 114.85,87.99 115.5,87.34 116.77,87.34 116.98,87.55 116.98,87.72 117.03,87.77 117.19,87.77 117.3,87.66 117.3,87.35 117.23,87.28 U4.BD17
  TOP w0.102: v2(112.97,90.93) 113.22,90.68 113.96,90.68
  IN2 w0.089: v2(83.97,100.39) 83.97,100.17 84.12,100.02 84.3,100.02 84.39,100.11 84.39,100.7 84.74,101.05 86.79,101.05 87.04,101.3 87.04,101.32 87.05,101.33
  IN2 w0.127: 87.05,101.33 87.75,102.03 90.17,102.03 91.64,100.57 102.23,100.57 112.06,90.73 112.76,90.73 v2(112.97,90.93)
  BOTTOM w0.089: JCPU1.B21 84.41,99.94 v2(83.97,100.39)
DMI_CRX_PTX_N3: length 39.8
  TOP w0.089: 114.11,89.14 114.13,89.13 114.13,89.12 114.17,89.08 114.17,89.07 114.31,88.93 114.31,87.97 115.51,86.77 116.6,86.77 U4.BE18
  TOP w0.102: 114.11,89.14 114.02,89.24 112.65,89.24 112.53,89.36 112.53,89.54 112.65,89.66 v2(112.92,89.66)
  IN2 w0.089: v2(84.97,100.4) 85.34,100.02 87.19,100.02 87.21,100.04 87.23,100.04
  IN2 w0.127: 87.23,100.04 90.09,100.04 90.25,99.88 101.92,99.88 112.44,89.37 112.63,89.37 v2(112.92,89.66)
  BOTTOM w0.089: JCPU1.A21 85.42,99.94 v2(84.97,100.4)
DMI_CRX_PTX_P0: length 50.3
  TOP w0.089: U4.BB21 117.58,85.63 117.32,85.37 116.95,85.37 116.8,85.51 116.56,85.51 116.44,85.39 115.25,85.39 114.42,86.21 113.98,86.21 113.98,86.2 113.96,86.2
  TOP w0.102: v2(110.67,93.72) 110.86,93.53 110.86,88.74 113.4,86.2 113.42,86.2 113.96,86.2
  IN2 w0.089: 87.23,103.15 87.22,103.15 87.2,103.17 87.05,103.17 86.28,102.4 83.56,102.4 82.6,101.44 82.6,100.05 82.39,99.84 82.04,99.84 81.95,99.76 v2(81.95,99.44)
  IN2 w0.127: 87.23,103.15 91.5,103.15 92.91,101.74 103.22,101.74 106,98.96 106.32,98.96 109,96.27 109,95.73 110.67,94.05 v2(110.67,93.72)
  BOTTOM w0.089: JCPU1.D20 82.44,98.94 v2(81.95,99.44)
DMI_CRX_PTX_P1: length 47.8
  TOP w0.089: 113.96,87.04 113.98,87.04 113.98,87.04 114.56,87.04 115.27,86.32 116.8,86.32 116.97,86.16 117.47,86.16 U4.BC20
  TOP w0.102: 113.96,87.04 113.77,87.04 v4(113.35,87.46) 112.01,88.81 112.01,91.03 112.56,91.59 v2(113.03,91.59)
  IN2 w0.089: 87.23,102.46 87.13,102.46 86.53,101.86 83.96,101.86 83.6,101.5 83.6,100.05 83.35,99.8 83.14,99.8 82.95,99.62 v2(82.95,99.43)
  IN2 w0.127: 87.23,102.46 90.35,102.46 91.79,101.03 102.41,101.03 111.67,91.76 112.86,91.76 v2(113.03,91.59)
  BOTTOM w0.089: v2(82.95,99.43) 83.43,98.94 JCPU1.C20
DMI_CRX_PTX_P2: length 43.8
  TOP w0.089: U4.BB17 117.55,87.25 117.29,86.99 117.02,86.99 116.87,87.14 115.42,87.14 114.65,87.9 114.65,90.04 114.23,90.46 113.96,90.46
  TOP w0.102: 113.96,90.46 113.08,90.46 v2(112.97,90.35)
  IN2 w0.089: 87.23,101.15 87.22,101.14 87.19,101.14 86.88,100.83 84.83,100.83 84.6,100.61 84.6,100.02 84.38,99.81 84.2,99.81 83.96,99.56 v2(83.96,99.42)
  IN2 w0.127: v2(112.97,90.35) 112.84,90.48 111.96,90.48 102.12,100.31 91.53,100.31 90.07,101.78 87.86,101.78 87.23,101.15
  BOTTOM w0.089: v2(83.96,99.42) 84.43,98.94 JCPU1.B20
DMI_CRX_PTX_P3: length 39.9
  TOP w0.089: 113.96,88.99 114.1,88.85 114.1,87.89 115.43,86.56 116.8,86.56 116.97,86.73 117.47,86.73 U4.BC18
  TOP w0.102: v2(112.92,88.83) 112.92,88.9 113.05,89.02 113.93,89.02 113.96,88.99
  IN2 w0.089: v2(84.96,99.43) 84.97,99.43 85.34,99.8 87.19,99.8 87.21,99.78 87.23,99.78
  IN2 w0.127: v2(112.92,88.83) 112.65,89.1 112.35,89.1 101.82,99.63 90.14,99.63 89.98,99.78 87.23,99.78
  BOTTOM w0.089: v2(84.96,99.43) 85.44,98.94 JCPU1.A20
DMI_CTX_PRX_N0: length 48.5
  TOP w0.102: U4.AW22 119.21,85.22 v2(119.53,85.54)
  IN2 w0.089: v2(81.97,97.37) 81.95,97.37 81.34,96.76 81.34,95.2 81.76,94.78 86.19,94.78 86.81,95.4 87.09,95.4 87.13,95.36 87.23,95.36 ; v2(119.53,85.54) 119.4,85.41 119.4,85.09 119.13,84.82 118.7,84.82 118.19,85.33 117.74,85.33 117.57,85.49 115.41,85.49 115.4,85.47 115.33,85.47 115.31,85.46 115.3,85.46
  IN2 w0.127: 87.23,95.36 91.19,95.36 92.71,96.88 100.67,96.88 112.1,85.46 115.3,85.46
  BOTTOM w0.089: JCPU1.D18 82.4,96.94 v2(81.97,97.37)
DMI_CTX_PRX_N1: length 47.9
  TOP w0.102: U4.AR20 121,86.31 v2(120.78,86.54)
  IN2 w0.089: 87.23,96.58 87.22,96.58 87.2,96.56 87.13,96.56 87.11,96.54 87.04,96.54 86.67,96.17 85.92,96.17 85.73,95.98 82.74,95.98 82.56,96.16 82.56,96.71 82.75,96.9 83.21,96.9 83.37,96.75 83.37,96.52 83.26,96.4 v2(83,96.4) ; 115.3,86.4 115.31,86.4 115.33,86.38 117.94,86.38 118.19,86.13 119.79,86.13 119.79,86.13 120.87,86.13 120.99,86.24 120.99,86.33 v2(120.78,86.54)
  IN2 w0.127: 87.23,96.58 91.08,96.58 92.32,97.82 101.07,97.82 112.5,86.4 115.3,86.4
  BOTTOM w0.089: v2(83,96.4) 83.46,95.94 JCPU1.C17
DMI_CTX_PRX_N2: length 47.7
  TOP w0.089: v2(121.39,87.54) 121.6,87.33 U4.AP17
  IN2 w0.089: 115.3,87.82 115.55,87.82 115.82,87.55 116.95,87.55 117.63,88.23 118.62,88.23 118.69,88.16 120.37,88.16 120.43,88.22 121.01,88.22 121.27,87.96 121.27,87.66 v2(121.39,87.54) ; 87.23,99.18 85.89,99.18 85.72,99.01 83.75,99.01 83.37,98.63 83.37,97 83.95,96.41 v2(83.95,96.38)
  IN2 w0.127: 115.3,87.82 113.01,87.82 101.64,99.19 89.91,99.19 89.9,99.18 87.23,99.18
  BOTTOM w0.089: JCPU1.B17 84.39,95.94 v2(83.95,96.38)
DMI_CTX_PRX_N3: length 44.1
  TOP w0.102: v2(119.57,86.56) 119.81,86.32 U4.AV20
  IN2 w0.089: 115.3,87.11 117.78,87.11 117.87,87.2 119.1,87.2 119.36,86.94 119.36,86.77 v2(119.57,86.56) ; 87.23,97.26 87.1,97.26 87.08,97.24 86.31,97.24 85.51,98.04 84.74,98.04 84.38,97.68 84.38,97.01 v2(85.01,96.38)
  IN2 w0.127: 87.23,97.26 90.79,97.26 92.04,98.51 101.36,98.51 112.75,87.11 115.3,87.11
  BOTTOM w0.089: v2(85.01,96.38) 85.44,95.94 JCPU1.A17
DMI_CTX_PRX_P0: length 48.4
  TOP w0.089: 118.62,85.28 v2(118.89,85.56)
  TOP w0.102: U4.AY22 118.62,85.28
  IN2 w0.089: v2(118.89,85.56) 119.04,85.56 119.18,85.42 119.18,85.18 119.04,85.04 118.79,85.04 118.28,85.54 117.83,85.54 117.66,85.71 115.3,85.71 ; v2(81.97,96.39) 82.09,96.39 82.16,96.47 82.16,96.94 82.09,97.01 81.89,97.01 81.55,96.67 81.55,95.29 81.85,94.99 86.1,94.99 86.72,95.62 87.23,95.62
  IN2 w0.127: 87.23,95.62 91.09,95.62 92.61,97.14 100.78,97.14 110.51,87.4 112.2,85.71 115.3,85.71
  BOTTOM w0.089: JCPU1.D17 82.42,95.94 v2(81.97,96.39)
DMI_CTX_PRX_P1: length 48
  TOP w0.102: U4.AP20 121.6,86.32 v2(121.38,86.54)
  IN2 w0.089: 87.23,96.32 87.13,96.32 86.76,95.96 86.01,95.96 85.82,95.77 82.65,95.77 82.34,96.07 82.34,96.8 v2(82.94,97.39) ; 115.3,86.14 115.31,86.14 115.33,86.16 117.85,86.16 118.1,85.92 119.7,85.92 119.7,85.91 120.96,85.91 121.2,86.15 121.2,86.36 v2(121.38,86.54)
  IN2 w0.127: 87.23,96.32 91.18,96.32 92.43,97.57 100.97,97.57 112.39,86.14 115.3,86.14
  BOTTOM w0.089: v2(82.94,97.39) 83.39,96.94 JCPU1.C18
DMI_CTX_PRX_P2: length 47.5
  TOP w0.102: v2(120.78,87.55) 121,87.33 U4.AR17
  IN2 w0.089: 115.3,87.57 115.49,87.57 115.73,87.34 117.04,87.34 117.72,88.02 118.53,88.02 118.6,87.94 120.45,87.94 120.52,88.01 120.92,88.01 121.05,87.87 121.05,87.67 120.93,87.55 v2(120.78,87.55) ; v2(84.02,97.39) 84.12,97.39 84.2,97.31 84.2,96.83 84.11,96.74 83.93,96.74 83.59,97.09 83.59,98.54 83.84,98.79 85.81,98.79 85.95,98.93 87.23,98.93
  IN2 w0.127: 115.3,87.57 112.91,87.57 101.53,98.94 89.81,98.94 89.8,98.93 87.23,98.93
  BOTTOM w0.089: v2(84.02,97.39) 84.47,96.94 JCPU1.B18
DMI_CTX_PRX_P3: length 44.2
  TOP w0.102: v2(118.93,86.58) 119.21,86.3 U4.AW20
  IN2 w0.089: v2(85.01,97.4) 85.24,97.4 85.35,97.29 85.35,96.91 85.21,96.77 84.92,96.77 84.6,97.1 84.6,97.59 84.83,97.83 85.42,97.83 86.22,97.03 87.11,97.03 87.13,97.01 87.23,97.01 ; 115.3,86.86 115.31,86.86 115.33,86.88 115.4,86.88 115.41,86.9 117.87,86.9 117.96,86.99 119.01,86.99 119.13,86.86 119.13,86.78 v2(118.93,86.58)
  IN2 w0.127: 87.23,97.01 90.9,97.01 92.15,98.25 101.25,98.25 112.65,86.86 115.3,86.86
  BOTTOM w0.089: JCPU1.A18 85.46,96.94 v2(85.01,97.4)
DMI_RCOMP: length 2.6
  TOP w0.089: 118.62,87.23 v2(118.96,87.56)
  TOP w0.102: U4.AY17 118.62,87.23
  BOTTOM w0.089: v2(118.96,87.56) 119.04,87.65 119.04,88.05 118.96,88.14 v1(118.68,88.14) 118.25,88.14 118.14,88.24 R135.2
DPRSLPVR_VGA-1: length 6.4
  TOP w0.102: v1(189.74,132.74) PR816.2
  TOP w0.203: v2(189.19,134.45) 189.19,134.74 188.62,135.31 PU801.39
  TOP w0.254: PR816.2 189.19,134.28 v2(189.19,134.45)
  BOTTOM w0.203: PR818.2 189.54,134.8 v2(189.19,134.45) 189.02,134.62 189.02,134.96 188.71,135.27 188.71,135.27 188.56,135.42 PR819.2
DPWROK_EC: length 40.4
  TOP w0.102: U31.71 159.62,86.56 158.7,85.64 155.94,85.64 155.52,86.07 155.52,88.44 155.61,88.53 155.61,89.8 v2(156.01,90.21) ; R149.2 134.4,99.85 134.79,100.24 134.79,100.37 136.68,102.26 142.21,102.26 144.62,99.84 148.17,99.84 151.59,96.43 153.27,96.43 155.13,94.57 155.74,94.57 v2(155.79,94.52)
  BOTTOM w0.102: v2(155.79,94.52) 155.79,94.51 v1(155.79,91.72) 155.79,91.16 156.01,90.94 v2(156.01,90.21)
DQMA0: length 27.7
  TOP w0.102: UV5.D3 110.92,128.45 110.07,127.59 110.07,125.19 110.23,125.03
  TOP w0.127: v2(120.78,130.59) 120.01,130.59 118.86,129.43 117.61,129.43 117.48,129.3 117.48,129.05 117.61,128.92 118.36,128.92 118.49,128.8 118.49,128.54 118.36,128.42 117.61,128.42 117.48,128.29 117.48,128.03 117.61,127.91 v1(117.96,127.91) 118.36,127.91 118.49,127.78 118.49,127.29 118.28,127.09 118.1,127.09 117.93,127.26 117.75,127.26 117.57,127.07 117.57,126.9 117.74,126.73 117.74,126.55 117.56,126.37 117.38,126.37 117.21,126.54 117.03,126.54 116.85,126.36 116.85,126.18 117.02,126.01 117.02,125.83 116.84,125.65 116.66,125.65 116.5,125.82 116.32,125.82 116.14,125.64 116.14,125.46 116.3,125.29 116.3,125.11 116.12,124.93 115.94,124.93 115.78,125.1 115.6,125.1 115.42,124.92 115.42,124.74 115.58,124.57 115.58,124.39 115.39,124.19 110.37,124.19 110.23,124.33 110.23,125.03
  BOTTOM w0.102: 120.81,130.59 120.94,130.59 122.02,131.67 UV1.A32
  BOTTOM w0.127: 120.81,130.59 v2(120.78,130.59)
DQMA1: length 31.8
  BOTTOM w0.102: UV1.C32 123.32,131.67 123.96,132.32 123.96,132.71 123.7,132.97 123.7,133.25 123.37,133.58 122.32,133.58 122.04,133.31 120.92,133.31 120.81,133.2 ; 109.67,124.79 109.67,126.07 109.53,126.21 109.53,126.96 108.05,128.45 UV6.D3
  BOTTOM w0.127: 109.67,124.79 109.67,124.49 v1(111.12,123.04) 112.81,121.36 116.73,121.36 118.56,123.19 118.56,130.95 120.81,133.2
DQMA2: length 35.1
  TOP w0.127: v2(109.04,129.41) 108.84,129.21 108.06,129.21 UV5.E7
  IN2 w0.102: v2(124.37,136.89) 124.31,136.83 122.98,136.83 122.88,136.73 122.88,136.2 122.78,136.1 122.58,136.1 122.47,136.2 122.47,136.73 122.37,136.83 121.94,136.83 121.58,136.48 121.58,136.16 122.34,135.41 122.34,133.86
  IN2 w0.157: 122.34,133.86 122.34,131.68 122.21,131.56 121.91,131.56 121.79,131.43 121.79,130.77 121.91,130.64 122.3,130.64 122.42,130.52 122.42,129.32 122.28,129.18 121.72,129.18 121.6,129.31 121.6,129.56 121.47,129.69 120.94,129.69 120.81,129.56 120.81,128.86 120.35,128.41 116.22,128.41 116.1,128.28 116.1,127.06 115.97,126.93 115.07,126.93 115.03,126.9 111.18,126.9 110.9,127.18 109.82,127.18 109.51,127.49 109.51,128.94 v2(109.04,129.41)
  BOTTOM w0.102: v2(124.37,136.89) 124.37,137.03 124.76,137.41 124.89,137.41 125.19,137.71 125.19,138.04 124.95,138.28 124.73,138.28 124.14,138.87 UV1.D23
DQMA3: length 34.6
  IN1 w0.102: v2(110.82,128.82) 110.82,128.55 110.95,128.43 111.39,128.43 111.49,128.33 111.49,128.13 111.61,128.01 111.78,128.01 111.9,128.13 111.9,128.33 112,128.43 112.21,128.43 112.31,128.33 112.31,128.13 112.43,128.01 112.59,128.01 112.71,128.13 112.71,128.33 112.81,128.43 113.46,128.43
  IN1 w0.157: 113.46,128.43 113.75,128.71 114.78,128.71 117.1,131.04 117.1,131.26 116.86,131.5 116.86,131.68 117.13,131.94 117.3,131.94 117.55,131.7 117.77,131.7 117.99,131.93 117.99,132.15 117.45,132.69 117.45,132.92 117.67,133.14 117.89,133.14 118.44,132.6 118.66,132.6 118.9,132.84 118.9,133 118.41,133.5 118.41,134.56 119.27,135.42 119.27,137.89 119.43,138.05 120.06,138.05 120.19,138.18 120.19,138.55 120.06,138.68 119.58,138.68 119.45,138.81 119.45,139.18 119.58,139.31 120.46,139.31 120.62,139.47 120.62,140.18 120.99,140.55 122.03,140.55 122.14,140.66 122.76,140.66 v2(123.26,140.17)
  BOTTOM w0.102: UV6.E7 111.23,129.52 110.92,129.83 110.41,129.83 110.27,129.69 109.58,129.69 109.46,129.56 109.46,129.34 109.56,129.24 110.23,129.24 110.33,129.14 110.33,127.91 110.46,127.78 110.69,127.78 110.82,127.91 v2(110.82,128.82) ; v2(123.26,140.17) 123.57,139.86 123.86,139.86 UV1.E22
DQMA4: length 31.1
  TOP w0.102: UV7.E7 111.18,155.12 v2(110.78,155.52)
  IN1 w0.102: v2(110.78,155.52) 111.15,155.15 113.81,155.15
  IN1 w0.157: v2(118.08,147.34) 118.14,147.41 118.14,150.91 118.58,151.35 119.13,151.35 119.26,151.47 119.26,151.9 119.13,152.03 118.54,152.03 118.43,152.13 118.43,152.73 116.47,154.69 116.47,155.13 116.31,155.29 115.03,155.29 114.69,154.95 114.45,154.95 114.24,155.15 113.81,155.15
  BOTTOM w0.102: UV1.C14 123.17,146.07 122.86,145.77 122.33,145.77 121.91,146.19 121.89,146.19
  BOTTOM w0.127: v2(118.08,147.34) 117.9,147.34 117.77,147.22 117.77,146.48 117.9,146.35 119.51,146.35 119.64,146.23 119.64,145.93 119.51,145.81 v1(118.83,145.81) 117.9,145.81 117.77,145.68 117.77,145.35 117.9,145.22 119.65,145.22 119.78,145.09 119.78,144.38 119.91,144.26 120.4,144.26 120.53,144.38 120.53,146.17 120.66,146.3 121.77,146.3 121.89,146.19
DQMA5: length 28.6
  TOP w0.102: UV7.D3 109.15,157.09 109.15,157.69 111.05,159.59
  TOP w0.127: 111.05,159.59 111.6,160.14 115.6,160.14 119.13,156.61 v1(119.13,154.43) 119.13,149.88 119.43,149.59 121.52,149.59 122.23,148.88 122.23,147.28 122.06,147.11 v2(121.61,147.11)
  BOTTOM w0.102: UV1.A14 122.45,146.26 v2(121.61,147.11)
DQMA6: length 31.1
  IN2 w0.102: 113.81,157.29 112.97,157.29 112.87,157.19 112.87,156.89 112.77,156.79 112.57,156.79 112.47,156.89 112.47,157.19 112.37,157.29 112.16,157.29 112.06,157.19 112.06,156.89 111.96,156.79 111.76,156.79 111.65,156.89 111.65,157.19 111.55,157.29 111.35,157.29 111.25,157.19 111.25,156.89 111.15,156.79 110.94,156.79 110.84,156.89 110.84,157.19 110.74,157.29 110.47,157.29 110.34,157.16 110.34,156.91 110.24,156.8 110.04,156.8 109.94,156.91 109.94,157.16 109.81,157.29 109.07,157.29 108.95,157.16 108.95,156.99 109.07,156.86 109.51,156.86 109.63,156.74 109.63,156.57 109.51,156.46 108.71,156.46 108.58,156.33 108.58,156.13 108.71,156 v2(108.86,156) ; v2(124.5,149.05) 124.46,149.05 123.7,149.81 123.7,151.07 121.8,152.98 120.81,152.98
  IN2 w0.157: 120.81,152.98 120.34,152.98 116.62,156.7 116.33,156.7 115.34,155.7 115.16,155.7 114.89,155.97 114.89,156.15 115.89,157.15 115.89,157.33 115.63,157.59 115.45,157.59 114.68,156.82 114.45,156.82 113.98,157.29 113.81,157.29
  BOTTOM w0.102: UV8.E7 107.98,155.29 108.69,156 v2(108.86,156) ; UV1.E10 124.27,149.05 v2(124.5,149.05)
DQMA7: length 28
  BOTTOM w0.076: 122.59,151.43 122.61,151.43 122.87,151.17 123.31,151.17 123.31,151.16 123.37,151.16 123.49,151.05 123.82,151.05 123.93,151.16 124.17,151.16 124.35,150.99 124.35,150.99 124.36,150.97 124.36,150.92
  BOTTOM w0.102: 124.36,150.92 124.36,150.75 123.68,150.07 UV1.D9 ; 122.59,151.43 121.52,151.43 121.27,151.68 ; 111.29,159.14 111.08,159.14 110.28,158.33 110.28,157.03 110.98,156.32 111.33,156.32 111.45,156.2 111.45,156.04 111.33,155.92 UV8.D3
  BOTTOM w0.127: 111.29,159.14 111.84,159.7 114.6,159.7 114.73,159.57 114.73,157.72 114.85,157.59 116.09,157.59 117.85,155.82 117.85,153.96 117.98,153.83 118.98,153.83 119.11,153.71 119.11,153.45 118.98,153.33 117.98,153.33 117.85,153.2 v1(117.85,152.98) 117.95,152.89 120.32,152.89 121.27,151.93 121.27,151.68
DQMB0: length 31.3
  TOP w0.127: UV9.D3 124.37,166.97 124.37,167.78 124.23,167.92 121.27,167.92 119.84,166.48 119.84,164.4 121.31,162.93 123.59,162.93 124.24,162.27 124.24,161.74 124.33,161.66 124.85,161.66 125.04,161.47 125.04,161.24 124.91,161.11 124.39,161.11 124.26,160.98 124.26,160.73 124.39,160.6 124.91,160.6 125.04,160.47 125.04,160.22 124.91,160.09 v1(124.4,160.09) 124.27,159.97 124.27,159.71 124.4,159.59 124.91,159.59 125.04,159.46 125.04,157.5 125,157.46 125,156.03 124.82,155.85 124.37,155.85 124.19,155.67 124.19,153.73 124.45,153.46 124.89,153.46 125.38,152.97 127.22,152.97 v2(127.67,153.41)
  BOTTOM w0.102: v2(127.67,153.41) 127.45,153.41 127.16,153.7 127.16,153.77 UV1.H3
DQMB1: length 30.8
  BOTTOM w0.102: UV1.H1 126.65,156.23 ; UV10.D3 124.55,169.95 124.55,169.67 124.44,169.56 124.04,169.56 123.93,169.46 123.93,169.26 124.04,169.16 124.12,169.16 124.25,169.03 124.25,168.84 124.12,168.72 120.92,168.72
  BOTTOM w0.127: 120.92,168.72 120.79,168.72 120.29,168.22 118.47,168.22 118.34,168.09 118.34,167.78 118.47,167.65 v1(119.36,167.65) 119.74,167.65 119.88,167.51 119.88,167.23 119.76,167.1 118.49,167.1 118.36,166.98 118.36,166.72 118.49,166.6 119.76,166.6 119.88,166.47 119.88,160.27 121.68,158.47 124.41,158.47 126.06,156.83 127.01,156.83 127.15,156.69 127.15,156.39 127.06,156.3 126.72,156.3 126.65,156.23
DQMB2: length 35.1
  TOP w0.127: UV9.E7 125.34,169.94 125.34,169.36 v2(124.94,168.97)
  IN2 w0.102: 124.68,157.31 125.63,156.36 125.64,156.36 126.87,155.13 129.8,155.13 130.12,155.45 v2(130.12,155.66) ; 122.16,163.92 122.16,165.15 122.37,165.36 122.37,168.44 122.9,168.97 v2(124.94,168.97)
  IN2 w0.157: 122.16,163.92 122.27,163.81 122.27,160.95 122.11,160.79 121.17,160.79 121.01,160.64 121.01,160.32 121.17,160.16 122.28,160.16 122.41,160.04 122.41,159.66 122.28,159.53 121.16,159.53 121.01,159.38 121.01,158.72 121.45,158.28 121.95,158.28 122.08,158.41 122.08,158.68 122.21,158.81 122.58,158.81 122.71,158.68 122.71,158.41 122.84,158.28 123.71,158.28 124.68,157.31
  BOTTOM w0.102: UV1.T3 133.05,154.61 132.62,155.05 132.62,156.22 132.2,156.64 131.15,156.64 130.82,156.96 130.51,156.96 130.17,156.61 130.17,155.7 v2(130.12,155.66)
DQMB3: length 32.5
  IN1 w0.102: v2(124.94,167.17) 124.94,167.56 124.82,167.69 124.23,167.69 124.1,167.56 124.1,165.36 124.23,165.24 124.28,165.24 124.55,164.96 124.55,164.51 124.4,164.36 ; v2(133.55,153.16) 134.34,153.16 134.46,153.28 134.46,153.49 134.34,153.62 133.46,153.62 133.36,153.72 133.36,153.92 133.46,154.02 135.06,154.02 135.16,154.12 135.16,154.39 135.88,155.12 135.88,156.32 135.47,156.73 135.05,156.73 134.98,156.8
  IN1 w0.157: 134.98,156.8 134.73,157.05 134.73,157.57 133.86,158.44 126.37,158.44 125.09,159.72 125.09,160.52 124.93,160.68 124.18,160.68 124.05,160.8 124.05,161.18 124.18,161.3 124.93,161.3 125.09,161.46 125.09,163.67 124.96,163.8 124.49,163.8 124.37,163.93 124.37,164.32 124.4,164.36
  BOTTOM w0.102: UV1.T5 133.24,153.47 v2(133.55,153.16) ; v2(124.94,167.17) 125.35,166.77 UV10.E7
DQMB4: length 38.3
  IN1 w0.102: v2(153.28,169.1) 153.28,168.79 153.39,168.68 154.87,168.68 155.82,167.72
  IN1 w0.14: 140.1,157 140.1,155.62 v2(139.15,154.67)
  IN1 w0.157: 155.82,167.72 155.95,167.6 155.95,166.42 156.13,166.24 156.55,166.24 156.67,166.11 156.67,165.36 156.55,165.23 155.83,165.23 155.4,165.66 155.4,165.99 155.28,166.11 154.96,166.11 154.77,165.92 154.77,165.2 155.37,164.6 155.72,164.6 156.05,164.27 156.05,162.63 151.74,158.32 141.42,158.32 140.1,157
  BOTTOM w0.102: UV1.AE4 140.25,153.82 139.55,153.12 139.29,153.12 139,153.41 139,154.52 v2(139.15,154.67) ; UV11.E7 152.41,169.97 v2(153.28,169.1)
DQMB5: length 33.3
  BOTTOM w0.102: UV1.AF5 141.13,153.55 141.97,153.55 142.21,153.8 142.21,154.24 142.38,154.41 142.38,154.91 142.32,154.97 142.32,155.22 142.44,155.33 142.44,156.8
  BOTTOM w0.127: UV11.D3 153.1,166.91 154.55,168.35 155.96,168.35 157.65,166.66 157.65,162.91 153.62,158.89 149.38,158.89 149.26,158.76 v1(149.26,158.59) 149.26,158.32 149.13,158.19 148.88,158.19 148.75,158.32 148.75,158.76 148.62,158.89 148.37,158.89 148.24,158.76 148.24,158.32 148.11,158.19 143.83,158.19 142.44,156.8
DQMB6: length 32.3
  TOP w0.102: v2(152.7,167.17) 152.3,166.77 UV12.E7
  IN2 w0.102: v2(152.7,167.17) 152.31,166.78 152.31,164.14
  IN2 w0.157: 152.31,164.14 152.34,164.11 152.34,163.98 152.46,163.85 153.17,163.85 153.3,163.73 153.3,163.41 153.17,163.28 151.83,163.28 151.67,163.12 151.67,162.81 151.83,162.65 153.17,162.65 153.3,162.52 153.3,162.15 153.17,162.02 151.83,162.02 151.67,161.86 151.67,161.55 151.83,161.39 153.17,161.39 153.3,161.26 153.3,160.89 153.17,160.76 151.83,160.76 151.67,160.6 151.67,160.29 151.83,160.13 152.95,160.13 153.08,160 153.08,159.52 152.95,159.39 151.41,159.39 151.04,159.03 151.04,158.21 149.04,156.21 144.67,156.21 143.79,155.32 143.79,153.55 144.05,153.29 v2(144.05,152.97)
  BOTTOM w0.102: UV1.AK6 144.34,152.67 v2(144.05,152.97)
DQMB7: length 33
  TOP w0.102: UV12.D3 153.93,169.14 153.93,168.6 154.15,168.38 155.81,168.38 156.48,167.71 ; v2(146.9,153.39) 146.68,153.6 146.68,154.62
  TOP w0.127: 156.48,167.71 157.59,166.6 157.59,162.28 153.89,158.58 148.89,158.58 148.77,158.46 148.77,157.63 148.64,157.5 148.39,157.5 148.26,157.63 148.26,158.46 148.13,158.58 147.88,158.58 147.75,158.46 147.75,156.55 147.62,156.42 146.79,156.42 146.68,156.31 146.68,154.62
  BOTTOM w0.102: UV1.AK5 144.3,153.47 144.77,152.99 145.81,152.99 146.31,153.49 146.81,153.49 146.9,153.4 v2(146.9,153.39)
DRAM_RST#: length 155.5
  TOP w0.102: UV9.T2 134.6,165.97 135.32,166.68 136.01,166.68 136.43,167.1 136.43,167.36 136.62,167.55 136.96,167.55 137.35,167.93 137.35,168.33 v2(137.03,168.65) ; v2(109.3,140.88) 109.53,140.64 110.21,140.64 110.55,140.31 v1(111.27,140.31) 111.75,139.83 111.75,138.32 UV5.T2 ; 142.93,172.66 142.93,171.36 143.5,170.79 UV12.T2 143.32,170.58 142.09,170.58 140.66,169.15 v2(140.66,168.98) ; v2(148.2,148.41) 148,148.21 RV53.1 ; UV7.T2 107.18,145.76 108.62,144.32 v2(108.62,143.39)
  TOP w0.203: 142.93,172.66 142.93,173.22 v2(142.93,173.23)
  IN1 w0.127: v2(140.66,168.98) 140.61,168.93 137.32,168.93 v2(137.03,168.65) ; v2(108.62,143.39) 109.21,142.79 109.21,141.91 109.3,141.83 v2(109.3,140.88)
  IN2 w0.249: v2(148.2,148.41) 148.7,148.9 148.7,150.46 149.83,151.59 151.2,151.59 158.52,158.91 158.52,169.99 154.9,173.61 149.94,173.61 148.7,174.84 145.07,174.84 143.46,173.23 v2(142.93,173.23) ; v2(134.81,172.56) 134.51,172.86 134.51,174.5 134.04,174.97 127.19,174.97 125.46,173.24 122.26,173.24 118.07,169.05 118.07,162.49 116.42,160.84 108.24,160.84 108.07,160.68 104.59,160.68 104.11,160.2 104.11,152.25 103.2,151.34 103.2,148.61 103.95,147.86 105,147.86 105.33,147.53 105.33,146.11 v2(105.61,145.83)
  BOTTOM w0.102: v2(109.3,140.88) 109.2,140.88 107.23,138.9 UV6.T2 ; UV8.T2 110.97,145.3 110.97,144.11 110.61,143.76 110.23,143.76 109.43,142.96 109.04,142.96 v2(108.62,143.39) 107.44,144.57 107.44,145.26 106.87,145.83 v2(105.61,145.83) ; UV11.T2 143.32,165.97 142.5,166.79 141.6,166.79 140.99,167.39 140.99,168.64 v2(140.66,168.98) ; v2(137.03,168.65) 137.03,168.75 135.53,170.25 134.92,170.25 134.4,170.77 UV10.T2 134.17,171 134.81,171.65 v2(134.81,172.56)
DRAM_RST#_R: length 4.6
  TOP w0.102: RV54.2 143.02,146.61 v1(143.33,146.3) ; RV54.2 143.02,148.14 RV57.2 ; RV54.2 142.54,147.3 v2(142.32,147.09)
  BOTTOM w0.102: UV1.AH11 142.32,148.14 v2(142.32,147.09)
DRON: length 43.8
  TOP w0.102: v1(23.79,117.17) 24.31,117.68 v2(24.7,117.68)
  TOP w0.254: PR935.2 v2(25.73,92.41)
  IN1 w0.254: v2(25.73,92.41) 24.6,93.54 18.51,93.54 16.41,95.63 16.41,112.37 17.55,113.51 19.16,113.51 19.78,112.88 23.43,112.88 23.95,113.41 23.95,117.01 24.62,117.68 v2(24.7,117.68)
  BOTTOM w0.203: PU901.21 24.29,118.09 24.7,117.68 24.7,117.68 v2(24.7,117.68)
DS3_EN: length 11.4
  TOP w0.102: v1(155.65,81.61) 155.37,81.33 R38.2 R34.2 154.36,79.37 R781.1 153.05,79.37 153.02,79.33 Q124.2 150.67,80.45 150.67,81.84 150.98,82.15 151.43,82.15 151.8,82.52 Q120.2
DSWODVREN: length 5.7
  TOP w0.089: 137.96,92.17 137.01,91.21 135.14,91.21 135.01,91.08 134.57,91.08 134.4,90.91 U4.C8
  TOP w0.102: R143.1 139.46,92.49 R134.2 138.28,92.49 137.96,92.17
EC_FAN_PWM: length 167.9
  TOP w0.102: v2(174.53,85.76) 175.01,86.23 175.24,86.23 175.57,86.56 U31.26
  IN1 w0.127: v2(98.53,160.51) 98.12,160.1 98.12,150.58 98.15,150.55 98.15,146.86 98.86,146.15 98.86,123.24 98.07,122.46 98.07,114.79 98.74,114.13 100.03,114.13 102.25,116.35 111.76,116.35 112.46,115.64 122.06,115.64 123.3,114.4 129.12,114.4 130.58,115.86 141.12,115.86 141.32,115.66 151.18,115.66 151.85,114.98 162.32,114.98 166.84,119.5 171.69,119.5 v2(172.65,118.55)
  BOTTOM w0.102: v2(174.53,85.76) 174.68,85.91 174.68,87.37 176.19,88.88 176.19,92.45 177.06,93.32 177.06,112.65 172.65,117.05 v2(172.65,118.55) ; JFAN1.3 96.88,158.67 97.14,158.67 97.71,159.24 97.71,159.69 v2(98.53,160.51)
EC_LID_OUT#: length 93.1
  TOP w0.089: U4.AB11 126.45,89.81 v2(126.79,90.15)
  TOP w0.102: v2(158.95,70.65) 159.02,70.65 161.59,73.21 163.43,73.21 163.99,73.77 U31.101
  IN1 w0.089: v2(126.79,90.15) 126.2,90.74 126.2,92.94 124.51,94.64 124.51,94.79
  IN1 w0.127: 124.51,94.79 124.51,96.16 124.91,96.57 124.91,99.77 126.78,101.64 v2(126.78,101.74)
  IN2 w0.127: v2(159.72,99.73) 155.11,104.34 149.96,104.34 147.92,106.39 128.85,106.39 v2(126.33,103.87)
  BOTTOM w0.102: v2(126.33,103.87) 126.78,103.43 v2(126.78,101.74) 127.25,101.27 R253.2 ; v2(158.95,70.65) 159.71,71.41 159.71,80.87 158.08,82.5 158.08,83.94 159.24,85.1 159.24,86.7 158.64,87.3 158.64,88.41 v1(159.39,89.16) 159.39,99.4 v2(159.72,99.73)
EC_MUTE#: length 49.2
  TOP w0.102: UA1.39 157.85,46 158.72,45.13 v2(159.5,45.13) ; U31.83 162.63,81.76 v2(163.41,80.97)
  BOTTOM w0.102: v2(159.5,45.13) 160.57,45.13 163.91,48.47 163.91,57.62 159.96,61.57 159.96,70.04 160.57,70.65 160.57,79.91 v1(161.36,80.7) 162.05,81.39 162.56,81.39 162.99,80.97 v2(163.41,80.97) 163.41,80.98 R593.1
EC_ON: length 164
  TOP w0.102: v2(168.15,76.29) 168.39,76.04 U31.112
  TOP w0.254: PR407.2 104.54,10.83 v3(104.54,13.56) v2(104.54,15.03)
  IN1 w0.127: v2(161.44,75.05) 166.92,75.05 v2(168.15,76.29)
  IN2 w0.127: v2(179.81,13.7) 179.13,14.39 121.66,14.39 119.74,16.3 105.81,16.3 v2(104.54,15.03)
  BOTTOM w0.102: v2(161.44,75.05) 161.44,74.03 165.57,69.89 165.57,57.9 168.12,55.36 174.21,55.36 176.74,52.83 176.74,45.92 181.87,40.79 181.87,15.75 179.82,13.7 v2(179.81,13.7)
EC_RSMRST#: length 84.1
  TOP w0.089: U4.J2 131.58,93.8 131.58,94.28 132.39,95.09 132.39,96.07 132.98,96.66 133.43,96.66 133.75,96.97 133.75,97.07
  TOP w0.102: U31.100 163.59,76.67 v2(163.99,77.07) ; 133.75,97.07 133.75,97.6 R139.2 133.5,98.75 R312.1 133.51,98.78 132.81,99.48 132.81,99.81 132.43,100.19 132.43,101.33 v3(132.93,101.83) 133.4,102.3 v2(133.54,102.3)
  IN1 w0.127: v2(133.54,102.3) 134.23,102.99 134.23,103.03 136.81,105.61 150.24,105.61 154.16,109.53 163.84,109.53 v2(164.38,110.08)
  BOTTOM w0.102: v2(164.38,110.08) 164.38,96.83 163.93,96.37 163.93,93.96 163.96,93.93 163.96,90.99 166.42,88.54 166.42,85.36 167.22,84.57 167.22,79.73 166.48,78.99 166.48,78.02 165.53,77.07 v2(163.99,77.07)
EC_RST#: length 5.5
  TOP w0.102: R590.2 172.27,92.72 C661.2 ; C661.2 173.4,92.51 173.4,91.93 173.19,91.72 U31.37 ; C661.2 173.48,92.72 174.31,93.56 174.31,94.19 174.26,94.24 v3(174.26,94.36)
EC_RX: length 167.6
  TOP w0.102: R506.1 198.13,163.63 v2(197.17,162.67) ; v2(177.35,92.12) 177.26,92.03 177.26,90.64 176.04,89.42 175.52,89.42 175.36,89.26 175.36,88.69 175.49,88.56 U31.31 ; JP3.3 v2(183.85,34.55)
  IN2 w0.127: v2(178.3,101.74) 178.47,101.9 192.52,101.9 193.9,103.28 193.9,109.58 201.82,117.51 201.82,136.02 204.95,139.15 204.95,141.51 206.43,143 206.43,145.81 204.75,147.49 204.75,157.79 199.44,163.1 197.58,163.1 197.17,162.69 v2(197.17,162.67)
  BOTTOM w0.102: v2(178.3,101.74) 178.29,101.72 v1(178.29,98.03) 178.29,93.12 177.35,92.18 v2(177.35,92.12) 177.24,92.01 177.24,90.94 177.08,90.78 177.08,87.66 176.79,87.37 176.79,84.05 177.03,83.81 177.03,68.88 176.79,68.63 176.79,55.04 178.38,53.46 178.38,48.2 183.36,43.22 183.36,34.83 183.64,34.55 v2(183.85,34.55)
