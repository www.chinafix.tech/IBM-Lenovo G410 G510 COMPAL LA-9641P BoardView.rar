# Allegro board IBM-Lenovo G410 G510 COMPAL LA-9641P BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MDB25: length 33.1
  IN1 w0.102: v2(127.34,171.17) 126.94,170.77 124.67,170.77
  IN1 w0.157: v2(133.35,152.19) 132.97,152.58 129.41,152.58 127.67,154.31 126.41,154.31 124.92,155.8 124.65,155.8 120.71,159.74 120.71,166.81 124.67,170.77
  BOTTOM w0.102: UV10.G2 126.97,170.8 v2(127.34,171.17) ; UV1.V6 134.27,152.67 133.86,152.27 133.43,152.27 v2(133.35,152.19)
MDB26: length 31.9
  IN1 w0.102: v2(133.55,156.82) 133.37,156.64 131.18,156.64 130.82,156.99 129.97,156.99
  IN1 w0.157: v2(124.93,169.55) 123.2,167.82 123.2,166.79 123.05,166.64 122.64,166.64 122.51,166.51 122.51,166.13 122.64,166.01 122.89,166.01 123.02,165.88 123.02,165.33 122.89,165.2 122.4,165.2 122.1,164.9 122.1,160.48 125.58,156.99 127.31,156.99 127.47,156.84 127.47,156.21 127.59,156.08 127.97,156.08 128.1,156.21 128.1,156.84 128.25,156.99 128.75,156.99 128.97,156.77 128.97,155.37 129.1,155.24 129.47,155.24 129.6,155.37 129.6,156.9 129.69,156.99 129.97,156.99
  BOTTOM w0.102: UV1.V1 134.65,155.71 v2(133.55,156.82) ; v2(124.93,169.55) 124.95,169.55 UV10.E3
MDB27: length 32.4
  IN1 w0.102: v2(128.17,169.62) 127.83,169.96 124.8,169.96 122.29,167.45
  IN1 w0.157: 122.29,167.45 122.06,167.22 122.06,165.42 121.63,164.99 121.63,160.29 125.42,156.5 126.66,156.5 128.38,154.78 132.12,154.78 v2(133.57,156.23)
  BOTTOM w0.102: UV10.H3 127.82,169.97 v2(128.17,169.62) ; UV1.V3 134.45,154.48 134.45,154.82 134.33,154.93 134.33,155.71 133.82,156.23 v2(133.57,156.23)
MDB28: length 33.1
  IN1 w0.102: v2(127.34,166.37) 127.62,166.37 127.81,166.18 127.81,165.28 127.69,165.16 127.5,165.16 127.38,165.03 127.38,164.72 127.5,164.6 127.76,164.6 127.94,164.41 128.46,164.41 128.59,164.54 128.59,165.07 128.71,165.19 128.94,165.19 129.06,165.07 129.06,164.25 128.75,163.93 128.75,163.92
  IN1 w0.157: v2(135.8,152.94) 135.8,152.93 135.05,152.93 134.92,153.06 134.92,153.54 135.05,153.67 135.33,153.67 135.44,153.78 135.44,153.96 136.16,154.68 136.16,158.71 135.01,159.85 133.6,159.85 133.47,159.98 133.47,160.46 133.34,160.59 132.99,160.59 132.86,160.46 132.86,159.98 132.74,159.85 132.38,159.85 132.22,160.01 132.22,160.32 132.06,160.47 131.96,160.47 131.84,160.6 131.84,160.97 131.96,161.1 132.06,161.1 132.19,161.22 132.19,161.56 132.06,161.69 130.96,161.69 130.83,161.56 130.83,160.49 130.7,160.36 130.08,160.36 129.97,160.47 129.97,162.85 129.84,162.97 129.38,162.97 129.26,162.85 129.26,161.7 129.13,161.57 128.7,161.57 128.57,161.7 128.57,162.98 128.75,163.15 128.75,163.92
  BOTTOM w0.102: UV1.Y6 136.07,152.67 v2(135.8,152.94) ; UV10.H8 127.77,165.95 v2(127.34,166.37)
MDB29: length 32
  IN1 w0.102: 126.32,163.95 126.21,164.07 125.47,164.07 125.34,164.2 125.34,165.06 125.22,165.19 124.68,165.19 124.56,165.31 124.56,165.86 124.68,165.99 126.37,165.99 126.54,165.81 v2(126.54,165.58)
  IN1 w0.157: 126.32,163.95 126.32,163.01 126.19,162.88 125.68,162.88 125.55,162.76 125.55,162.47 125.71,162.32 126.46,162.32 126.59,162.19 126.59,161.81 126.46,161.69 125.71,161.69 125.55,161.53 125.55,161.24 125.72,161.06 127.52,161.06 127.64,160.93 127.64,159.6 127.52,159.47 127.08,159.47 126.89,159.66 126.89,160.31 126.78,160.43 125.97,160.43 125.84,160.3 125.84,159.62 126.56,158.9 134.46,158.9 135.19,158.16 135.19,157.33 135.35,157.17 v2(135.66,157.17)
  BOTTOM w0.102: v2(135.66,157.17) 136.26,156.56 136.26,155.08 UV1.Y1 ; v2(126.54,165.58) 126.17,165.96 UV10.F8
MDB30: length 32.3
  IN1 w0.102: v2(125.77,166.37) 125.43,166.37 125.36,166.45 125.36,166.81 125.43,166.89 126.8,166.89 126.93,166.76 126.93,166.27 127,166.2 127,165.31 126.88,165.19 126.31,165.19 126.18,165.06 126.18,164.4 126.31,164.28 127.75,164.28 127.88,164.15 127.88,163.92
  IN1 w0.157: 127.88,163.92 127.88,163.76 127.83,163.71 126.91,163.71 126.78,163.59 126.78,162.96 126.91,162.83 127.99,162.83 128.11,162.71 128.11,162.29 127.99,162.16 127.24,162.16 127.11,162.04 127.11,161.65 127.24,161.52 127.99,161.52 128.11,161.39 128.11,161.12 128.1,161.11 128.1,159.53 128.27,159.36 128.63,159.36 128.76,159.49 128.76,160.98 128.89,161.11 129.31,161.11 129.44,160.98 129.44,159.49 129.57,159.36 134.65,159.36 135.66,158.35 v2(135.66,157.78)
  BOTTOM w0.102: UV1.Y3 136.55,154.56 136.55,154.87 136.58,154.91 136.58,155.29 136.47,155.4 136.47,156.69 136.37,156.79 ; v2(125.77,166.37) 126.16,166.77 UV10.F7
  BOTTOM w0.127: v2(135.66,157.78) 135.69,157.78 136.25,157.22 136.25,156.91 136.37,156.79
MDB31: length 32.7
  IN1 w0.102: 129.64,163.92 129.32,164.23 129.32,166.18 129.2,166.3 129.03,166.3 128.91,166.19 128.8,166.19 128.66,166.33 128.66,166.47 128.76,166.58 128.76,166.73 128.64,166.86 128.63,166.86 128.2,167.29 128.02,167.29 127.71,166.98 127.71,166.8 v2(128.14,166.37)
  IN1 w0.157: 129.64,163.92 129.64,163.88 130.43,163.09 130.43,162.57 130.57,162.43 131.09,162.43 131.37,162.15 133.37,162.15 133.97,161.55 134.38,161.14 134.38,161.05 134.11,160.78 134.11,160.6 134.39,160.31 134.57,160.31 134.83,160.58 134.94,160.58 135.34,160.18 135.56,160.18 135.63,160.25 135.86,160.25 136.08,160.03 136.08,159.8 136.01,159.73 136.01,159.51 136.25,159.27 136.55,159.27 136.79,159.51 136.97,159.51 137.25,159.24 137.25,159.06 136.62,158.43 136.62,154.44 136.75,154.31 137.54,154.31 137.66,154.44 137.66,154.92 137.79,155.05 138.34,155.05 138.46,154.92 138.46,154.33 138.59,154.2 139,154.2 139.12,154.07 139.12,153.68 139,153.55 137.56,153.55 137.38,153.38 137.38,152.71 137.27,152.6 136.44,152.6 136.23,152.82 136.23,153.58 v2(135.95,153.86)
  BOTTOM w0.102: v2(128.14,166.37) 127.77,166.75 UV10.H7 ; UV1.Y5 136.25,153.56 v2(135.95,153.86)
MDB32: length 38.4
  IN1 w0.102: v2(151.04,167.75) 150.67,167.38 150.67,167.03 150.92,166.78 151.3,166.78 151.52,166.56 151.52,164.56 151.75,164.34 151.75,164.14
  IN1 w0.157: v2(137.09,157.58) 137.09,157.59 138.17,158.67 138.17,160.58 138.42,160.82 146.29,160.82 146.5,161.03 146.5,161.55 146.65,161.71 146.97,161.71 147.13,161.55 147.13,161.03 147.25,160.9 147.68,160.9 147.83,161.06 147.83,162.6 147.99,162.76 148.31,162.76 148.46,162.6 148.46,161.06 148.62,160.9 149.34,160.9 149.46,161.03 149.46,162.02 149.59,162.15 150.39,162.15 150.52,162.28 150.52,162.71 150.39,162.84 149.59,162.84 149.46,162.96 149.46,164.2 149.59,164.32 150.18,164.32 150.31,164.2 150.31,163.69 150.44,163.56 151.59,163.56 151.75,163.72 151.75,164.14
  BOTTOM w0.102: v2(151.04,167.75) 150.85,167.56 150.02,167.56 149.85,167.4 149.85,166.82 UV11.H3 ; UV1.AA4 136.75,154.18 136.75,154.78 136.79,154.82 136.79,155.37 136.67,155.49 136.67,156.91
  BOTTOM w0.127: v2(137.09,157.58) 136.67,157.16 136.67,156.91
MDB33: length 39
  IN1 w0.102: v2(152.13,167.71) 152.17,167.75 152.88,167.75 153.12,167.5 153.12,164.59 152.96,164.43 152.96,164.14
  IN1 w0.157: 152.96,164.14 152.96,163.62 152.3,162.96 152.3,162.34 152.78,161.86 152.78,161.64 152.56,161.41 152.34,161.41 151.84,161.91 151.66,161.91 151.4,161.66 151.4,161.48 151.88,161 151.88,160.78 151.65,160.56 151.43,160.56 150.98,161.01 150.75,161.01 150.53,160.79 150.53,160.57 150.68,160.42 150.68,160.24 150.41,159.98 150.23,159.98 150.09,160.12 149.95,160.12 149.72,159.9 139.23,159.9 139.1,159.76 139.1,159.48 139.26,159.32 139.66,159.32 139.8,159.19 139.8,158.93 139.56,158.69 139.26,158.69 139.1,158.54 139.1,158.29 138.59,157.78 138.59,157.44 138.46,157.31 137.85,157.31 137.73,157.18 137.73,156.73 137.85,156.6 138.54,156.6 138.67,156.47 138.67,155.52 138.54,155.39 137.74,155.39 137.54,155.6 137.54,155.98 137.21,156.31 v2(137.08,156.31)
  BOTTOM w0.102: UV11.E3 152.3,167.54 v2(152.13,167.71) ; v2(137.08,156.31) 137.6,155.79 137.6,155.54 137.34,155.29 137.34,154.86 137.46,154.75 137.46,153.27 UV1.AB6
MDB34: length 37.9
  IN1 w0.157: v2(137.1,158.24) 137.1,158.25 137.71,158.87 137.71,160.98 138.02,161.29 145.01,161.29 147.32,163.6 148.37,163.6 148.6,163.83 148.6,164.63 149.09,165.12 150.06,165.12 150.33,165.39 v2(150.33,165.56)
  BOTTOM w0.102: 138.93,157.31 138.01,156.39 138.01,155.22 UV1.AB1 ; UV11.G2 150.7,165.94 v2(150.33,165.56)
  BOTTOM w0.127: v2(137.1,158.24) 137.7,158.84 137.7,161.17 137.37,161.5 137.37,163.86 137.5,163.99 138.96,163.99 139.09,163.86 139.09,163.59 138.96,163.47 138.08,163.47 137.95,163.34 137.95,163.09 138.08,162.96 138.94,162.96 139.05,162.85 139.05,162.2 139.35,161.89 v1(139.35,160.82) 139.35,157.73 138.93,157.31
MDB35: length 38.2
  IN1 w0.102: v2(151.9,165.59) 152.32,165.17 152.32,164.14
  IN1 w0.157: v2(137.08,156.93) 138.64,158.48 138.64,160.22 138.78,160.36 149.45,160.36 151.09,162 151.09,162.4 152.32,163.64 152.32,164.14
  BOTTOM w0.102: 138.17,157.31 138.17,156.98 137.8,156.61 137.8,155.46 137.55,155.2 137.55,154.95 137.85,154.64 UV1.AB3 ; v2(151.9,165.59) 151.52,165.97 UV11.F2
  BOTTOM w0.127: v2(137.08,156.93) 137.57,157.42 137.57,158.24 138.03,158.7 138.03,161.56 138.16,161.68 138.38,161.68 138.58,161.88 138.89,161.88 139.02,161.75 139.02,161.19 138.89,161.07 138.7,161.07 138.58,160.94 138.58,160.69 138.7,160.56 138.89,160.56 139.02,160.43 139.02,160.18 138.89,160.05 138.74,160.05 138.62,159.92 138.62,159.67 138.74,159.54 138.89,159.54 139.02,159.42 139.02,159.14 138.89,159.02 138.78,159.02 v1(138.65,158.89) 138.65,158.63 138.78,158.51 138.89,158.51 139.02,158.38 139.02,157.96 138.85,157.79 138.3,157.79 138.17,157.66 138.17,157.31
MDB36: length 38.9
  IN1 w0.102: 155.6,170.51 154.71,170.51 153.67,171.55 150.63,171.55 v2(150.24,171.16)
  IN1 w0.14: v2(140.07,153.03) 140.21,153.03 143.49,156.3 145.64,156.3
  IN1 w0.157: 145.64,156.3 152.59,156.3 158.68,162.4 158.68,167.42 155.6,170.51
  BOTTOM w0.102: v2(140.07,153.03) 139.72,152.67 UV1.AD6 ; UV11.H8 149.9,170.81 150.24,171.14 v2(150.24,171.16)
MDB37: length 37.7
  IN1 w0.102: v2(152.64,169.1) 153.02,169.49 154.03,169.49 154.52,169 155.09,169 156.06,168.03
  IN1 w0.14: 156.1,167.98 156.06,168.03
  IN1 w0.157: v2(140.52,156.63) 140.52,156.76 141.6,157.84 151.92,157.84 156.51,162.44 156.51,164.54 157.3,165.33 157.3,166.79 156.1,167.98
  BOTTOM w0.102: 139.52,157.31 139.52,155.14 UV1.AD1 ; UV11.F7 151.78,169.69 152.03,169.69 152.62,169.1 v2(152.64,169.1)
  BOTTOM w0.127: v2(140.52,156.63) v1(140.52,158.9) 140.39,159.03 139.81,159.03 139.68,158.9 139.68,157.59 139.52,157.43 139.52,157.31
MDB38: length 38.2
  IN1 w0.102: v2(150.29,170.37) 150.8,169.85 154.95,169.85 155.26,169.54
  IN1 w0.157: v2(140.53,155.67) 141.01,156.15 141.01,156.52 141.87,157.38 152.11,157.38 156.98,162.25 156.98,164.35 157.76,165.13 157.76,167.04 155.26,169.54
  BOTTOM w0.102: UV1.AD3 139.84,154.66 139.84,155.32 139.72,155.45 139.72,156.6 139.84,156.72 140.01,156.72 140.13,156.6 140.13,155.83 140.28,155.67 v2(140.53,155.67) ; v2(150.29,170.37) 150.29,170.35 UV11.H7
MDB39: length 38.5
  IN1 w0.102: 155.4,170.06 153.62,170.06 152.92,170.76 151.58,170.76 v2(151.18,171.17)
  IN1 w0.157: 155.4,170.06 158.22,167.23 158.22,164.49 158.07,164.33 157.64,164.33 157.49,164.17 157.49,163.87 157.64,163.71 157.97,163.71 158.1,163.58 158.1,163.21 157.97,163.08 157.64,163.08 157.49,162.92 157.49,161.86 152.45,156.82 142.12,156.82 141.37,156.08 141.37,154.54 140.71,153.88 v2(139.75,153.88)
  BOTTOM w0.102: v2(139.75,153.88) 139.45,153.58 UV1.AD5 ; v2(151.18,171.17) 151.18,171.15 151.19,171.15 151.5,170.84 UV11.F8
MDB40: length 32.6
  BOTTOM w0.102: UV1.AF1 141.05,155.23 140.95,155.33 140.95,156.28 141.26,156.59 141.26,157.31
  BOTTOM w0.127: UV11.A2 155.71,166.17 156.2,166.17 156.43,165.94 156.43,165.33 156.32,165.22 156.32,163.59 155.84,163.11 152.83,163.11 152.7,162.98 152.7,162.73 152.83,162.6 154.86,162.6 154.99,162.47 154.99,162.22 154.86,162.09 152.8,162.09 152.67,161.97 152.67,161.71 152.8,161.59 v1(153.22,161.59) 153.77,161.59 153.89,161.46 153.89,161.16 153.77,161.04 152.78,161.04 152.65,160.91 152.65,160.35 152.53,160.22 152.27,160.22 152.15,160.35 152.15,160.91 152.02,161.04 144.81,161.04 141.26,157.48 141.26,157.31
MDB41: length 32.8
  BOTTOM w0.102: 141.89,157.18 141.89,156.46 141.36,155.93 141.36,155.53 141.56,155.33 141.56,154.78 UV1.AF3
  BOTTOM w0.127: 141.89,157.18 143.57,158.86 144.2,158.86 144.33,158.99 144.33,159.62 144.46,159.75 144.72,159.75 144.85,159.62 144.85,159 144.98,158.87 145.23,158.87 145.36,159 v1(145.36,159.78) 145.36,160.25 145.49,160.38 145.8,160.38 145.93,160.25 145.93,159.68 146.06,159.55 146.36,159.55 146.48,159.68 146.48,160.23 146.61,160.36 146.86,160.36 146.99,160.23 146.99,159.68 147.12,159.55 153.35,159.55 156.98,163.19 156.98,166.39 155.68,167.69 154.72,167.69 153.9,166.87 UV11.C3
MDB42: length 33.5
  BOTTOM w0.102: UV1.AF6 140.75,153.18 140.75,154.4 141,154.66 141.12,154.66 141.36,154.9 141.36,155.25 141.15,155.45 141.15,156.09 141.59,156.53 141.59,157.31
  BOTTOM w0.127: UV11.A3 156.12,166.77 156.65,166.23 156.65,163.33 153.22,159.89 151.76,159.89 151.64,160.02 151.64,160.55 151.51,160.68 151.26,160.68 151.13,160.55 151.13,160.02 151,159.89 150.7,159.89 150.57,160.02 150.57,160.54 150.44,160.66 150.19,160.66 150.06,160.54 v1(150.06,160.28) 150.06,160.02 149.94,159.89 149.68,159.89 149.55,160.02 149.55,160.58 149.43,160.71 149.17,160.71 149.05,160.58 149.05,160.02 148.92,159.89 148.67,159.89 148.54,160.02 148.54,160.58 148.41,160.71 148.16,160.71 148.03,160.58 148.03,160.02 147.9,159.89 147.65,159.89 147.52,160.02 147.52,160.58 147.4,160.71 144.95,160.71 141.59,157.35 141.59,157.31
MDB43: length 33
  BOTTOM w0.102: 142.11,156.93 142.11,156.02 142.23,155.89 142.23,155.42 142.12,155.3 142.12,154.88 142.18,154.83 142.18,154.52 141.85,154.2 UV1.AG4
  BOTTOM w0.127: 142.11,156.93 143.71,158.53 145.66,158.53 145.78,158.66 145.78,159.09 145.91,159.22 146.16,159.22 146.29,159.09 146.29,158.66 146.42,158.53 146.67,158.53 146.8,158.66 146.8,159.09 146.93,159.22 147.18,159.22 147.31,159.09 v1(147.31,158.94) 147.31,158.66 147.43,158.53 147.69,158.53 147.81,158.66 147.81,159.09 147.94,159.22 153.48,159.22 157.31,163.05 157.31,166.52 155.87,167.97 154.49,167.97 153.5,166.98 153.5,166.37 UV11.C2
MDB44: length 33.1
  BOTTOM w0.102: UV1.AH5 142.65,153.79 143.05,154.19 143.05,154.7 143.18,154.83 143.18,155.97 143.86,156.65
  BOTTOM w0.127: 143.86,156.65 143.98,156.77 145.3,156.77 145.6,157.07 153.37,157.07 158.75,162.46 158.75,167.19 v1(158.59,167.35) 156.43,169.5 155.4,169.5 155.11,169.8 155.11,170.18 154.91,170.38 153.52,170.38 UV11.D7
MDB45: length 33.1
  BOTTOM w0.102: 143.94,156.3 143.94,155.5 143.74,155.3 143.74,154.86 143.81,154.8 143.81,154.54 143.59,154.32 143.33,154.32 143.28,154.26 143.28,154.13 143.03,153.89 143.03,153.31 142.87,153.15 142.51,153.15 142.39,153.02 142.39,152.57 142.51,152.45 142.73,152.45 142.85,152.57 UV1.AH6
  BOTTOM w0.127: UV11.A7 155.68,170.14 156.57,170.14 159.11,167.59 v1(159.11,162.82) 159.11,162.35 153.51,156.74 145.74,156.74 145.46,156.46 144.1,156.46 143.94,156.3
MDB46: length 32.5
  BOTTOM w0.102: UV1.AJ4 143.45,153.74 143.58,153.61 143.76,153.61 143.89,153.74 143.89,154.33 144.01,154.46 144.01,154.88 143.95,154.95 143.95,155.22 144.14,155.41 144.14,155.93 144.36,156.14 145.64,156.14
  BOTTOM w0.127: 145.64,156.14 145.91,156.41 153.64,156.41 159.46,162.23 v1(159.46,165.15) 159.46,167.73 156.82,170.37 155.31,170.37 154.91,170.77 UV11.B8
MDB47: length 32.1
  BOTTOM w0.102: 145.7,155.77 144.25,154.33 UV1.AK3
  BOTTOM w0.127: 145.7,155.77 146.01,156.08 153.83,156.08 v1(154.55,156.8) 159.81,162.06 159.81,167.85 156.38,171.28 155.85,171.28 155.75,171.18 154.32,171.18 UV11.C8
MDB48: length 33.5
  TOP w0.102: v2(150.27,167.17) 149.9,166.81 UV12.H7
  IN2 w0.102: v2(150.27,167.17) 149.92,166.83 149.92,164.41 150.19,164.14 ; 143.52,157.31 143.52,157.03 142.7,156.22 142.7,152.87 142.44,152.6 142.44,150.31 142.32,150.19 142.14,150.19 142.02,150.31 142.02,151.07 141.89,151.2 v2(141.62,151.2)
  IN2 w0.157: 150.19,164.14 150.26,164.07 150.26,161.97 150.02,161.73 146.65,161.73 146.53,161.6 146.53,161.24 146.65,161.11 150.13,161.11 150.26,160.98 150.26,160.61 150.13,160.48 144.8,160.48 143.52,159.2 143.52,157.31
  BOTTOM w0.102: v2(141.62,151.2) 141.5,151.07 UV1.AF8
MDB49: length 34
  TOP w0.102: UV12.H8 149.9,165.94 v2(149.53,165.56)
  IN2 w0.102: v2(141.6,150.49) 141.24,150.85 141.24,152.09 141.43,152.28 141.69,152.28
  IN2 w0.157: v2(149.53,165.56) 149.57,165.56 149.69,165.43 149.69,164.28 149.58,164.17 149.07,164.17 148.96,164.28 148.96,166.99 148.84,167.12 148.44,167.12 148.31,166.99 148.31,164.29 148.17,164.15 147.26,164.15 147.09,163.98 146.8,163.98 146.67,163.85 146.67,163.41 146.8,163.28 149.33,163.28 149.46,163.15 149.46,162.8 149.32,162.66 146.2,162.66 146.02,162.48 146.02,161.66 145.31,160.94 144.61,160.94 143.06,159.39 143.06,156.97 142.44,156.35 142.44,155.29 142.28,155.13 141.93,155.13 141.8,155.01 141.8,154.63 141.93,154.5 142.15,154.5 142.27,154.38 142.27,152.87 141.69,152.28
  BOTTOM w0.102: v2(141.6,150.49) 141.38,150.27 UV1.AF9
MDB50: length 33.4
  TOP w0.102: v2(151.9,166.39) 151.52,166.77 UV12.F7
  IN2 w0.102: v2(142.85,150.86) 143.4,151.41 143.4,152.35 143.12,152.63 143.12,155.91 143.46,156.25 143.95,156.25 144.93,157.22 144.93,157.31 ; 151.66,164.14 151.66,164.27 151.51,164.42 151.51,165.99 v2(151.9,166.39)
  IN2 w0.157: 144.93,157.31 144.93,158.2 145,158.28 145.42,158.28 145.58,158.12 145.58,156.83 145.73,156.68 146.05,156.68 146.21,156.83 146.21,158.12 146.36,158.28 146.68,158.28 146.84,158.12 146.84,156.83 146.99,156.68 147.31,156.68 147.47,156.83 147.47,158.12 147.62,158.28 147.94,158.28 148.1,158.12 148.1,156.83 148.25,156.68 148.57,156.68 148.73,156.83 148.73,158.12 148.88,158.28 149.25,158.28 149.37,158.15 149.37,157.93 149.5,157.81 149.98,157.81 150.11,157.93 150.11,158.21 150.58,158.68 150.58,159.22 151.19,159.83 151.19,163.38 151.66,163.85 151.66,164.14
  BOTTOM w0.102: v2(142.85,150.86) 142.63,151.07 UV1.AG8
MDB51: length 33.2
  TOP w0.102: UV12.F8 151.5,166.28 151.42,166.36 v2(151.13,166.36)
  IN2 w0.102: 150.72,164.14 150.72,165.96 v2(151.13,166.36) ; v2(142.98,152.16) 142.92,152.22 142.92,156.14 143.98,157.21 143.98,157.31
  IN2 w0.157: 143.98,157.31 143.98,157.43 144.11,157.55 144.24,157.55 144.37,157.68 144.37,158 144.24,158.12 144.11,158.12 143.98,158.25 143.98,158.58 144.14,158.74 149.84,158.74 149.97,158.87 149.97,159.24 149.84,159.37 144.99,159.37 144.87,159.5 144.87,159.89 144.99,160.02 150.33,160.02 150.72,160.41 150.72,164.14
  BOTTOM w0.102: v2(142.98,152.16) 142.54,152.16 UV1.AG7
MDB52: length 33.3
  TOP w0.102: UV12.G2 150.72,170.77 v2(151.13,170.36)
  IN2 w0.102: 156.61,164.14 156.61,167.06 152.92,170.76 151.52,170.76 v2(151.13,170.36) ; v2(144.04,149.91) 145.21,151.07 145.21,151.57 145.5,151.86 146.82,151.86 147.44,152.49 150.53,152.49 151.25,153.21
  IN2 w0.157: 151.25,153.21 156.61,158.56 156.61,164.14
  BOTTOM w0.102: v2(144.04,149.91) 144.4,150.27 UV1.AK9
MDB53: length 32.2
  TOP w0.102: UV12.H3 149.95,169.97 v2(150.37,169.55)
  IN2 w0.102: v2(145.63,152.28) 145.63,152.54 145.75,152.66 146.98,152.66 147.44,153.12 147.7,153.12
  IN2 w0.157: 147.7,153.12 148.66,153.12 150.7,155.16 151.9,155.16 153.45,156.71 153.45,157.65 154.87,159.07 154.87,160.34 155.04,160.52 155.51,160.52 155.67,160.67 155.67,160.99 155.51,161.15 155.04,161.15 154.88,161.3 154.88,161.62 155.04,161.78 155.51,161.78 155.67,161.93 155.67,162.25 155.51,162.41 155.04,162.41 154.88,162.56 154.88,162.86 155.01,162.99 155.46,162.99 155.58,163.11 155.58,163.49 155.46,163.62 155.01,163.62 154.88,163.74 154.88,164.14 155.18,164.44 155.18,166.65 155.37,166.84 155.37,167.61 153.17,169.81 150.63,169.81 v2(150.37,169.55)
  BOTTOM w0.102: UV1.AL7 145.25,151.9 v2(145.63,152.28)
MDB54: length 32.3
  TOP w0.102: v2(151.9,171.15) 151.52,170.77 UV12.F2
  IN2 w0.102: v2(151.9,171.15) 152.3,171.54 153.75,171.54 156.49,168.8
  IN2 w0.157: v2(145.65,151.48) 146.92,151.48 147.64,152.21 150.91,152.21 157.49,158.79 157.49,167.81 156.49,168.8
  BOTTOM w0.102: UV1.AM8 v2(145.65,151.48)
MDB55: length 32
  TOP w0.102: UV12.E3 152.3,169.97 v2(152.7,170.37)
  IN2 w0.102: 152.97,170.37 153.02,170.33 ; 148.15,152.79 147.46,152.79 146.95,152.28 v2(146.41,152.28)
  IN2 w0.157: 153.02,170.33 155.75,167.6 155.75,166.57 155.62,166.44 155.62,165.47 156.15,164.94 156.15,160.06 155.99,159.9 155.52,159.9 155.37,159.74 155.37,159.43 155.52,159.27 155.99,159.27 156.15,159.11 156.15,158.76 155.99,158.6 155.05,158.6 154.8,158.35 154.8,158.12 155.07,157.85 155.07,157.67 154.8,157.41 154.62,157.41 154.35,157.68 154.13,157.68 153.91,157.46 153.91,157.24 154.13,157.02 154.13,156.74 153.82,156.42 153.82,156.42 151.95,154.56 151.3,154.56 151.08,154.78 150.85,154.78 150.63,154.56 150.63,154.33 151.07,153.89 151.07,153.71 150.8,153.44 150.62,153.44 150.17,153.88 149.93,153.88 149.71,153.66 149.71,153.44 149.82,153.32 149.82,153.14 149.55,152.88 149.37,152.88 149.26,152.99 149.04,152.99 148.84,152.79 148.15,152.79 ; v2(152.7,170.37) 152.97,170.37
  BOTTOM w0.102: v2(146.41,152.28) 146.05,151.93 UV1.AM7
MDB56: length 32.4
  TOP w0.102: 156.1,164.14 156.1,165.12 155.66,165.55 155.24,165.55 155.11,165.68 155.11,166.13 154.86,166.37 153.5,166.37 UV12.D7
  TOP w0.127: 156.1,164.14 156.1,163.46 155.97,163.33 154.74,163.33 154.5,163.09 154.5,162.53 154.87,162.16 154.87,161.65 154.31,161.08 144.72,161.08 144.6,160.97 144.6,160.67 144.73,160.55 v1(146.22,160.55) 148,160.55 148.13,160.42 148.13,160.17 148,160.04 144.73,160.04 144.6,159.91 144.6,155.73 v2(144.7,155.64)
  BOTTOM w0.102: v2(144.7,155.64) 144.25,155.19 UV1.AK1
MDB57: length 32.6
  TOP w0.102: 156.43,164.14 156.43,165.87 155.53,166.77 UV12.A7 ; v2(144.76,154.26) 144.76,154.67 145.1,155.01 v1(145.1,155.25) 145.1,156.08 144.93,156.26 144.93,157.31
  TOP w0.127: 156.43,164.14 156.43,163.09 156.3,162.96 155.33,162.96 155.2,162.84 155.2,162.5 155.33,162.37 155.47,162.37 155.6,162.25 155.6,161.99 155.47,161.86 155.34,161.86 155.21,161.74 155.21,161.52 154.46,160.77 148.76,160.77 148.64,160.64 148.64,160.35 148.76,160.22 152.5,160.22 152.62,160.09 152.62,159.83 152.5,159.71 145.06,159.71 144.93,159.58 144.93,157.31
  BOTTOM w0.102: v2(144.76,154.26) 145.05,153.97 UV1.AL4
MDB58: length 32.9
  TOP w0.102: UV12.B8 154.71,165.71 155.11,165.3 155.11,164.14 ; v2(146.42,153.06) 146.22,152.86 145.12,152.86 144.14,153.84 144.14,156.21 144.27,156.34 144.27,157.31
  TOP w0.127: 155.11,164.14 155.11,163.83 154.99,163.7 153.7,163.7 153.58,163.57 153.58,163.26 153.7,163.13 153.99,163.13 154.12,163 154.12,162.68 153.99,162.56 151.43,162.56 151.3,162.43 151.3,162.15 151.43,162.02 154.19,162.02 154.31,161.9 154.31,161.55 154.19,161.43 v1(152.78,161.43) 144.4,161.43 144.27,161.29 144.27,157.31
  BOTTOM w0.102: UV1.AM6 146.05,152.7 v2(146.42,153.06)
MDB59: length 31.9
  TOP w0.102: 156.77,168.57 156.36,168.98 154.52,168.98 153.9,169.6 UV12.C3
  TOP w0.127: v2(147.09,155.69) 147.49,156.09 148.08,156.09 148.2,156.22 148.2,157.01 148.33,157.13 148.59,157.13 148.71,157.01 148.71,156.22 148.84,156.09 149.21,156.09 149.34,156.22 v1(149.34,157.86) 149.34,158.12 149.46,158.25 149.74,158.25 149.87,158.12 149.87,157.02 150,156.89 150.25,156.89 150.38,157.02 150.38,158.12 150.5,158.25 154.03,158.25 156.49,160.71 156.67,160.71 156.77,160.61 156.95,160.61 157.13,160.79 157.13,160.97 157.03,161.07 157.03,161.25 157.21,161.43 157.39,161.43 157.48,161.34 157.66,161.34 157.84,161.52 157.84,161.7 157.75,161.79 157.75,161.97 157.95,162.17 157.95,167.39 156.77,168.57
  BOTTOM w0.102: v2(147.09,155.69) 146.47,155.69 UV1.AM1
MDB60: length 32.3
  TOP w0.127: v2(147.89,154.62) 148.42,155.15 v1(150.74,155.15) 151.08,155.15 151.21,155.28 151.21,156.09 151.33,156.22 151.59,156.22 151.71,156.09 151.71,155.28 151.84,155.15 152.14,155.15 152.27,155.28 152.27,157.44 152.41,157.58 152.71,157.58 152.84,157.45 152.84,156.26 152.97,156.13 153.22,156.13 153.35,156.26 153.35,157.45 153.47,157.58 154.31,157.58 154.84,158.11 155.02,158.11 155.14,158 155.32,158 155.5,158.18 155.5,158.36 155.38,158.47 155.38,158.65 155.6,158.87 155.78,158.87 155.96,158.69 156.14,158.69 158.69,161.23 158.69,167.8 156.51,169.97 UV12.A3
  BOTTOM w0.102: v2(147.89,154.62) 147.82,154.68 147.26,154.68 146.65,154.07 UV1.AN4
MDB61: length 32
  TOP w0.127: UV12.A2 155.94,170.34 156.69,170.34 159.08,167.95 159.08,161.15 155.36,157.43 155.18,157.43 155.03,157.58 154.85,157.58 154.67,157.4 154.67,157.22 154.82,157.07 154.82,156.9 154.52,156.6 154.35,156.6 154.05,156.9 153.87,156.9 153.68,156.71 153.68,156.53 v1(154.39,155.82) 154.67,155.54 154.67,155.36 154.49,155.18 154.31,155.18 153.63,155.86 153.45,155.86 153.27,155.68 153.27,155.5 153.91,154.86 153.91,154.68 153.73,154.5 153.55,154.5 152.91,155.14 152.73,155.14 152.26,154.68 148.64,154.68 147.9,153.93 147.9,153.95 v2(147.88,153.95)
  BOTTOM w0.102: v2(147.88,153.95) 147.56,154.27 UV1.AP3
MDB62: length 31.6
  TOP w0.127: UV12.C2 154.31,170.37 154.92,170.37 155.11,170.18 155.11,169.76 155.38,169.49 156.42,169.49 158.31,167.61 v1(158.31,162.86) 158.31,161.39 156.91,159.99 156.73,159.99 156.58,160.14 156.4,160.14 156.22,159.96 156.22,159.78 156.37,159.64 156.37,159.46 156.19,159.28 156.01,159.28 155.87,159.42 155.69,159.42 154.17,157.91 151.99,157.91 151.86,157.78 151.86,156.68 151.73,156.55 151.48,156.55 151.35,156.68 151.35,157.78 151.22,157.91 150.94,157.91 150.81,157.78 150.81,155.74 150.68,155.61 150.34,155.61 150.21,155.74 150.21,156.42 150.08,156.55 149.83,156.55 149.7,156.42 149.7,155.83 149.56,155.69 v2(147.95,155.69)
  BOTTOM w0.102: UV1.AP1 147.45,155.19 v2(147.95,155.69)
MDB63: length 31.9
  TOP w0.102: UV12.C8 154.3,165.57 154.3,164.25 ; v2(148.71,153.85) 147.53,152.66 145.03,152.66 143.94,153.75 143.94,157.31
  TOP w0.127: 154.3,164.25 154.19,164.13 151.99,164.13 151.89,164.03 151.89,163.75 151.99,163.65 153.12,163.65 153.25,163.52 153.25,163.26 153.12,163.14 151.09,163.14 150.96,163.01 150.96,161.88 150.83,161.76 144.27,161.76 143.94,161.43 143.94,157.31
  BOTTOM w0.102: v2(148.71,153.85) 148.32,153.85 147.94,153.47 UV1.AP5
MDI0+: length 74.7
  TOP w0.089: v2(34.16,31.37) 34.06,31.27 34.06,30.71 33.66,30.32 33.66,30.14 33.69,30.12 UL1.11
  IN2 w0.102: v2(34.16,31.37) 34.16,30.88 33.61,30.33 29.76,30.33 25.69,34.4 25.69,70.05 25.55,70.19 25.45,70.19 v2(25.33,70.07)
  BOTTOM w0.089: TL1.1 27.06,85.14 27.38,84.82 28.6,84.82 29.63,83.79 29.63,69.58 28.96,68.91 v4(28.53,68.91) 25.3,68.91 24.97,69.24 24.97,69.65 DL1.4 24.61,70.38 25.02,70.38 v2(25.33,70.07)
MDI0-: length 74.6
  TOP w0.089: UL1.12 33.29,30.12 33.32,30.15 33.32,30.46 v4(33.56,30.7) 33.71,30.86 33.71,31.23 v2(33.57,31.37)
  IN2 w0.102: v2(25.36,70.69) 25.56,70.49 25.67,70.49 26,70.17 26,34.53 29.89,30.64 33.49,30.64 33.82,30.97 33.82,31.15 33.6,31.37 v2(33.57,31.37)
  BOTTOM w0.089: TL1.2 27.31,83.87 27.39,83.94 27.39,84.35 27.52,84.48 28.45,84.48 29.29,83.64 29.29,69.72 28.82,69.26 25.44,69.26 25.31,69.39 25.31,69.54 25.42,69.64 26.38,69.64 DL1.3 26.74,70.38 25.68,70.38 v2(25.36,70.69)
MDI1+: length 59.8
  TOP w0.089: v2(32.56,32.57) 32.46,32.47 32.46,30.29 32.49,30.26 UL1.14
  IN2 w0.102: v2(32.56,32.57) 32.39,32.4 32.39,32.13 32,31.74 30.01,31.74 26.86,34.89 26.86,71.48 26.65,71.69 25.7,71.69 v2(25.59,71.58)
  BOTTOM w0.089: v2(25.59,71.58) 25.91,71.9 26.74,71.9 DL1.1 26.74,72.28 26.26,72.28 26.14,72.4 26.14,72.79 26.36,73.01 27.57,73.01 28.36,73.8 28.36,77.08 27.92,77.52 TL1.7
MDI1-: length 59.7
  TOP w0.089: UL1.15 32.09,30.26 32.12,30.29 v4(32.12,30.73) 32.12,32.42 v2(31.97,32.57)
  IN2 w0.102: v2(31.97,32.57) 32.09,32.45 32.09,32.25 31.88,32.04 30.13,32.04 27.16,35.01 27.16,71.61 26.78,71.99 25.82,71.99 v2(25.59,72.22)
  BOTTOM w0.089: v2(25.59,72.22) 25.28,71.9 24.62,71.9 DL1.6 24.62,72.28 25.09,72.28 25.43,72.62 25.62,72.62 25.8,72.79 25.8,72.94 26.22,73.35 27.42,73.35 28.02,73.94 28.02,76.94 27.78,77.18 27.38,77.18 27.22,77.02 27.22,76.38 27.1,76.25 TL1.8
MDO0+: length 10.8
  IN2 w0.254: v2(12.95,82.13) 12.95,82.14 12.95,85.37 12.3,86.02 JLAN1.1
  BOTTOM w0.254: v2(12.95,82.13) 13,82.18 13,82.99 15.01,85 v1(15.12,85) 16.05,85 16.19,85.14 TL1.16
MDO0-: length 10.7
  IN2 w0.254: JLAN1.2 12.87,86.16 13.46,85.58 13.46,82.21 v2(13.54,82.13)
  BOTTOM w0.254: v2(13.54,82.13) 13.51,82.16 13.51,82.78 15.22,84.49 15.88,84.49 16.09,84.29 16.09,84.08 16.3,83.87 TL1.15
MDO1+: length 20.1
  IN2 w0.254: v2(14.78,79.13) 14.78,79.13 14.76,79.11 14.76,78.71 14.33,78.28 13.61,78.28 13.06,78.83 13.06,80.55 14.4,81.88 14.4,87.73 14.07,88.05 JLAN1.3
  BOTTOM w0.254: TL1.10 16.35,77.52 16.16,77.33 16.16,76.92 16,76.76 15.09,76.76 14.71,77.14 14.71,79.06 14.78,79.13 v2(14.78,79.13)
MDO1-: length 20.1
  IN2 w0.254: v2(14.2,79.13) 14.25,79.08 14.25,78.92 14.12,78.79 13.82,78.79 13.57,79.04 13.57,80.34 14.9,81.67 14.9,87.94 13.93,88.91 13.93,90.06 JLAN1.6
  BOTTOM w0.254: TL1.9 v1(15.12,76.25) 14.88,76.25 14.2,76.93 v2(14.2,79.13)
ME_FLASH: length 36.6
  TOP w0.089: v2(136.18,84.5) 136.17,84.49 135.39,84.49 U4.A24
  TOP w0.102: v2(163.98,77.89) 163.2,77.11 163.2,74.94 U31.99
  IN2 w0.127: v2(163.98,77.89) 163.3,78.56 155.64,78.56 154.82,79.38 147.74,79.38 v2(147.47,79.12)
  BOTTOM w0.089: v2(136.18,84.5) 136.5,84.82 136.76,84.82
  BOTTOM w0.102: 136.76,84.82 137.03,84.82 137.18,84.67 137.18,83.64 137.69,83.14 137.69,82.37 137.78,82.28 RP12.4 138.62,82.28 138.97,82.64 140.17,82.64 R105.1 140.91,82.23 142.13,81.01 145.58,81.01 v1(146.46,80.13) v2(147.47,79.12)
MECH#1: length 3.3
  BOTTOM w0.102: TV12.1 121.9,126.92 UV1.A39
MECH#2: length 3.3
  BOTTOM w0.102: TV13.1 153.24,155.07 UV1.AW1
MECH#3: length 3.4
  BOTTOM w0.102: UV1.AW39 152.83,127.47 TV14.1
MIC_IN: length 2.9
  TOP w0.203: CA41.2 157.95,44.59 v1(157.16,45.38) 156.66,45.88 156.66,45.98 156.65,46 UA1.36
MICB_L: length 1.6
  TOP w0.203: UA1.32 155.05,44.96 RA17.1
MICB_R: length 1.9
  TOP w0.203: UA1.33 155.45,45.97 155.4,45.93 155.4,45.46 155.91,44.96 RA18.1
MIIC_SCL: length 2.5
  TOP w0.102: RT4.1 84.45,134.91 84.45,133.46 84.5,133.41 UT2.31
MIIC_SDA: length 2.6
  TOP w0.102: UT2.30 85,133.31 84.82,133.49 v1(84.82,134.13) 84.82,134.8 RT12.2
NC11: length 3.6
  TOP w0.102: T66.1 9.76,116.38 JCRT1.11
NOKIA_MIC: length 1.8
  TOP w0.203: UA1.31 154.65,45.44 RA12.1
NOVO#: length 104.5
  TOP w0.102: v2(175.72,90.37) 175.31,89.95 175.31,89.93 174.83,89.45 174.59,89.45 174.39,89.65 U31.34 ; D26.2 R642.1 101.53,113.8 R643.1 R628.2 102.53,113.8 v1(103.99,113.8) 116.31,113.8 v2(116.45,113.94)
  IN1 w0.127: v2(167.37,116.85) 164.49,113.97 157.75,113.97 157,113.22 151.31,113.22 150.58,113.94 138.33,113.94 137.9,114.37 130.89,114.37 129.65,113.13 117.26,113.13 v2(116.45,113.94)
  BOTTOM w0.102: v2(175.72,90.37) 175.95,90.6 175.95,92.53 176.83,93.41 176.83,100.44 175.81,101.46 175.81,108.4 v2(167.37,116.85)
NOVO_BTN#: length 26.3
  TOP w0.102: v2(103.28,111.74) 102.52,112.51 R628.1 ; JPWRB1.3 102.58,124.89 102.85,125.17 v2(102.85,126.03) ; v1(99.7,117.56) 99.56,117.42 v2(99.56,116.61) 98.81,116.61 98.64,116.44 D24.3 101.1,115.96 101.2,116.06 101.2,116.56 D26.1 101.88,116.57 102.61,115.83 v2(102.61,114.97)
  IN1 w0.127: v2(103.28,111.74) 102.61,112.42 v2(102.61,114.97) ; v2(102.85,126.03) 101.72,124.9 101.72,121.96 98.95,119.19 98.95,117.22 v2(99.56,116.61)
NTC_V: length 201.9
  TOP w0.102: v2(167.55,78.8) 167.19,78.44 U31.109 ; PR226.2 v2(182.99,60.57)
  TOP w0.254: PH201.1 v2(66.5,96.4)
  IN1 w0.127: v2(101.06,117.61) 102.22,117.61 102.8,117.03 121.39,117.03 123.5,114.92 128.92,114.92 130.37,116.37 141.33,116.37 141.53,116.16 151.39,116.16 152.06,115.49 160.87,115.49 162.47,117.1 v2(162.47,117.1)
  IN2 w0.089: 70.54,116 70.54,111.7 70.54,111.7 70.54,111.4 70.54,111.4 70.54,99.85 70.89,99.5 70.89,97.28 70.51,96.9 67,96.9 v2(66.5,96.4)
  IN2 w0.127: v2(182.99,60.57) 182,59.58 169.22,59.58 v2(168.81,59.99) ; v2(101.06,117.61) 100.65,117.61 100.18,117.13 77.65,117.13 75.67,119.11 72.56,119.11 70.54,117.09 70.54,116
  BOTTOM w0.102: v2(162.47,117.1) 163.14,117.1 165.09,115.15 165.09,107.98 165.3,107.78 165.3,94.37 165.16,94.23 165.16,91.58 v1(166.09,90.65) 166.09,89.88 167.13,88.83 167.13,85.66 167.93,84.86 167.93,79.18 v2(167.55,78.8) 167.55,61.86 168.81,60.59 v2(168.81,59.99)
NTC_VGA: length 18.5
  IN1 w0.254: v2(180.69,141.77) 180.53,141.61 v2(165.23,141.61)
  BOTTOM w0.254: PH802.1 v2(165.23,141.61) ; v2(180.69,141.77) 181.03,142.11 v1(181.31,142.11) 181.6,142.11 182.06,141.65 PR853.2
NUVOTON_VTT: length 2.8
  TOP w0.102: R595.1 170.39,72.79 v1(170.39,73.35) U31.117
ODD_DA#: length 63.1
  TOP w0.102: JODD1.11 199.71,59.9 195.96,56.15 183.93,56.15 JODD2.10 183.92,56.15 182.91,56.15 182.75,55.98 182.75,55.43 182.46,55.15 R555.2 v1(173.46,55.15) v2(171.28,57.33) ; v2(175.03,83.66) 175.12,83.76 U31.19
  BOTTOM w0.102: v2(175.03,83.66) 176.35,82.34 176.35,70.56 173.58,67.79 173.58,61.91 171.28,59.61 v2(171.28,57.33)
ODD_DETECT#: length 18.4
  TOP w0.102: R710.2 196.9,55.67 189.91,55.67 187.38,53.15 JODD2.7 ; R710.2 198.2,56.9 JODD1.8 ; R710.2 v1(196.93,56.65)
ODD_EN: length 85.3
  TOP w0.089: U4.C16 134.4,87.26 134.74,86.93 134.82,86.93 135.18,86.56 135.59,86.56 135.63,86.6 136.05,86.6 v2(136.32,86.32)
  TOP w0.102: v2(191.59,82.61) 191.42,82.78 180.09,82.78 180.06,82.74 178.8,82.74 177.95,81.89 v2(177.77,81.89)
  IN1 w0.089: v2(136.32,86.32) 136.32,86.11 135.97,85.76 135.97,85.29 136.16,85.1 136.76,85.1
  IN1 w0.127: v2(177.77,81.89) 177.34,81.46 167.16,81.46 165.86,80.15 161.42,80.15 159.68,81.89 141.17,81.89 138.81,84.25 137.99,84.25 137.14,85.1 136.76,85.1
  BOTTOM w0.102: v2(191.59,82.61) 192.03,82.17 192.03,67.48 v1(191.75,67.19) Q100.2
ODTA0: length 36.9
  TOP w0.102: v2(109.45,132.05) 109.82,132.42 110.73,132.42 111.19,132.87 111.31,132.87 111.59,133.16 111.59,133.27 111.89,133.57 112.16,133.57 112.48,133.25 UV5.K1 ; 120.81,141.48 120.87,141.42 123.58,141.42 123.8,141.2 124.6,141.2 125.51,140.29 127.24,140.29 127.36,140.42 v2(127.36,140.68)
  TOP w0.203: 120.81,141.48 120.43,141.48 120.15,141.76 120.15,141.97 120.03,142.09 119.51,142.09 v1(119.34,141.92) v2(118.82,141.92)
  IN1 w0.102: v2(109.45,132.05) 109.82,132.42 110.43,132.42 110.45,132.43 110.57,132.43 110.78,132.23 110.96,132.23 111.09,132.36 111.09,132.54 110.8,132.83 110.8,132.99 110.91,133.11 111.08,133.11 111.38,132.81 111.54,132.81 112.55,133.82 113.64,133.82
  IN1 w0.127: 113.64,133.82 113.89,133.82 116.56,136.49 116.56,140.31 116.74,140.48 117.43,140.48 118.82,141.87 v2(118.82,141.92)
  BOTTOM w0.102: UV6.K1 105.7,133.25 105.58,133.13 105.58,132.97 105.7,132.85 108.5,132.85 109.31,132.05 v2(109.45,132.05) ; v2(127.36,140.68) 127.36,140.18 UV1.J21
ODTA1: length 38.2
  TOP w0.102: v2(109.7,152.41) 109.28,151.99 108.52,151.99 108.02,151.49 107.9,151.49 107.61,151.21 107.61,151.09 107.32,150.8 107.02,150.8 106.69,151.12 UV7.K1
  IN1 w0.102: 108.57,151.59 108.57,152.63 108.79,152.85 109.15,152.85 109.59,152.41 v2(109.7,152.41)
  IN1 w0.127: v2(107.06,144.89) 107.22,145.06 107.22,150.24 108.57,151.59
  IN2 w0.102: v2(124.47,142.58) 124.06,142.99 123.3,142.99 123.01,143.28 121.22,143.28 121.03,143.47 120.81,143.47
  IN2 w0.249: 120.81,143.47 118.6,143.47 118.47,143.34 116.42,143.34 115.36,142.28 113.17,142.28 112.11,143.34 111.33,143.34 110.78,143.89 108.06,143.89 v2(107.06,144.89)
  BOTTOM w0.102: v2(124.47,142.58) 125.54,142.58 UV1.G19 ; UV8.K1 112.46,151.44 111.2,151.44 110.24,152.41 v2(109.7,152.41)
ODTB0: length 37.3
  TOP w0.102: v2(128.11,168.55) 128.5,168.15 128.5,167.3 129,166.81 129,166.68 129.28,166.4 129.39,166.4 129.69,166.1 129.69,165.83 129.37,165.51 UV9.K1 ; 133.95,157.13 133.95,154.54 132.42,153 132.42,151.65 132.33,151.56 v2(132.07,151.56)
  TOP w0.203: 133.95,157.13 133.81,157.28 132.86,157.28 132.75,157.39 132.75,157.95 132.89,158.09 133.93,158.09 134.25,158.41 134.25,158.58 134.03,158.79 v1(133.52,158.79) 133.2,158.79 133.09,158.9 133.09,159.05 133.62,159.58 134.04,159.58 134.34,159.88 134.34,160.3 134.76,160.72 135.17,160.72 135.53,161.07 135.53,161.49 135.95,161.91 v2(136.19,161.91)
  IN1 w0.102: v2(128.11,168.55) 128.18,168.55 128.49,168.24 128.49,167.64 129.81,166.32 129.81,164.8 130.47,164.15
  IN1 w0.127: 130.47,164.15 131.69,162.93 133.69,162.93 134.71,161.91 v2(136.19,161.91)
  BOTTOM w0.102: v2(128.11,168.55) 128.11,168.63 128.96,169.48 128.96,171.51 129.1,171.64 129.29,171.64 UV10.K1 ; v2(132.07,151.56) 132.34,151.56 UV1.T7
ODTB1: length 37.7
  TOP w0.102: v2(135.86,152.34) 135.42,152.77 135.42,153.88 136.63,155.08 136.63,157.31 ; UV12.K1 147.98,171.24 147.98,170.63 148.28,170.34 148.39,170.34 148.68,170.06 148.68,169.93 149.17,169.43 149.17,168.67 v2(149.59,168.25)
  TOP w0.203: v2(138.21,162.1) v1(138.21,161.59) 138.21,161.31 137.89,160.99 137.89,159.67 136.63,158.41 136.63,157.31
  IN1 w0.127: v2(138.21,162.1) 138.09,162.22 138.09,162.9 138.19,163 139.11,163 139.21,162.9 139.21,162.4 139.14,162.33 138.92,162.33 138.84,162.25 138.84,161.92 139.02,161.75 144.84,161.75 148.65,165.55 148.65,166.56 149.59,167.5 v2(149.59,168.25)
  BOTTOM w0.102: v2(149.59,168.25) 149.59,168.14 148.63,167.17 148.63,165.49 UV11.K1 ; UV1.W7 135.39,151.87 v2(135.86,152.34)
ON/OFF: length 199.6
  TOP w0.102: v2(103.19,114.93) 102.79,114.53 102.29,114.53 D26.3 101.43,114.97 100.78,115.62 99.99,115.62 99.8,115.43 99.8,114.28 99.55,114.03 D24.2 98.64,114.75 98.88,114.98 v2(99.36,114.98) ; JPWRB1.4 101.29,125.89 101.05,126.13 v2(101.05,126.37) ; v2(168.92,76.31) 169.19,76.04 U31.114 169.19,73.69 169.41,73.47 169.41,69.16 v3(169.08,68.83) R701.1 169.09,66.43 J11.2 170.32,67.13 v2(170.15,67.29)
  IN1 w0.127: v2(103.19,114.93) 103.6,114.53 116.59,114.53 117.73,113.38 129.54,113.38 130.79,114.63 138.01,114.63 138.44,114.2 150.69,114.2 151.35,113.54 156.96,113.54 157.64,114.22 163.99,114.22 v2(166.69,116.92) ; v2(101.05,126.37) 101.47,125.96 101.47,122.06 98.7,119.29 98.7,115.64 v2(99.36,114.98)
  IN2 w0.127: v2(191.03,66.52) 170.92,66.52 v2(170.15,67.29)
  BOTTOM w0.102: v2(168.92,76.31) 167.95,77.28 167.95,78.77 168.16,78.97 168.16,84.96 167.36,85.75 167.36,88.93 166.42,89.87 166.42,90.79 166,91.21 166,94.75 165.52,95.22 165.52,107.87 165.32,108.07 165.32,116.72 165.93,117.32 166.29,117.32 v2(166.69,116.92) ; v2(191.03,66.52) 191.03,67.71 191.59,68.27 191.59,80.72 191.03,81.28 191.03,83.18 191.87,84.02 192.77,84.02 196.86,88.11 196.86,91.09 199.18,93.42 J12.2
P2: length 15.5
  TOP w0.102: 189.57,160.92 189.57,161.93 v3(189.63,162)
  IN2 w0.254: v4(187.97,157.29) 186.93,157.29 185.8,156.16 v2(183.9,156.16)
  BOTTOM w0.254: v2(183.9,156.16) 183.49,155.74 PQ304.3 183.49,154.28 184.06,153.71 185.38,153.71 185.68,153.41 PR304.1 185.68,150.8 184.49,149.62 PC302.1
  vias: v4(187.98,158.58) v4(187.97,157.94) v4(188.61,158.6) v4(188.6,157.93) v4(188.61,157.29) v4(189.31,158.59) v4(189.29,157.94) v4(189.27,157.3) v4(189.93,157.3) v4(189.97,158.57) v4(189.95,157.93)
P2-1: length 31.6
  TOP w0.254: v4(190.66,161.73) 189.9,162.49 v1(187.73,162.49) 186.87,162.49 PC301.1 186.48,162.11 PQ301.4 ; v2(185,151.84) 185.85,150.98 185.85,149.86 185.31,149.32 PR305.1
  IN1 w0.254: v2(185,151.84) 185.49,152.33 186.65,152.33 190.66,156.34 v4(190.66,161.73)
  BOTTOM w0.254: PQ304.1 183.54,153.55 183.95,153.14 184.27,153.14 PR304.2 185,152.41 v2(185,151.84) 184.32,151.84 183.5,151.02 PC302.2 182.96,150.48 PR306.1 ; PQ302.4 189.91,161.37 190.28,161.73 v4(190.66,161.73)
P2-2: length 2.2
  TOP w0.102: PQ307.3 185.19,149.85 v1(185.43,150.09)
  TOP w0.254: PR305.2 184.38,148.82 PQ307.3
P3:
  vias: v3(183.51,161.76) v4(183.08,158.09) v4(183.72,157.41) v4(183.75,158.09) v4(184.4,158.1) v4(184.4,157.44) v4(184.37,156.79) v4(185.07,158.09) v4(185.07,157.43) v4(185.05,156.8) v4(185.72,158.1) v4(185.73,157.46) v4(185.71,156.82)
PACIN: length 64.4
  TOP w0.254: v2(191.17,152.89) 192.12,153.85 192.12,161.81 193.58,163.27 196.64,163.27 198.13,164.75 v3(198.13,165.49) 198.13,165.78 197.67,166.24 PR312.1 196.77,166.24 PR314.1 PR310.2 194.68,166.51 194.68,167.86 PQ308.1
  IN1 w0.254: v2(165.65,152.89) 165.84,153.08 179.32,153.08 179.9,153.66 v2(181.58,153.66) 183.92,151.32 185.23,151.32 185.85,151.95 190.22,151.95 v2(191.17,152.89)
  BOTTOM w0.254: v2(165.65,152.89) 164.45,154.1 164.45,154.6 165.74,155.89 165.74,161.06 163.51,163.29 PQ313.2 ; PR303.1 v2(181.58,153.66)
PBTN_OUT#: length 81.3
  TOP w0.089: 132.8,97.07 132.8,97 132.15,96.36 132.15,95.11 131.28,94.24 U4.K1
  TOP w0.102: v2(165.84,78.93) 165.84,75.98 165.99,75.84 U31.106 ; 132.8,97.07 132.8,98.81 132.33,99.28 132.33,99.61 131.95,99.99 131.95,101.71 v2(132.54,102.31)
  IN1 w0.127: v2(163.68,110.09) 153.97,110.09 150,106.12 136.6,106.12 132.78,102.31 v2(132.54,102.31)
  BOTTOM w0.102: v2(165.84,78.93) 165.84,79.04 166.73,79.93 166.73,84.37 165.94,85.16 165.94,88.34 162.86,91.42 162.86,93.09 162.99,93.22 162.99,94.84 163.43,95.29 v1(163.43,100.1) 163.43,109.85 v2(163.68,110.09)
PC_BEEP: length 3.7
  TOP w0.102: UA1.10 159.38,50.87 159.77,51.27 159.77,52.31 v1(160.03,52.56) 160.73,53.26 RA492.2
PCH_BT_ON#: length 154.9
  TOP w0.089: U4.BB4 117.93,92.66 v2(117.93,92.19)
  TOP w0.102: v2(113.23,101.03) 112.98,101.03 112.78,100.82 112.78,100.36 112.94,100.2 v1(113.33,100.2) 114.49,100.2 114.74,100.44 RP15.1
  IN1 w0.089: 116.79,94.79 116.79,94.39 117.66,93.52 119.43,93.52 120.02,92.93 120.02,92.5 119.95,92.43 119.95,91.49 119.45,90.99 118.46,90.99 117.93,91.53 v2(117.93,92.19)
  IN1 w0.127: v2(113.23,101.03) 113.45,100.8 114.51,100.8 116.79,98.52 116.79,94.79
  IN2 w0.127: v2(113.23,101.03) 113.23,101.39 114.31,102.47 115.91,102.47 118.79,105.36 124.64,105.36 125.62,106.34 127.45,108.16 133.66,108.16 134.05,108.56 140.02,108.56 140.41,108.16 148.65,108.16 150.52,106.3 154.79,106.3 155.24,106.75 156.67,106.75 158.17,105.25 163.32,105.25 165.15,103.43 191.89,103.43 192.38,103.91 192.38,110.22 199.44,117.27 199.44,121 200.3,121.87 200.3,137.75 201.19,138.63 201.19,142.35 200.49,143.05 200.49,144.35 v2(200.59,144.45)
  BOTTOM w0.102: JWLN1.5 200.1,142 200.51,142.41 200.51,144.37 v2(200.59,144.45)
PCH_CLK_BIASREF: length 3.2
  TOP w0.089: v2(121.91,75.17) U4.AN44
  BOTTOM w0.089: v2(121.91,75.17) 121.59,75.17 121.36,75.4 v1(121.36,75.83) 121.36,76.15 121.42,76.2 R214.1
PCH_DPWROK: length 13.4
  TOP w0.102: v2(134.42,97.19) R139.1 134.4,97.86 R149.1 ; v2(131.22,89.48) 131.22,89.49 131.21,89.49 130.99,89.26 U4.L13
  IN1 w0.089: v2(131.22,89.48) 131.57,89.13 132.1,89.13 132.21,89.24 132.21,89.96 132.11,90.07 132.11,91.46 132.86,92.21 132.86,93.75 133.17,94.05 133.17,94.32 133.64,94.79
  IN1 w0.127: 133.64,94.79 134.2,95.35 134.2,96.11 134.49,96.4 134.49,97.11 v2(134.42,97.19)
  BOTTOM w0.102: v2(134.42,97.19) 134.42,98 v1(134.63,98.21)
PCH_GPI011: length 10.8
  TOP w0.089: 136.31,97.07 136.31,96.61 v2(136.24,96.54)
  TOP w0.102: R216.2 136.31,97.07 ; U4.N7 130.38,91.6 v2(130.66,91.32)
  IN2 w0.127: v2(130.66,91.32) 130.96,91.62 130.96,91.82 131.53,92.39 131.53,92.83 132.37,93.67 134.58,93.67 135.33,94.42 135.33,95.21 135.67,95.55 135.67,95.97 v2(136.24,96.54)
  BOTTOM w0.089: v2(130.66,91.32) 130.8,91.32 v1(131.08,91.6)
PCH_GPIO0: length 17.5
  TOP w0.089: U4.AT8 120.69,91 v2(120.39,90.7)
  TOP w0.102: RP15.2 115.39,101.66 115.23,101.82 v2(114.34,101.82)
  IN1 w0.089: 118.16,94.79 118.16,94.47 118.61,94.03 119.43,94.03 120.56,92.89 120.56,92.19 120.75,92 120.75,91.06 v2(120.39,90.7)
  IN1 w0.127: v2(114.34,101.82) 114.92,101.82 117.8,98.94 117.8,96.19 118.16,95.83 118.16,94.79
  BOTTOM w0.089: v2(120.39,90.7) 120.5,90.7 v1(120.82,91.02)
PCH_GPIO1: length 29
  TOP w0.089: U4.F13 133.09,89.32 132.76,89.32 v2(132.58,89.51)
  TOP w0.102: R248.2 140.81,76.58 140.95,76.44 142.72,76.44 144.47,78.19 144.47,81.14 143.9,81.71 143.9,83.32 142.24,84.98 v2(142.24,86.18)
  IN1 w0.089: 136.76,92.01 135.6,92.01 133.7,90.1 133.17,90.1 v2(132.58,89.51)
  IN1 w0.127: 136.76,92.01 137.45,92.01 142.24,87.21 v2(142.24,86.18)
  BOTTOM w0.089: v1(132.16,89.91) 132.57,89.51 v2(132.58,89.51)
PCH_GPIO2: length 10.8
  TOP w0.089: U4.G17 132.78,87.38 v2(132.95,87.55)
  IN1 w0.089: 136.76,87.4 134.18,87.4 133.98,87.2 133.3,87.2 v2(132.95,87.55)
  IN1 w0.127: v2(140.37,85.68) 138.65,87.4 136.76,87.4
  BOTTOM w0.102: v1(141.03,84.92) 140.37,85.58 v2(140.37,85.68) RP13.7
PCH_GPIO3: length 9.8
  TOP w0.089: U4.F17 133.37,86.94 v2(133.02,86.59)
  IN1 w0.089: v2(133.02,86.59) 133.46,87.02 134.06,87.02 134.18,87.15 136.76,87.15
  IN1 w0.127: 136.76,87.15 138.55,87.15 139.07,86.62 v2(139.07,85.69)
  BOTTOM w0.102: RP13.9 v2(139.07,85.69) 139.07,85.47 v1(139.5,85.04)
PCH_GPIO4: length 18.6
  TOP w0.102: U4.L15 130.99,88.3 v2(131.24,88.56)
  IN2 w0.089: v2(131.24,88.56) 131.62,88.93 134.47,88.93 135.81,90.27 136.76,90.27
  IN2 w0.127: v2(143.31,91.14) 139.75,91.14 138.88,90.27 136.76,90.27
  BOTTOM w0.102: v2(143.31,91.14) 143.31,91.13 v1(142.79,90.61) 142.22,90.04 142.22,89.71 141.94,89.42 141.1,89.42 140.37,88.7 RP13.4
PCH_GPIO5: length 15.4
  TOP w0.089: U4.M15 130.39,88.3 v2(130.66,88.57)
  IN2 w0.089: v2(130.66,88.57) 131.07,88.15 133.72,88.15 134.01,88.44 134.23,88.44 135.05,89.25 136.51,89.25 136.76,89.51
  IN2 w0.127: 136.76,89.51 137.19,89.94 139.02,89.94 139.46,90.39 140.82,90.39 v2(141.37,89.84)
  BOTTOM w0.102: RP13.3 139.72,88.56 140.85,89.69 141.22,89.69 v2(141.37,89.84)
PCH_GPIO6: length 4.1
  TOP w0.089: U4.A14 135.43,88.35 136.99,88.35 137.1,88.24 137.67,88.24
  TOP w0.102: R249.2 139.06,88 v1(138.23,88) 137.92,88 137.67,88.24
PCH_GPIO12: length 19.3
  TOP w0.102: v2(131.83,89.5) 131.58,89.25 U4.K13
  IN1 w0.089: v2(131.83,89.5) 131.83,89.52 131.3,90.05 131.3,92.22 131.65,92.56 131.65,93.49 132.52,94.37 132.52,94.75 132.56,94.79
  IN1 w0.127: 132.56,94.79 133.33,95.56 133.33,95.93 133.13,96.14 133.13,96.43 133.87,97.16 133.87,97.6 132.43,99.04 132.43,101.05 132.84,101.46 133.46,101.46 v2(134.21,102.21)
  BOTTOM w0.102: v2(134.21,102.21) 134.2,102.21 133.17,101.18 v1(132.74,101.18) R252.2
PCH_GPIO13: length 5.4
  TOP w0.089: v2(133.83,84.98) 134.07,85.22 U4.C22
  BOTTOM w0.089: 136.32,85.05 136.16,84.89 133.92,84.89 v2(133.83,84.98) v1(133.08,84.98)
  BOTTOM w0.102: R106.2 137.47,85.05 136.32,85.05
PCH_GPIO16: length 8.8
  TOP w0.089: U4.AN2 121.95,94.13 121.68,94.4 121.68,95.08 120.03,96.74 120.03,96.91
  TOP w0.102: 120.03,96.91 R280.1 119.57,97.78 119.57,99.1 120.03,99.57 120.03,99.63 119.07,100.59 v1(119.07,100.85)
PCH_GPIO18: length 5.6
  TOP w0.089: 123.89,97.07 123.89,96.71 124.51,96.1 124.51,94.4 U4.AF1
  TOP w0.102: R184.1 123.89,98.69 123.89,97.07
PCH_GPIO24: length 15.2
  TOP w0.102: U4.Y10 127.44,90.4 v2(127.77,90.73) ; v2(128.73,102.36) 129.39,102.36 v1(129.43,102.4)
  IN1 w0.089: 128.37,94.79 128.37,94.63 127.33,93.6 127.33,91.17 v2(127.77,90.73)
  IN1 w0.127: 128.37,94.79 128.37,95.39 128.93,95.95 128.93,102.17 v2(128.73,102.36)
  BOTTOM w0.102: R273.2 129.11,101.99 v2(128.73,102.36)
PCH_GPIO26: length 4.9
  TOP w0.089: U4.V3 127.91,93.34 127.91,93.82 127.71,94.03 127.71,94.49 v2(127.99,94.76)
  BOTTOM w0.102: RP9.5 128.09,97.69 128.09,95.81 128.24,95.65 v1(128.24,95.35) 128.24,95.02 v2(127.99,94.76)
PCH_GPIO27: length 11.7
  TOP w0.102: U4.R11 129.41,89.81 v2(129.72,90.12)
  IN1 w0.089: 131.96,94.79 131.96,94.55 130.09,92.68 130.09,90.49 v2(129.72,90.12)
  IN1 w0.127: 131.96,94.79 131.96,94.82 v2(132.9,95.76)
  BOTTOM w0.089: v1(129.2,90.31) 129.53,90.31 v2(129.72,90.12)
  BOTTOM w0.102: R266.2 135.51,95.36 134.68,95.36 R267.2 132.99,95.85 v2(132.9,95.76)
PCH_GPIO28: length 16.8
  TOP w0.102: U4.AD11 125.69,89.91 125.19,90.41 v2(125.19,90.72)
  IN1 w0.089: v2(125.19,90.72) 125.6,91.13 125.6,92.24 125.12,92.72 125.12,93.04 124.14,94.02 124.14,94.79
  IN1 w0.127: v2(125.03,101.16) 124.59,100.72 124.59,100.13 123.93,99.46 123.93,95.93 124.14,95.72 124.14,94.79
  BOTTOM w0.102: R256.2 v2(125.03,101.16) 124.47,101.16 124.37,101.27 v1(124.37,101.72) 124.37,102.05 124.59,102.28 R260.2
PCH_GPIO33: length 8.7
  TOP w0.089: 137.96,85.84 137.91,85.89 137.59,85.89 137.27,86.22 137.27,86.51 136.71,87.07 135.67,87.07 135.6,87.14 134.94,87.14 U4.B17
  TOP w0.102: v1(140.05,84.01) 140,84.01 139,85.01 R101.2 138.62,84.66 138.31,84.66 v2(138.31,84.67) 138.03,84.94 138.03,85.77 137.96,85.84
  BOTTOM w0.102: R104.2 138.64,84.02 138.31,84.36 v2(138.31,84.67)
PCH_GPIO35: length 1.7
  TOP w0.089: v2(121.32,94.92) 121.32,94.33 121.52,94.13 U4.AP1
  BOTTOM w0.102: R265.2 121.43,95.03 v2(121.32,94.92)
PCH_GPIO36: length 7
  TOP w0.089: U4.AT3 120.71,93.7 120.43,93.99 120.43,94.47 120.05,94.85 119.74,94.85 118.35,96.24 v2(118.35,96.66) 118.17,96.84 118.17,97.07
  TOP w0.102: R271.2 118.17,97.07
  BOTTOM w0.102: v1(118.35,96.03) v2(118.35,96.66) 118.12,96.66 117.92,96.86 R275.1
PCH_GPIO37: length 10.6
  TOP w0.089: U4.AK1 123.15,95.65 123.04,95.76 123.04,96.29 122.84,96.49 122.84,97.07
  TOP w0.102: R270.2 v2(121.76,102.73) 121.77,102.73 122.13,102.38 v1(122.13,102.17) 122.13,98.08 122.84,97.37 122.84,97.07
  BOTTOM w0.102: R274.1 v2(121.76,102.73)
PCH_GPIO38: length 13.2
  TOP w0.089: 113.96,95.08 v2(114.35,95.08) ; U4.AT7 120.68,91.6 v2(120.37,91.28)
  TOP w0.102: 113.96,95.08 113.93,95.08 R283.1 113.17,95.85 R278.2
  IN1 w0.089: v2(120.37,91.28) 119.88,90.79 117.8,90.79 115.3,93.29
  IN1 w0.127: v2(114.35,95.08) 114.83,94.6 114.83,93.76 115.3,93.29
  BOTTOM w0.089: v1(118.96,90.47) 119.77,91.28 v2(120.37,91.28)
PCH_GPIO39: length 5
  TOP w0.089: 121.85,97.07 122.07,96.85 122.07,96.76 122.54,96.29 v1(122.54,95.96) 122.54,95.64 122.8,95.38 122.8,94.49 122.66,94.36 122.66,94.05 122.34,93.72 U4.AM3
  TOP w0.102: R268.2 121.59,97.33 121.85,97.07
PCH_GPIO44: length 4.5
  TOP w0.089: U4.AA2 126.83,93.68 126.93,93.77 126.93,94.29 127.12,94.49 127.12,95.32 126.96,95.49 v1(126.96,95.68) 126.96,96.07 v2(127.08,96.19)
  BOTTOM w0.102: v2(127.08,96.19) 127.08,96.19 127.08,96.8 127.56,97.28 RP9.6
PCH_GPIO45: length 8.1
  TOP w0.089: U4.AE4 125.18,93.25 124.87,93.57 124.87,93.81 125,93.94 125,93.95 125.12,94.06 125.12,94.35 125.35,94.58 125.35,95.08 v2(124.93,95.5)
  BOTTOM w0.102: v2(124.93,95.5) 124.99,95.44 125.39,95.44 v1(125.56,95.6) 125.56,96.35 126.03,96.82 126.03,97.9 126.43,98.29 126.92,98.29 127.06,98.15 RP9.7
PCH_GPIO46: length 5.3
  TOP w0.089: v2(127.67,95.29) 127.67,95.29 127.67,95.28 127.51,95.12 127.51,93.98 127.22,93.69 U4.Y3
  BOTTOM w0.102: RP9.8 126.56,96.13 v1(126.99,95.69) 127.4,95.29 v2(127.67,95.29)
PCH_GPIO48: length 13.3
  TOP w0.089: U4.AN4 121.93,92.79 121.93,93.23 121.67,93.49 121.67,93.58 120.96,94.29 120.96,95.15 120.52,95.59 120.52,95.89 119.35,97.07
  TOP w0.102: v1(117.56,104.14) 117.34,103.92 RP15.6 117.34,102.17 118.05,101.46 118.05,100.99 119.34,99.7 119.34,97.07 119.35,97.07
