# Allegro board IBM-Lenovo G410 G510 COMPAL LA-9641P BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D24: length 62.9
  IN2 w0.089: 50.92,77.14 51.02,77.23 51.45,77.23 52.41,78.19 52.86,78.19 53.05,78.38 53.74,78.38 54.63,79.27 54.63,80.62 54.85,80.83 55.37,80.83 55.63,81.1 55.63,81.58 56.09,82.04 56.32,82.04 56.48,82.19 56.48,82.94 56.6,83.07 56.91,83.07 57.04,82.94 v2(57.04,82.41)
  IN2 w0.127: 50.92,77.14 46.74,72.95 46.74,72.73 46.51,72.5 46.28,72.5 46.18,72.4 46.18,72.15 46.31,72.02 46.63,72.02 46.76,71.89 46.76,71.64 46.63,71.51 46.31,71.51 46.18,71.39 46.18,71.13 46.31,71.01 46.63,71.01 46.76,70.88 46.76,70.62 46.63,70.5 46.31,70.5 46.18,70.37 46.18,70.12 46.31,69.99 46.63,69.99 46.76,69.86 46.76,69.61 46.63,69.48 46.31,69.48 46.18,69.35 46.18,69.1 46.31,68.97 46.63,68.97 46.76,68.85 46.76,68.59 46.63,68.47 46.31,68.47 46.18,68.34 46.18,68.08 46.31,67.96 46.63,67.96 46.76,67.83 46.76,67.58 46.63,67.45 46.31,67.45 46.18,67.32 46.18,67.07 46.31,66.94 46.63,66.94 46.76,66.81 46.76,66.56 46.63,66.43 46.31,66.43 46.18,66.31 46.18,66.05 46.31,65.93 46.63,65.93 46.76,65.8 46.76,65.54 46.63,65.42 46.31,65.42 46.18,65.29 46.18,65.04 46.31,64.91 46.63,64.91 46.76,64.78 46.76,64.53 46.63,64.4 46.31,64.4 46.18,64.27 46.18,64.02 46.31,63.89 46.63,63.89 46.76,63.77 46.76,58.1 47.51,57.34 47.51,50.82 49.19,49.14 49.19,43.74 49.65,43.28 v2(49.65,42.53)
  BOTTOM w0.089: JCPU1.AJ4 57.51,82.88 v2(57.04,82.41)
  BOTTOM w0.102: JDIMM2.57 51.32,43.5 51.19,43.37 50.75,43.37 50.62,43.25 50.62,41.13 50.49,41 50.22,41 50.09,41.13 50.09,42.41 49.96,42.53 v2(49.65,42.53)
DDR_B_D25: length 62.5
  IN2 w0.089: 50.38,77.14 50.71,77.47 51.43,77.47 52.35,78.39 52.81,78.39 53,78.58 53.69,78.58 54.45,79.35 54.45,80.69 54.77,81.01 55.29,81.01 55.46,81.17 55.46,81.8 56.04,82.38 v2(56.04,82.41)
  IN2 w0.127: v2(49.64,41.01) 49.39,41.01 49.23,41.18 49.23,43.16 48.81,43.58 48.81,48.99 47.13,50.66 47.13,55.99 46.53,56.6 46.53,56.78 46.94,57.19 46.94,57.37 46.76,57.55 46.58,57.55 46.17,57.14 45.99,57.14 45.8,57.32 45.8,57.67 45.93,57.8 46.25,57.8 46.38,57.92 46.38,58.18 46.25,58.31 45.93,58.31 45.8,58.43 45.8,58.69 45.93,58.81 46.25,58.81 46.38,58.94 46.38,59.19 46.25,59.32 45.93,59.32 45.8,59.45 45.8,59.7 45.93,59.83 46.25,59.83 46.38,59.96 46.38,60.21 46.25,60.34 45.93,60.34 45.8,60.46 45.8,60.72 45.93,60.85 46.25,60.85 46.38,60.97 46.38,61.23 46.25,61.35 45.93,61.35 45.8,61.48 45.8,61.73 45.93,61.86 46.25,61.86 46.38,61.99 46.38,62.24 46.25,62.37 45.93,62.37 45.8,62.5 45.8,62.75 45.93,62.88 46.25,62.88 46.38,63 46.38,63.26 46.25,63.39 45.93,63.39 45.8,63.51 45.8,72.56 50.38,77.14
  BOTTOM w0.089: JCPU1.AK4 56.51,82.88 v2(56.04,82.41)
  BOTTOM w0.102: v2(49.64,41.01) 49.78,41.01 49.91,40.88 49.91,40.55 50.03,40.43 51.12,40.43 51.24,40.55 51.24,43 51.37,43.13 51.57,43.13 51.92,43.48 JDIMM2.59
DDR_B_D26: length 60.4
  IN2 w0.089: 54.64,77.14 54.64,77.2 55.31,77.87 55.81,77.87 56.83,78.89 57.26,78.89 57.44,79.08 57.44,79.48 57.32,79.6 57.16,79.6 57.04,79.48 v2(57.04,79.41)
  IN2 w0.127: 54.64,77.14 54.64,77.05 50.45,72.87 50.45,67.4 50.32,67.27 49.35,67.27 49.22,67.15 49.22,66.89 49.35,66.76 50.32,66.76 50.45,66.64 50.45,66.29 50.32,66.16 49.35,66.16 49.22,66.04 49.22,65.78 49.35,65.66 50.32,65.66 50.45,65.53 50.45,65.27 50.32,65.15 49.35,65.15 49.22,65.02 49.22,64.77 49.35,64.64 50.32,64.64 50.45,64.51 50.45,64.26 50.32,64.13 49.35,64.13 49.22,64 49.22,63.75 49.35,63.62 50.32,63.62 50.45,63.5 50.45,63.24 50.32,63.12 49.35,63.12 49.22,62.99 49.22,62.73 49.35,62.61 50.32,62.61 50.45,62.48 50.45,62.23 50.32,62.1 49.35,62.1 49.22,61.97 49.22,61.72 49.35,61.59 50.32,61.59 50.45,61.46 50.45,61.21 50.32,61.08 49.68,61.08 49.56,60.96 49.56,60.7 49.68,60.58 50.32,60.58 50.45,60.45 50.45,56.87 50.82,56.5 50.82,51.02 51.66,50.18 51.66,44.76 52.15,44.26 52.15,42.83 v2(52.45,42.53)
  BOTTOM w0.089: JCPU1.AJ1 57.51,79.88 v2(57.04,79.41)
  BOTTOM w0.102: v2(52.45,42.53) 53.38,42.53 54.32,43.47 JDIMM2.67
DDR_B_D27: length 61.4
  IN2 w0.089: v2(57.04,80.41) 57.04,80.75 56.91,80.88 56.74,80.88 56.61,80.75 56.61,79.08 55.76,78.23 55.25,78.23 54.18,77.16 54.18,77.14 54.18,77.14
  IN2 w0.127: v2(52.45,41.01) 52.37,41.01 52.25,40.88 52.25,40.64 52.12,40.51 51.9,40.51 51.77,40.63 51.77,44.1 51.28,44.6 51.28,50.02 50.44,50.86 50.44,56.34 50.07,56.71 50.07,57.73 49.73,58.07 49.73,59.99 48.84,60.88 48.84,67.65 48.97,67.78 49.94,67.78 50.07,67.91 50.07,68.16 49.94,68.29 48.97,68.29 48.84,68.42 48.84,68.67 48.97,68.8 49.94,68.8 50.07,68.92 50.07,69.18 49.94,69.3 48.97,69.3 48.84,69.43 48.84,69.69 48.97,69.81 49.94,69.81 50.07,69.94 50.07,70.19 49.94,70.32 48.97,70.32 48.84,70.45 48.84,70.7 48.97,70.83 49.94,70.83 50.07,70.96 50.07,71.23 49.94,71.36 48.97,71.36 48.84,71.48 48.84,71.74 48.97,71.86 49.94,71.86 50.07,71.99 50.07,73.03 54.18,77.14
  BOTTOM w0.089: v2(57.04,80.41) 57.51,80.88 JCPU1.AJ2
  BOTTOM w0.102: JDIMM2.69 54.92,43.47 v2(52.45,41.01)
DDR_B_D28: length 57.8
  IN2 w0.089: v2(54,80.39) 53.6,79.99 53.6,79.47 53.13,79 52.5,79 52.28,78.78 50.95,78.78 49.3,77.14
  IN2 w0.127: 49.3,77.14 45.04,72.88 45.04,57 45.61,56.43 45.61,51.11 48.05,48.67 48.05,37.34 48.18,37.21 48.86,37.21 48.99,37.08 48.99,36.83 48.86,36.7 48.18,36.7 48.05,36.57 48.05,35.46 48.67,34.84 v2(49.91,34.84)
  BOTTOM w0.089: JCPU1.AM1 54.45,79.94 v2(54,80.39)
  BOTTOM w0.102: JDIMM2.56 51.02,35.27 50.59,34.85 49.92,34.85 v2(49.91,34.84)
DDR_B_D29: length 57.5
  IN2 w0.089: v2(54,79.43) 53.43,78.85 53.43,78.83 52.79,78.83 52.55,78.59 52.3,78.59 51.38,77.67 50.37,77.67 49.84,77.14
  IN2 w0.127: 49.84,77.14 45.42,72.72 45.42,57.16 45.99,56.59 45.99,51.26 48.43,48.83 48.43,38.76 49.43,37.76 49.43,35.94 50.33,35.03 50.33,33.74 v2(49.91,33.32)
  BOTTOM w0.089: v2(54,79.43) 53.51,79.92 JCPU1.AN1
  BOTTOM w0.102: JDIMM2.58 51.62,35.19 50.36,33.93 50.36,33.77 v2(49.91,33.32)
DDR_B_D30: length 60.7
  IN2 w0.089: 53.33,77.14 53.48,77.29 54.01,77.29 55.29,78.57 55.85,78.57 56.43,79.16 56.43,80.02 v2(56.05,80.41)
  IN2 w0.127: v2(53.82,34.84) 52.95,35.71 52.95,35.89 53.14,36.08 53.14,36.26 52.96,36.44 52.78,36.44 52.59,36.25 52.41,36.25 52.23,36.43 52.23,36.61 52.42,36.8 52.42,36.98 52.24,37.16 52.06,37.16 51.87,36.97 51.69,36.97 51.39,37.27 51.39,38.19 51.52,38.32 52.24,38.32 52.36,38.44 52.36,38.7 52.24,38.82 51.52,38.82 51.39,38.95 51.39,39.2 51.52,39.33 52.21,39.33 52.34,39.46 52.34,39.71 52.21,39.84 51.52,39.84 51.39,39.97 51.39,43.94 50.89,44.44 50.89,49.87 50.06,50.7 50.06,56.19 49.69,56.55 49.69,57.57 49.35,57.91 49.35,59.83 48.46,60.72 48.46,72.27 48.79,72.59 48.97,72.59 49.31,72.25 49.49,72.25 49.67,72.43 49.67,72.61 49.32,72.95 49.32,73.13 53.33,77.14
  BOTTOM w0.089: JCPU1.AK2 56.51,80.88 56.04,80.41 v2(56.05,80.41)
  BOTTOM w0.102: v2(53.82,34.84) 54.26,34.84 54.62,35.2 JDIMM2.68
DDR_B_D31: length 59.8
  IN2 w0.089: 52.79,77.14 53.17,77.52 53.88,77.52 55.76,79.4 v2(56.03,79.4)
  IN2 w0.127: v2(53.82,33.32) 53.19,33.32 53.07,33.19 53.07,32.18 52.94,32.05 52.54,32.05 52.41,32.18 52.41,35.65 51.01,37.05 51.01,43.79 50.51,44.28 50.51,49.71 49.68,50.54 49.68,56.03 49.31,56.4 49.31,57.41 48.97,57.75 48.97,59.67 48.08,60.56 48.08,72.43 52.79,77.14
  BOTTOM w0.089: v2(56.03,79.4) 56.51,79.88 JCPU1.AK1
  BOTTOM w0.102: JDIMM2.70 55.22,34.72 v2(53.82,33.32)
DDR_B_D32: length 63.8
  IN2 w0.089: 77.29,77.14 75.45,78.98 74.9,78.98 74.64,79.24 74.64,79.83 74.77,79.96 75.91,79.96 76.04,80.09 v2(76.04,80.41)
  IN2 w0.127: v2(77.3,40.91) 77.3,40.67 77.43,40.55 77.62,40.55 77.74,40.67 77.74,43.2 78.84,44.3 78.84,49.66 79.9,50.72 79.9,51.46 80.03,51.59 80.21,51.59 80.31,51.69 80.31,51.99 80.21,52.1 80.03,52.1 79.9,52.22 79.9,52.48 80.03,52.6 80.21,52.6 80.33,52.73 80.33,52.98 80.21,53.11 80.03,53.11 79.9,53.24 79.9,53.49 80.03,53.62 80.21,53.62 80.33,53.75 80.33,54 80.21,54.13 80.03,54.13 79.9,54.25 79.9,54.51 80.03,54.64 80.21,54.64 80.33,54.76 80.33,55.02 80.21,55.14 80.03,55.14 79.9,55.27 79.9,55.7 80.03,55.83 80.36,55.83 80.47,55.94 80.47,56.36 84.03,59.91 84.03,60.47 84.77,61.22 84.77,72.95 82.2,75.52 81.99,75.52 81.18,74.72 80.9,74.72 80.52,75.09 80.52,75.27 80.71,75.45 80.71,75.63 80.53,75.81 80.35,75.81 80.16,75.63 79.98,75.63 79.8,75.81 79.8,75.99 79.96,76.14 79.96,76.32 79.78,76.5 79.6,76.5 79.44,76.35 79.26,76.35 78.69,76.93 77.5,76.93 77.29,77.14
  BOTTOM w0.089: JCPU1.L2 75.51,80.94 v2(76.04,80.41)
  BOTTOM w0.102: JDIMM2.129 75.32,42.54 75.48,42.38 75.62,42.38 75.96,42.71 76.13,42.71 76.24,42.59 76.24,42.43 75.91,42.09 75.91,41.95 76.05,41.8 76.19,41.8 76.7,42.3 76.86,42.3 76.98,42.18 76.98,42.01 76.48,41.51 76.48,41.37 76.94,40.91 v2(77.3,40.91)
DDR_B_D33: length 63.3
  IN2 w0.089: v2(75.04,80.41) 75.36,80.41 75.48,80.54 75.48,80.78 75.36,80.91 74.57,80.91 74.44,80.78 74.44,79.19 74.83,78.8 75.08,78.8 76.75,77.14
  IN2 w0.127: 76.75,77.14 77.34,76.55 78.53,76.55 81.16,73.91 81.34,73.91 82.21,74.79 82.39,74.79 82.57,74.61 82.57,74.43 81.7,73.56 81.7,73.38 81.88,73.2 82.06,73.2 82.93,74.07 83.11,74.07 83.29,73.89 83.29,73.71 82.42,72.84 82.42,72.66 82.6,72.48 82.78,72.48 83.65,73.35 83.83,73.35 84.01,73.17 84.01,72.99 83.14,72.12 83.14,71.94 83.32,71.76 83.5,71.76 84.03,72.3 84.21,72.3 84.39,72.12 84.39,71.94 83.85,71.4 83.85,71.22 84.39,70.68 84.39,61.37 83.64,60.63 83.64,60.07 79.03,55.45 79.03,52.54 79.15,52.41 79.4,52.41 79.52,52.28 79.52,52.03 79.4,51.9 79.08,51.9 78.95,51.78 78.95,51.52 79.08,51.4 79.4,51.4 79.52,51.27 79.52,51.01 79.4,50.89 78.97,50.89 78.84,50.76 78.84,50.2 78.46,49.82 78.46,44.45 77.3,43.3 v2(77.3,42.43)
  BOTTOM w0.089: JCPU1.M2 74.51,80.94 v2(75.04,80.41)
  BOTTOM w0.102: v2(77.3,42.43) 77.05,42.69 76.66,42.69 75.92,43.43 JDIMM2.131
DDR_B_D34: length 65.9
  IN2 w0.089: 84.01,78.03 83.8,78.24 81.58,78.24 79.95,79.87 78.82,79.87 78.5,80.19 78.5,80.74 78.25,80.99 77.96,80.99 77.62,81.33 77.62,81.65 77.28,81.99 75.93,81.99 75.8,82.11 75.8,83.23 75.93,83.36 v2(76.04,83.36)
  IN2 w0.127: 84.01,78.03 85.99,76.04 85.99,75.87 85.77,75.64 85.77,75.46 85.95,75.28 86.13,75.28 86.35,75.51 86.53,75.51 86.71,75.33 86.71,75.15 86.48,74.92 86.48,74.74 86.67,74.56 86.84,74.56 87.07,74.79 87.25,74.79 87.43,74.61 87.43,74.43 87.2,74.2 87.2,74.02 87.38,73.84 87.56,73.84 87.79,74.07 87.97,74.07 88.15,73.89 88.15,73.71 87.92,73.48 87.92,73.3 88.16,73.06 88.16,60.78 88.04,60.66 87.58,60.66 87.45,60.53 87.45,59.47 84.44,56.46 84.44,56.33 84.32,56.2 83.96,56.2 83.83,56.08 83.83,55.82 83.96,55.7 84.32,55.7 84.44,55.57 84.44,55.29 84.32,55.16 83.95,55.16 83.82,55.03 83.82,54.78 83.95,54.65 84.32,54.65 84.44,54.53 84.44,54.27 84.32,54.14 83.95,54.14 83.82,54.02 83.82,53.76 83.95,53.64 84.32,53.64 84.44,53.51 84.44,53.26 84.32,53.13 83.95,53.13 83.82,53 83.82,52.75 83.95,52.62 84.32,52.62 84.44,52.49 84.44,50.67 82.36,48.58 82.36,46.19 81.39,45.23 81.39,43 81.16,42.77 81.16,41.33 80.69,40.86 80.4,40.86 v2(80.35,40.91)
  BOTTOM w0.089: v2(76.04,83.36) 75.63,82.94 JCPU1.L4
  BOTTOM w0.102: v2(80.35,40.91) 79.67,41.59 79.67,42.55 78.92,43.31 JDIMM2.141
DDR_B_D35: length 66.9
  IN2 w0.089: v2(75.04,82.41) 75.04,82.94 74.91,83.07 74.56,83.07 74.4,82.91 74.4,81.97 74.56,81.81 77.21,81.81 77.44,81.58 77.44,80.4 77.86,79.97 78.15,79.97 78.68,79.45 78.68,79.26 78.89,79.05 80.18,79.05 81.2,78.03
  IN2 w0.127: 81.2,78.03 81.35,77.88 82.81,77.88 83.24,77.45 83.42,77.45 83.64,77.68 83.82,77.68 84,77.5 84,77.32 83.78,77.09 83.78,76.91 83.96,76.73 84.14,76.73 84.36,76.96 84.54,76.96 84.72,76.78 84.72,76.6 84.5,76.37 84.5,76.19 84.68,76.01 84.85,76.01 85.08,76.24 85.26,76.24 85.44,76.06 85.44,75.88 85.21,75.65 85.21,75.47 87.78,72.9 87.78,64.15 87.66,64.02 86.98,64.02 86.86,63.89 86.86,63.64 86.98,63.51 87.66,63.51 87.78,63.38 87.78,63.2 87.66,63.07 86.98,63.07 86.86,62.94 86.86,62.69 86.98,62.56 87.66,62.56 87.78,62.43 87.78,62.18 87.66,62.05 86.98,62.05 86.86,61.93 86.86,61.67 86.98,61.54 87.66,61.54 87.78,61.42 87.78,61.16 87.66,61.04 86.98,61.04 86.86,60.91 86.86,60.35 86.11,59.6 86.11,59.05 83.44,56.38 83.44,52.32 83.57,52.19 83.91,52.19 84.01,52.09 84.01,51.78 83.91,51.68 83.57,51.68 83.44,51.56 83.44,51.3 83.57,51.18 83.91,51.18 84.01,51.08 84.01,50.77 83.91,50.67 83.57,50.67 83.44,50.54 83.44,50.39 80.97,47.92 80.97,43.43 80.35,42.81 v2(80.35,42.43)
  BOTTOM w0.089: JCPU1.M4 74.51,82.94 v2(75.04,82.41)
  BOTTOM w0.102: JDIMM2.143 79.51,43.14 79.63,43.02 79.78,43.02 79.9,43.15 80.05,43.15 80.19,43 80.19,42.86 80.06,42.73 80.06,42.59 80.22,42.43 v2(80.35,42.43)
DDR_B_D36: length 62.3
  IN2 w0.089: v2(76.04,79.41) 76.23,79.41 77.95,77.69 77.96,77.69
  IN2 w0.127: 77.96,77.69 79.67,77.69 80.8,76.56 82.24,76.56 85.54,73.26 85.54,60.9 84.79,60.15 84.79,59.6 81.8,56.61 81.8,50.61 79.61,48.42 79.61,43.98 78.51,42.88 78.51,37.82 78.2,37.51 78.2,33.54 77.98,33.32 77.65,33.32 77.53,33.45 77.53,34.1 77.4,34.23 77.14,34.23 77.02,34.1 77.02,33.45 76.89,33.32 v2(76.47,33.32)
  BOTTOM w0.089: JCPU1.L1 75.51,79.94 v2(76.04,79.41)
  BOTTOM w0.102: v2(76.47,33.32) 75.62,34.18 JDIMM2.130
DDR_B_D37: length 62.5
  IN2 w0.089: v2(75.04,79.41) 75.53,79.41 77.63,77.31 77.96,77.31
  IN2 w0.127: 77.96,77.31 79.51,77.31 80.64,76.18 82.08,76.18 85.16,73.11 85.16,61.06 84.41,60.31 84.41,59.75 81.42,56.76 81.42,50.77 80.88,50.24 80.7,50.24 80.42,50.52 80.24,50.52 80.06,50.34 80.06,50.16 80.34,49.88 80.34,49.7 80.16,49.52 79.98,49.52 79.7,49.8 79.52,49.8 79.34,49.62 79.34,49.44 79.62,49.16 79.62,48.98 79.22,48.58 79.22,44.14 78.13,43.04 78.13,40.32 78,40.2 77.85,40.2 77.72,40.07 77.72,39.81 77.85,39.69 78,39.69 78.13,39.56 78.13,39.3 78,39.17 77.4,39.17 77.28,39.04 77.28,38.79 77.4,38.66 78,38.66 78.13,38.54 78.13,37.97 77.73,37.58 77.73,36.24 77.61,36.12 77.23,36.12 77.11,35.99 77.11,35.74 77.23,35.61 77.61,35.61 77.73,35.48 77.73,34.99 77.59,34.84 v2(76.47,34.84)
  BOTTOM w0.089: JCPU1.M1 74.51,79.94 v2(75.04,79.41)
  BOTTOM w0.102: v2(76.47,34.84) 76.21,35.1 JDIMM2.132
DDR_B_D38: length 67.3
  IN2 w0.089: v2(76.04,84.39) 76.62,83.81 76.62,83.26 76.9,82.99 78.28,82.99 78.62,82.65 78.62,81.33 79.02,80.93 79.39,80.93 81.64,78.69 84.43,78.69 85.1,78.03
  IN2 w0.127: 85.1,78.03 88.93,74.2 88.93,60.47 88.49,60.03 88.49,59.43 85.69,56.62 85.69,50.83 83.12,48.26 83.12,45.86 82.19,44.93 82.19,42.72 81.92,42.45 81.92,40.57 80.06,38.71 80.06,34.37 79,33.31 79.01,33.31 v2(79.01,33.32)
  BOTTOM w0.089: v2(76.04,84.39) 75.6,83.94 JCPU1.L5
  BOTTOM w0.102: v2(79.01,33.32) 78.44,33.89 78.44,35.17 78.62,35.34 JDIMM2.140
DDR_B_D39: length 67
  IN2 w0.089: 84.56,78.03 84.07,78.51 81.56,78.51 80.03,80.05 78.89,80.05 78.68,80.26 78.68,81.02 78.44,81.26 78.44,82.58 78.21,82.81 76.63,82.81 76.44,82.99 76.44,83.74 76.25,83.93 75.56,83.93 v2(75.04,83.41)
  IN2 w0.127: 84.56,78.03 85.13,77.46 88.54,74.04 88.54,60.62 88.11,60.19 88.11,59.59 84.83,56.3 84.83,50.51 82.74,48.42 82.74,46.03 81.81,45.1 81.81,42.88 81.54,42.61 81.54,40.73 79.61,38.8 79.61,37.45 79.49,37.33 79.14,37.33 79.01,37.2 79.01,36.94 79.14,36.82 79.49,36.82 79.61,36.69 79.61,36.44 79.49,36.31 79.14,36.31 79.01,36.18 79.01,35.93 79.14,35.8 79.49,35.8 79.61,35.67 79.61,35.42 79.49,35.29 79.14,35.29 79.01,35.17 v2(79.01,34.84)
  BOTTOM w0.089: JCPU1.M5 74.51,83.94 v2(75.04,83.41)
  BOTTOM w0.102: v2(79.01,34.84) 79.21,35.05 JDIMM2.142
DDR_B_D40: length 71.4
  IN2 w0.089: 86.61,78.03 85.6,79.04 84.16,79.04 84.07,79.13 84.07,79.46 83.98,79.54 83.81,79.54 83.72,79.46 83.72,79.13 83.63,79.04 81.89,79.04 79.62,81.32 79.62,82.88 79.51,82.99 78.8,82.99 78.62,83.17 78.62,84.69 78.79,84.85 79.35,84.85 79.47,84.98 79.47,85.3 79.35,85.43 v2(79.04,85.43)
  IN2 w0.127: v2(82.64,40.91) 82.98,40.91 83.1,41.04 83.1,44.55 84.03,45.48 84.03,47.88 86.6,50.45 86.6,56.16 89.41,58.96 89.41,59.65 89.84,60.09 89.84,60.51 89.92,60.58 90.33,60.58 90.46,60.71 90.46,61.06 90.33,61.18 90,61.18 89.87,61.31 89.87,61.56 90,61.69 90.63,61.69 90.76,61.82 90.76,62.07 90.63,62.2 90,62.2 89.87,62.33 89.87,62.58 90,62.71 90.63,62.71 90.76,62.83 90.76,63.09 90.63,63.21 90,63.21 89.87,63.34 89.87,63.6 90,63.72 90.63,63.72 90.76,63.85 90.76,64.1 90.63,64.23 90,64.23 89.87,64.36 89.87,64.61 90,64.74 90.63,64.74 90.76,64.87 90.76,73.88 86.61,78.03
  BOTTOM w0.089: JCPU1.G7 79.51,85.9 v2(79.04,85.43)
  BOTTOM w0.102: JDIMM2.147 80.72,43.58 81.5,42.79 81.5,41.98 81.6,41.87 82.1,41.87 82.2,41.77 82.2,41.57 82.1,41.47 81.11,41.47 80.99,41.34 80.99,40.93 81.11,40.8 82.53,40.8 v2(82.64,40.91)
DDR_B_D41: length 72
  IN2 w0.089: 85.85,78.03 85.01,78.87 81.82,78.87 79.44,81.25 79.44,82.57 79.21,82.81 78.71,82.81 78.44,83.08 78.44,85.58 78.21,85.81 77.68,85.81 77.55,85.94 77.55,87.81 77.43,87.93 77.17,87.93 77.04,87.81 v2(77.04,87.41)
  IN2 w0.127: v2(82.64,42.43) 82.72,42.52 82.72,44.71 83.65,45.64 83.65,48.04 86.22,50.61 86.22,56.32 89.02,59.12 89.02,59.81 89.46,60.25 89.46,65.01 89.59,65.14 90.2,65.14 90.33,65.26 90.33,65.52 90.2,65.65 89.59,65.65 89.46,65.77 89.46,67.14 89.59,67.27 90.18,67.27 90.31,67.39 90.31,67.65 90.18,67.77 89.59,67.77 89.46,67.9 89.46,68.15 89.59,68.28 90.18,68.28 90.31,68.41 90.31,68.66 90.18,68.79 89.59,68.79 89.46,68.92 89.46,69.19 89.59,69.32 90.25,69.32 90.38,69.45 90.38,69.7 90.25,69.83 89.59,69.83 89.46,69.96 89.46,70.21 89.59,70.34 90.25,70.34 90.38,70.46 90.38,70.72 90.25,70.84 89.59,70.84 89.46,70.97 89.46,71.23 89.59,71.35 90.25,71.35 90.38,71.48 90.38,71.73 90.25,71.86 89.59,71.86 89.46,71.99 89.46,72.24 89.59,72.37 90.25,72.37 90.38,72.5 90.38,72.75 90.25,72.88 89.59,72.88 89.46,73 89.46,73.26 89.59,73.38 90.21,73.38 90.34,73.51 90.34,73.77 90.21,73.89 89.59,73.89 89.46,74.02 89.46,74.42 85.85,78.03
  BOTTOM w0.089: v2(77.04,87.41) 77.51,86.94 JCPU1.J8
  BOTTOM w0.102: JDIMM2.149 81.32,43.48 82.37,42.43 v2(82.64,42.43)
DDR_B_D42: length 71.8
  IN2 w0.089: 87.23,80.62 87.1,80.62 86.98,80.74 86.98,81.07 86.89,81.16 86.71,81.16 86.62,81.07 86.62,80.74 86.49,80.62 86.37,80.62 86.26,80.72 86.26,81.57 86.16,81.68 86.01,81.68 85.91,81.57 85.91,80.74 85.78,80.62 85.57,80.62 85.38,80.8 85.38,81.49 85.07,81.81 82.88,81.81 82.44,82.24 82.44,84.57 82.21,84.81 81.78,84.81 80.04,86.55 v2(80.04,87.41)
  IN2 w0.127: v2(85.2,42.43) 85.21,42.45 85.21,43.7 86.47,44.96 86.47,46.35 87.37,47.24 87.37,48.14 89.14,49.91 89.14,50.13 89.3,50.3 89.4,50.3 89.52,50.42 89.52,50.73 89.4,50.86 89.27,50.86 89.14,50.99 89.14,51.24 89.27,51.37 89.4,51.37 89.52,51.5 89.52,51.75 89.4,51.88 89.27,51.88 89.14,52 89.14,52.26 89.27,52.39 89.4,52.39 89.52,52.51 89.52,56.04 91.98,58.5 91.98,59.25 92.84,60.12 92.84,68.82 92.97,68.95 93.26,68.95 93.38,69.08 93.38,69.33 93.26,69.46 92.97,69.46 92.84,69.59 92.84,69.84 92.97,69.97 93.26,69.97 93.38,70.09 93.38,70.35 93.26,70.47 92.97,70.47 92.84,70.6 92.84,70.86 92.97,70.98 93.26,70.98 93.38,71.11 93.38,71.36 93.26,71.49 92.97,71.49 92.84,71.62 92.84,71.87 92.97,72 93.26,72 93.38,72.13 93.38,72.38 93.26,72.51 92.97,72.51 92.84,72.63 92.84,72.89 92.97,73.01 93.26,73.01 93.38,73.14 93.38,73.4 93.26,73.52 92.97,73.52 92.84,73.65 92.84,73.9 92.97,74.03 93.26,74.03 93.38,74.16 93.38,74.41 93.26,74.54 92.97,74.54 92.84,74.67 92.84,75 87.23,80.62
  BOTTOM w0.089: JCPU1.G8 79.57,86.94 v2(80.04,87.41)
  BOTTOM w0.102: v2(85.2,42.43) 85.08,42.55 84.61,42.55 84.48,42.42 84.48,40.86 84.36,40.74 84.16,40.74 84.03,40.86 84.03,43.18 83.72,43.49 JDIMM2.157
DDR_B_D43: length 71.8
  IN2 w0.089: v2(80.04,88.41) 80.53,87.92 80.53,86.32 81.86,84.99 82.28,84.99 82.62,84.65 82.62,82.32 82.95,81.98 85.28,81.98 85.4,81.86 86.53,81.86 87.23,81.16
  IN2 w0.127: v2(85.2,40.91) 85.2,40.67 85.32,40.55 85.63,40.55 85.76,40.67 85.76,43.7 86.85,44.79 86.85,46.19 88.73,48.07 88.73,48.96 89.91,50.14 89.91,55.88 93.23,59.2 93.23,62.12 93.29,62.19 93.67,62.19 93.81,62.33 93.81,62.78 93.69,62.91 93.37,62.91 93.24,63.03 93.24,63.29 93.37,63.41 93.69,63.41 93.81,63.54 93.81,63.79 93.69,63.92 93.37,63.92 93.24,64.05 93.24,64.3 93.37,64.43 93.69,64.43 93.81,64.56 93.81,64.81 93.69,64.94 93.37,64.94 93.24,65.06 93.24,65.32 93.37,65.45 93.69,65.45 93.81,65.57 93.81,65.83 93.69,65.95 93.37,65.95 93.24,66.08 93.24,66.33 93.37,66.46 93.69,66.46 93.81,66.59 93.81,66.84 93.69,66.97 93.37,66.97 93.24,67.1 93.24,67.35 93.37,67.48 93.69,67.48 93.81,67.6 93.81,67.86 93.69,67.99 93.37,67.99 93.24,68.11 93.24,68.37 93.37,68.49 93.69,68.49 93.81,68.62 93.81,74.58 87.23,81.16
  BOTTOM w0.089: v2(80.04,88.41) 79.57,87.94 JCPU1.G9
  BOTTOM w0.102: v2(85.2,40.91) 85.93,40.91 86.21,41.2 86.21,42.22 85.5,42.94 84.66,42.94 84.32,43.29 JDIMM2.159
DDR_B_D44: length 71.7
  IN2 w0.089: 87.19,78.03 85.91,79.3 85.11,79.3 84.54,79.87 81.82,79.87 81.5,80.18 81.5,80.5 81.13,80.87 80.82,80.87 80.44,81.24 80.44,84.59 78.62,86.41 v2(78.04,86.41)
  IN2 w0.127: 87.19,78.03 91.14,74.07 91.14,60.85 89.79,59.49 89.79,58.81 86.98,56 86.98,50.3 84.41,47.73 84.41,45.32 83.48,44.39 83.48,40.16 82.69,39.36 82.51,39.36 82.24,39.64 82.06,39.64 81.88,39.46 81.88,39.28 82.15,39 82.15,38.83 81.97,38.65 81.79,38.65 81.58,38.86 81.4,38.86 81.22,38.68 81.22,38.5 81.43,38.29 81.43,38.11 80.73,37.4 80.73,34.02 v2(81.43,33.32)
  BOTTOM w0.089: v2(78.04,86.41) 77.57,85.94 JCPU1.J7
  BOTTOM w0.102: JDIMM2.146 80.42,34.33 v2(81.43,33.32)
DDR_B_D45: length 71.7
  IN2 w0.089: v2(78.04,88.41) 78.04,87.24 80.62,84.66 80.62,81.32 80.89,81.05 81.2,81.05 81.68,80.57 81.68,80.26 81.89,80.05 84.61,80.05 85.03,79.63 86.25,79.63 87.23,78.65
  IN2 w0.127: 87.23,78.65 91.52,74.36 91.52,60.69 90.17,59.34 90.17,58.65 87.37,55.85 87.37,50.01 86.04,48.69 86.04,47.79 84.8,46.54 84.8,45.16 83.87,44.23 83.87,39.93 82.41,38.47 82.41,37.87 82.2,37.66 81.53,37.66 81.4,37.54 81.4,37.12 81.53,37 82.19,37 82.32,36.87 82.32,36.62 82.19,36.49 81.55,36.49 81.43,36.36 81.43,36.11 81.55,35.98 82.19,35.98 82.32,35.85 82.32,35.6 82.19,35.47 81.55,35.47 81.43,35.35 v2(81.43,34.84)
  BOTTOM w0.089: JCPU1.J9 77.57,87.94 v2(78.04,88.41)
  BOTTOM w0.102: v2(81.43,34.84) 81.02,35.25 JDIMM2.148
DDR_B_D46: length 72.3
  IN2 w0.089: v2(80.04,89.41) 81.59,87.86 81.59,86.23 81.83,85.99 82.28,85.99 82.62,85.65 82.62,85.18 82.81,84.99 83.28,84.99 83.62,84.65 83.62,83.32 83.89,83.05 86.42,83.05 87.23,82.23
  IN2 w0.127: v2(84.7,33.32) 86.52,35.14 86.52,43.32 88.25,45.05 88.25,46.44 89.49,47.69 89.49,48.65 91.23,50.39 91.23,56.14 93.99,58.89 93.99,61.32 94.57,61.91 94.57,74.89 87.23,82.23
  BOTTOM w0.089: v2(80.04,89.41) 79.57,88.94 JCPU1.G10
  BOTTOM w0.102: v2(84.7,33.32) 84.02,34 JDIMM2.158
DDR_B_D47: length 71.9
  IN2 w0.089: 87.23,81.7 86.87,82.05 85.48,82.05 84.67,82.87 83.82,82.87 83.44,83.24 83.44,84.57 83.21,84.81 82.73,84.81 82.44,85.1 82.44,85.57 82.21,85.81 81.76,85.81 81.41,86.16 81.41,87.79 80.21,88.99 78.46,88.99 v2(78.04,89.41)
  IN2 w0.127: 87.23,81.7 94.19,74.73 94.19,62.07 93.61,61.48 93.61,59.05 90.85,56.29 90.85,50.55 89.11,48.81 89.11,47.91 87.23,46.03 87.23,44.63 86.14,43.54 86.14,39.96 86.01,39.84 85.52,39.84 85.39,39.71 85.39,39.46 85.52,39.33 86.01,39.33 86.14,39.2 86.14,38.95 86.01,38.82 85.52,38.82 85.39,38.69 85.39,35.54 v2(84.7,34.84)
  BOTTOM w0.089: v2(78.04,89.41) 77.57,88.94 JCPU1.J10
  BOTTOM w0.102: v2(84.7,34.84) 84.62,34.92 JDIMM2.160
DDR_B_D48: length 75.7
  IN2 w0.089: 87.23,86.59 86,86.59 85.87,86.72 85.87,87.23 86,87.36 v2(86.09,87.36)
  IN2 w0.127: v2(87.86,40.91) 88.22,40.91 88.35,41.04 88.35,42.77 89.92,44.35 89.92,45.75 91.85,47.68 91.85,48.64 93.69,50.48 93.69,55.9 96.39,58.59 96.39,66.41 96.51,66.53 97.79,66.53 97.92,66.66 97.92,66.91 97.79,67.04 96.51,67.04 96.39,67.17 96.39,67.42 96.51,67.55 97.79,67.55 97.92,67.68 97.92,67.93 97.79,68.06 96.51,68.06 96.39,68.18 96.39,68.44 96.51,68.56 97.79,68.56 97.92,68.69 97.92,68.95 97.79,69.07 96.51,69.07 96.39,69.2 96.39,69.45 96.51,69.58 97.79,69.58 97.92,69.71 97.92,83.7 95.03,86.59 87.23,86.59
  BOTTOM w0.089: v2(86.09,87.36) 85.67,86.94 JCPU1.A8
  BOTTOM w0.102: JDIMM2.163 85.51,43.64 87.08,42.08 87.08,41.7 v2(87.86,40.91)
DDR_B_D49: length 76.9
  IN2 w0.089: v2(85.03,87.39) 85.03,87.3 86.31,86.03 87.23,86.03
  IN2 w0.127: v2(87.86,42.43) 87.86,42.83 89.54,44.51 89.54,45.91 91.47,47.84 91.47,48.8 93.31,50.64 93.31,56.06 95.93,58.68 95.93,70.09 96.06,70.22 97.19,70.22 97.32,70.35 97.32,70.6 97.19,70.73 96.06,70.73 95.93,70.85 95.93,71.11 96.06,71.23 97.28,71.23 97.41,71.36 97.41,71.62 97.28,71.74 96.06,71.74 95.93,71.87 95.93,72.12 96.06,72.25 97.28,72.25 97.41,72.38 97.41,72.63 97.28,72.76 96.06,72.76 95.93,72.89 95.93,73.14 96.06,73.27 97.28,73.27 97.41,73.39 97.41,73.65 97.28,73.77 96.06,73.77 95.93,73.9 95.93,74.16 96.06,74.28 97.28,74.28 97.41,74.41 97.41,74.66 97.28,74.79 96.06,74.79 95.93,74.92 95.93,75.37 96.15,75.58 97.26,75.58 97.54,75.86 97.54,83.46 94.97,86.03 87.23,86.03
  BOTTOM w0.089: JCPU1.B8 84.59,86.94 v2(85.03,87.39)
  BOTTOM w0.102: JDIMM2.165 86.12,43.47 87.15,42.43 v2(87.86,42.43)
DDR_B_D50: length 76.3
  IN2 w0.089: v2(86.04,88.41) 86.64,88.41 87.03,88.02 87.23,88.02
  IN2 w0.127: 87.23,88.02 95.83,88.02 99.24,84.61 99.24,65.49 99.67,65.05 99.67,61.71 99.55,61.59 98.98,61.59 98.85,61.46 98.85,61.2 98.98,61.08 99.55,61.08 99.67,60.95 99.67,60.7 99.55,60.57 98.63,60.57 98.5,60.44 98.5,60.19 98.63,60.06 99.55,60.06 99.67,59.93 99.67,59.23 98.69,58.25 98.51,58.25 98.3,58.46 98.13,58.46 97.95,58.28 97.95,58.1 98.15,57.89 98.15,57.71 97.97,57.53 97.79,57.53 97.59,57.74 97.41,57.74 97.23,57.56 97.23,57.38 97.44,57.17 97.44,56.99 97.26,56.81 97.08,56.81 96.87,57.02 96.69,57.02 95.75,56.09 95.75,55.79 95.62,55.66 95.33,55.66 95.2,55.54 95.2,55.28 95.33,55.16 95.62,55.16 95.75,55.03 95.75,54.78 95.62,54.65 95.36,54.65 95.23,54.52 95.23,54.27 95.36,54.14 95.62,54.14 95.75,54.01 95.75,53.76 95.62,53.63 95.48,53.63 95.35,53.51 95.35,53.25 95.48,53.12 95.62,53.12 95.75,53 95.75,52.74 95.62,52.62 95.48,52.62 95.35,52.49 95.35,52.24 95.48,52.11 95.62,52.11 95.75,51.98 95.75,51.63 95.62,51.5 95.27,51.5 95.14,51.37 95.14,50.06 93.17,48.09 93.17,47.13 91.24,45.2 91.24,43.8 90.37,42.92 90.37,41.47 v2(90.93,40.91)
  BOTTOM w0.089: JCPU1.A9 85.57,87.94 v2(86.04,88.41)
  BOTTOM w0.102: JDIMM2.175 89.12,43.47 90.22,42.37 90.22,41.63 v2(90.93,40.91)
DDR_B_D51: length 78
  IN2 w0.089: v2(85.04,88.41) 85.04,88.42 85.44,88.82 86.68,88.82 87.1,88.4 87.23,88.4
  IN2 w0.127: 87.23,88.4 95.99,88.4 100.05,84.33 100.05,83.9 99.93,83.77 99.75,83.77 99.62,83.65 99.62,83.39 99.75,83.27 99.93,83.27 100.05,83.14 100.05,82.88 99.93,82.76 99.75,82.76 99.62,82.63 99.62,82.38 99.75,82.25 99.93,82.25 100.05,82.12 100.05,81.87 99.93,81.74 99.75,81.74 99.62,81.61 99.62,81.36 99.75,81.23 99.93,81.23 100.05,81.11 100.05,80.85 99.93,80.73 99.75,80.73 99.62,80.6 99.62,80.34 99.75,80.22 99.93,80.22 100.05,80.09 100.05,79.84 99.93,79.71 99.75,79.71 99.62,79.58 99.62,79.33 99.75,79.2 99.93,79.2 100.05,79.07 100.05,78.82 99.93,78.69 99.75,78.69 99.62,78.57 99.62,78.31 99.75,78.19 99.93,78.19 100.05,78.06 100.05,77.5 99.93,77.38 99.75,77.38 99.62,77.25 99.62,77 99.75,76.87 99.93,76.87 100.05,76.74 100.05,76.49 99.93,76.36 99.75,76.36 99.62,76.23 99.62,75.98 99.75,75.85 99.93,75.85 100.05,75.73 100.05,75.47 99.93,75.35 99.75,75.35 99.62,75.22 99.62,74.96 99.75,74.84 99.93,74.84 100.05,74.71 100.05,74.46 99.93,74.33 99.75,74.33 99.62,74.2 99.62,73.95 99.75,73.82 99.93,73.82 100.05,73.69 100.05,73.44 99.93,73.31 99.75,73.31 99.62,73.19 99.62,72.93 99.75,72.81 99.93,72.81 100.05,72.68 100.05,72.42 99.93,72.3 99.75,72.3 99.62,72.17 99.62,71.92 99.75,71.79 99.93,71.79 100.05,71.66 100.05,71.41 99.93,71.28 99.75,71.28 99.62,71.15 99.62,65.64 100.05,65.21 100.05,59.07 97.59,56.61 97.59,56.06 97.52,55.99 96.97,55.99 96.77,55.79 96.77,55.42 96.9,55.3 97.56,55.3 97.69,55.17 97.69,54.92 97.56,54.79 96.9,54.79 96.77,54.66 96.77,54.41 96.9,54.28 97.56,54.28 97.68,54.15 97.68,53.9 97.56,53.77 96.9,53.77 96.77,53.65 96.77,53.39 96.9,53.26 97.43,53.26 97.56,53.14 97.56,52.88 97.43,52.76 96.9,52.76 96.77,52.63 96.77,51.02 93.55,47.8 93.55,46.02 91.63,44.09 91.63,43.12 v2(90.93,42.43)
  BOTTOM w0.089: v2(85.04,88.41) 84.57,87.94 JCPU1.B9
  BOTTOM w0.102: v2(90.93,42.43) 89.72,43.65 JDIMM2.177
DDR_B_D52: length 78.5
  IN2 w0.089: v2(83.04,87.41) 83.48,86.97 85.12,86.97 86.44,85.65 87.23,85.65
  IN2 w0.127: 87.23,85.65 94.81,85.65 97.16,83.3 97.16,77.13 95.55,75.53 95.55,61.59 94.9,60.94 94.9,58.18 92.93,56.21 92.93,50.79 91.09,48.95 91.09,48 89.16,46.07 89.16,44.67 87.43,42.94 87.43,39.58 87.56,39.45 88.64,39.45 88.77,39.32 88.77,39.07 88.64,38.94 87.56,38.94 87.43,38.81 87.43,37.31 87.56,37.19 88.37,37.19 88.5,37.06 88.5,36.81 88.37,36.68 87.56,36.68 87.43,36.55 87.43,33.77 v2(86.98,33.32)
  BOTTOM w0.089: v2(83.04,87.41) 82.57,86.94 JCPU1.D8
  BOTTOM w0.102: JDIMM2.164 85.82,34.49 v2(86.98,33.32)
DDR_B_D53: length 78.5
  IN2 w0.089: 86.86,85.27 86.77,85.27 86.56,85.06 84.95,85.06 84.44,85.57 84.44,85.71 84.14,86 82.85,86 82.48,86.37 82.48,86.97 v2(82.04,87.41)
  IN2 w0.127: 86.86,85.27 87.27,85.27 87.4,85.14 87.4,84.04 87.53,83.91 87.78,83.91 87.91,84.04 87.91,85.14 88.04,85.27 88.29,85.27 88.42,85.14 88.42,84.11 88.54,83.98 88.8,83.98 88.92,84.11 88.92,85.14 89.05,85.27 89.31,85.27 89.43,85.14 89.43,84.35 89.56,84.22 89.81,84.22 89.94,84.35 89.94,85.14 90.07,85.27 94.65,85.27 96.78,83.14 96.78,77.29 95.17,75.68 95.17,61.75 94.52,61.1 94.52,58.67 91.77,55.91 91.77,50.17 90.02,48.43 90.02,47.47 88.78,46.22 88.78,44.83 87.05,43.1 87.05,34.91 v2(86.98,34.84)
  BOTTOM w0.089: v2(82.04,87.41) 81.57,86.94 JCPU1.E8
  BOTTOM w0.102: JDIMM2.166 86.42,35.41 v2(86.98,34.84)
DDR_B_D54: length 80
  IN2 w0.089: 87.23,89.4 86.62,89.4 86.23,89 83.71,89 83.12,88.41 v2(83.04,88.41)
  IN2 w0.127: v2(89.4,33.32) 88.93,33.78 88.93,37.16 92.01,40.23 92.01,43.93 93.94,45.86 93.94,47.64 97.15,50.86 97.15,51.9 97.94,52.69 97.94,53.62 98.92,54.6 98.92,57.4 100.44,58.92 100.44,84.49 95.53,89.4 87.23,89.4
  BOTTOM w0.089: JCPU1.D9 82.57,87.94 v2(83.04,88.41)
  BOTTOM w0.102: v2(89.4,33.32) 88.82,33.9 JDIMM2.174
DDR_B_D55: length 79
  IN2 w0.089: 87.23,89.78 86.47,89.78 86.36,89.89 82.77,89.89 82.54,89.66 82.54,88.62 82.3,88.38 v2(82.02,88.38)
  IN2 w0.127: v2(89.4,34.84) 89.4,37.09 92.39,40.08 92.39,43.77 94.32,45.7 94.32,47.48 97.54,50.7 97.54,51.74 98.32,52.53 98.32,53.46 99.3,54.44 99.3,57.24 100.82,58.76 100.82,84.65 95.69,89.78 87.23,89.78
  BOTTOM w0.089: JCPU1.E9 81.59,87.94 v2(82.02,88.38)
  BOTTOM w0.102: v2(89.4,34.84) 89.42,34.86 JDIMM2.176
DDR_B_D56: length 87.4
  IN2 w0.089: v2(82.1,94.41) 82.47,94.04 82.47,92.82 82.63,92.65 82.63,91.25 82.87,91.01 86.57,91.01 86.89,90.69 87.23,90.69
  IN2 w0.127: v2(93.82,40.91) 93.3,41.42 93.3,43.39 95.69,45.78 95.69,47.56 98.45,50.32 98.45,51.36 99.16,52.07 100.43,52.07 100.56,51.94 100.56,51.62 100.68,51.49 100.94,51.49 101.07,51.62 101.07,51.94 101.19,52.07 101.6,52.07 101.73,52.2 101.73,52.77 101.6,52.9 101.07,52.9 100.95,53.02 100.95,53.28 101.07,53.4 101.6,53.4 101.73,53.53 101.73,53.79 101.6,53.91 101.07,53.91 100.95,54.04 100.95,54.29 101.07,54.42 101.6,54.42 101.73,54.55 101.73,54.8 101.6,54.93 101.07,54.93 100.95,55.06 100.95,55.31 101.07,55.44 101.6,55.44 101.73,55.56 101.73,55.82 101.6,55.94 101.07,55.94 100.95,56.07 100.95,56.33 101.07,56.45 101.6,56.45 101.73,56.58 101.73,56.83 101.6,56.96 101.07,56.96 100.95,57.09 100.95,57.34 101.07,57.47 101.6,57.47 101.73,57.6 101.73,85.03 96.07,90.69 87.23,90.69
  BOTTOM w0.089: v2(82.1,94.41) 82.1,94.4 81.65,93.94 JCPU1.E15
  BOTTOM w0.102: v2(93.82,40.91) 93.8,40.91 91.37,43.33 91.07,43.33 90.91,43.49 JDIMM2.181
DDR_B_D57: length 86.9
  IN2 w0.089: 87.23,91.07 87.09,91.07 86.34,91.82 83.8,91.82 83.45,92.18 83.45,92.58 83.17,92.86 82.91,92.86 82.66,93.11 82.66,93.74 82.76,93.84 83.17,93.84 83.3,93.96 83.3,94.28 83.17,94.41 v2(83.04,94.41)
  IN2 w0.127: 87.23,91.07 89.74,91.07 89.87,91.2 89.87,91.45 90,91.58 90.25,91.58 90.38,91.45 90.38,91.2 90.51,91.07 90.76,91.07 90.89,91.2 90.89,91.45 91.01,91.58 91.27,91.58 91.4,91.45 91.4,91.2 91.52,91.07 91.78,91.07 91.9,91.2 91.9,91.45 92.03,91.58 92.28,91.58 92.41,91.45 92.41,91.2 92.54,91.07 96.23,91.07 102.11,85.19 102.11,51.44 101.03,50.35 100.85,50.35 99.73,51.46 99.55,51.46 99.37,51.28 99.37,51.1 100.49,49.99 100.49,49.81 100.31,49.63 100.13,49.63 99.74,50.02 99.56,50.02 99.38,49.84 99.38,49.66 99.77,49.27 99.77,49.09 98.94,48.27 98.54,48.27 97.88,48.92 97.7,48.92 97.52,48.74 97.52,48.56 98.18,47.91 98.18,47.73 98,47.55 97.82,47.55 97.11,48.26 96.93,48.26 96.75,48.08 96.75,47.9 97.46,47.19 97.46,47.01 93.82,43.37 v2(93.82,42.43)
  BOTTOM w0.089: v2(83.04,94.41) 82.57,93.94 JCPU1.D15
  BOTTOM w0.102: JDIMM2.183 91.51,43.62 92.7,42.43 v2(93.82,42.43)
DDR_B_D58: length 86.4
  IN2 w0.089: v2(86.04,94.41) 86.12,94.33 86.91,94.33 87.18,94.6 87.23,94.6
  IN2 w0.127: v2(96.91,40.64) 97.48,40.64 99.46,42.61 99.46,42.95 98.64,43.76 98.64,43.94 98.82,44.12 99,44.12 99.91,43.22 100.09,43.22 100.27,43.4 100.27,43.58 99.36,44.48 99.36,44.66 99.54,44.84 99.72,44.84 100.83,43.73 101.01,43.73 101.19,43.91 101.19,44.09 100.08,45.2 100.08,45.38 100.26,45.56 100.44,45.56 101.25,44.75 101.43,44.75 104.96,48.27 104.96,86.37 96.72,94.6 87.23,94.6
  BOTTOM w0.089: v2(86.04,94.41) 85.57,93.94 JCPU1.A15
  BOTTOM w0.102: JDIMM2.191 93.91,43.63 96.91,40.64 v2(96.91,40.64)
DDR_B_D59: length 86.1
  IN2 w0.089: 87.23,94.22 87.18,94.22 86.96,94 85.45,94 v2(85.04,94.41)
  IN2 w0.127: 87.23,94.22 96.56,94.22 104.58,86.21 104.58,50.41 103.85,49.69 103.85,49.56 104.58,48.83 104.58,48.43 104.34,48.2 104.17,48.2 103.35,49.01 103.17,49.01 102.99,48.83 102.99,48.65 103.81,47.84 103.81,47.66 103.63,47.48 103.45,47.48 102.63,48.29 102.45,48.29 102.27,48.11 102.27,47.93 103.09,47.12 103.09,46.94 102.91,46.76 102.73,46.76 101.91,47.57 101.74,47.57 101.48,47.32 101.48,47.14 102.09,46.54 102.09,46.36 101.91,46.18 101.73,46.18 101.12,46.78 100.95,46.78 98.25,44.09 98.25,43.61 98.72,43.15 98.72,42.41 97.98,41.68 97.4,41.68 v2(96.91,42.16)
  BOTTOM w0.089: v2(85.04,94.41) 84.57,93.94 JCPU1.B15
  BOTTOM w0.102: v2(96.91,42.16) 96,42.16 94.51,43.64 JDIMM2.193
DDR_B_D60: length 87.3
  IN2 w0.089: 87.23,90.31 86.72,90.31 86.2,90.83 82.8,90.83 82.46,91.17 82.46,92.58 82.07,92.97 v2(82.07,93.41)
  IN2 w0.127: v2(91.68,32.18) 90.62,33.24 90.62,37.55 92.92,39.86 92.92,43.55 95.31,45.94 95.31,47.72 98.07,50.48 98.07,51.52 99,52.45 99.79,52.45 100.43,53.09 100.43,57.62 101.35,58.54 101.35,84.87 95.91,90.31 87.23,90.31
  BOTTOM w0.089: JCPU1.E14 81.6,92.94 v2(82.07,93.41)
  BOTTOM w0.102: JDIMM2.180 90.62,33.25 v2(91.68,32.18)
DDR_B_D61: length 85.6
  IN2 w0.089: 87.23,91.45 86.69,92 83.88,92 83.62,92.25 83.62,92.85 v2(83.09,93.38)
  IN2 w0.127: v2(91.68,33.7) 91.68,34.13 91.56,34.26 91.12,34.26 91,34.39 91,34.64 91.12,34.77 91.56,34.77 91.68,34.9 91.68,35.25 91.56,35.37 91.12,35.37 91,35.5 91,35.76 91.12,35.88 91.56,35.88 91.68,36.01 91.68,37.42 94.79,40.53 94.79,43.81 96.62,45.63 96.85,45.63 102.49,51.28 102.49,85.34 96.38,91.45 93.48,91.45 92.94,92 89.62,92 89.08,91.45 87.23,91.45
  BOTTOM w0.089: JCPU1.D14 82.65,92.94 v2(83.09,93.38)
  BOTTOM w0.102: JDIMM2.182 91.21,34.17 v2(91.68,33.7)
DDR_B_D62: length 86.4
  IN2 w0.089: 87.23,93.41 v2(86.04,93.41)
  IN2 w0.127: v2(94.95,32.56) 94,33.51 94,34.62 95.19,35.82 95.99,35.82 96.11,35.94 96.11,36.54 95.99,36.67 95.24,36.67 95.11,36.8 95.11,37.05 95.24,37.18 95.99,37.18 96.11,37.3 96.11,43.26 97.17,44.31 97.39,44.31 103.81,50.73 103.81,85.89 96.26,93.44 89.16,93.44 88.51,92.8 87.95,92.8 87.34,93.41 87.23,93.41
  BOTTOM w0.089: v2(86.04,93.41) 85.57,92.94 JCPU1.A14
  BOTTOM w0.102: v2(94.95,32.56) 94.21,33.3 JDIMM2.192
DDR_B_D63: length 86.2
  IN2 w0.089: v2(85.04,93.41) 85.46,93.82 87.23,93.82
  IN2 w0.127: v2(94.95,34.08) 96.5,35.62 96.5,37.44 96.62,37.57 97.53,37.57 97.66,37.69 97.66,37.95 97.53,38.07 96.62,38.07 96.5,38.2 96.5,38.46 96.62,38.58 97.83,38.58 97.96,38.71 97.96,38.96 97.83,39.09 96.62,39.09 96.5,39.22 96.5,43.1 97.28,43.89 97.51,43.89 104.19,50.57 104.19,86.05 96.42,93.82 87.23,93.82
  BOTTOM w0.089: JCPU1.B14 84.57,92.94 v2(85.04,93.41)
  BOTTOM w0.102: JDIMM2.194 94.82,34.22 v2(94.95,34.08)
DDR_B_DQS0: length 85.5
  IN2 w0.089: v2(51.98,95.46) 52.38,95.46 52.5,95.59 52.5,95.84 52.38,95.96 51.61,95.96 50.16,94.51 48.47,94.51 48.24,94.28
  IN2 w0.127: 48.24,94.28 43.52,89.56 38.08,89.56 29.97,81.45 29.97,48 34.83,43.14 34.83,39.5 35.81,38.52 36.52,37.81 36.52,34.16 37.2,33.48 37.37,33.48 v2(37.57,33.68)
  BOTTOM w0.089: JCPU1.AP17 52.46,95.94 v2(51.98,95.46)
  BOTTOM w0.102: JDIMM2.12 37.82,35.47 37.59,35.25 37.59,35.05 36.95,34.41 36.95,33.62 37.13,33.44 37.33,33.44 v2(37.57,33.68)
DDR_B_DQS1: length 77.9
  IN2 w0.089: v2(52.04,90.41) 51.87,90.25 51.87,90.25 51.4,89.78 51.4,89.23 51.17,89 49.13,89 48.32,88.19 48.28,88.15 48.25,88.15 48.24,88.14
  IN2 w0.127: 48.24,88.14 45.78,85.68 39.7,85.68 33.86,79.84 33.86,73.08 34.13,72.81 35.45,72.81 35.58,72.68 35.58,72.3 35.45,72.17 34.13,72.17 33.86,71.9 33.86,71.31 34.13,71.03 35.45,71.03 35.58,70.9 35.58,70.52 35.45,70.4 34.13,70.4 33.86,70.12 33.86,69.53 34.13,69.25 35.45,69.25 35.58,69.13 35.58,59.29 36.3,58.57 36.3,49.08 39.93,45.45 39.93,41.05 40.21,40.77 40.5,40.77 v2(40.74,40.53)
  BOTTOM w0.089: v2(52.04,90.41) 52.51,90.88 JCPU1.AP12
  BOTTOM w0.102: v2(40.74,40.53) 40.96,40.74 41.44,40.74 41.74,41.05 41.74,42.28 42.72,43.26 42.72,43.45 42.92,43.65 JDIMM2.29
DDR_B_DQS2: length 65.2
  IN2 w0.089: v2(52.04,84.41) 52.04,84.25 51.91,84.13 51.7,84.13 51.42,83.84 51.42,80.25 51.19,80.02 48.7,80.02 48.24,79.56
  IN2 w0.127: 48.24,79.56 41.28,72.6 41.28,66.37 41.15,66.24 40.44,66.24 40.16,65.96 40.16,65.37 40.44,65.1 41.15,65.1 41.28,64.97 41.28,64.59 41.15,64.46 39.99,64.46 39.72,64.19 39.72,63.59 39.99,63.32 41.15,63.32 41.28,63.19 41.28,62.81 41.15,62.68 40.05,62.68 39.78,62.41 39.78,61.82 40.05,61.54 41.15,61.54 41.28,61.41 41.28,60.32 42.27,59.33 42.27,50.96 45.12,48.11 45.12,41.03 45.37,40.78 45.62,40.78 v2(45.85,40.55)
  BOTTOM w0.089: v2(52.04,84.41) 52.51,84.88 JCPU1.AP6
  BOTTOM w0.102: v2(45.85,40.55) 46.11,40.8 46.4,40.8 46.76,41.16 46.76,42.39 47.33,42.97 47.91,42.97 48.14,43.19 48.14,43.46 48.32,43.64 JDIMM2.47
DDR_B_DQS3: length 61.6
  IN2 w0.089: v2(56.04,81.41) 56.29,81.41 56.4,81.3 56.4,81.11 56.3,81.01 55.81,81.01 55.46,80.66 55.46,79.77 53.64,77.95 52.49,77.95 51.67,77.14
  IN2 w0.127: 51.67,77.14 47.29,72.75 47.29,58.32 48.52,57.09 48.52,50.57 49.73,49.36 49.73,43.96 50.22,43.46 50.22,39.82 50.1,39.69 49.79,39.69 49.52,39.42 49.52,38.83 49.79,38.55 50.1,38.55 50.22,38.42 50.22,35.92 50.86,35.28 50.86,33.52 51.17,33.21 51.42,33.21 51.69,32.94 v2(51.69,32.94)
  BOTTOM w0.089: JCPU1.AK3 56.51,81.88 v2(56.04,81.41)
  BOTTOM w0.102: v2(51.69,32.94) 52,33.25 52.55,33.25 53.22,33.92 53.22,35.24 53.41,35.44 JDIMM2.64
DDR_B_DQS4: length 64.3
  IN2 w0.089: 78.65,78.3 78.64,78.29 78.62,78.29 78.62,78.29 78.56,78.24 78.44,78.24 78.44,78.24 77.76,78.24 77.46,78.54 77.46,79.66 77.34,79.78 76.66,79.78 76.41,80.02 76.41,80.64 76.27,80.78 75.77,80.78 75.58,80.98 75.58,81.45 75.45,81.58 75.17,81.58 75.04,81.45 v2(75.04,81.41)
  IN2 w0.127: v2(79.03,41.29) 79.31,41.01 79.45,41.01 79.55,41.11 79.55,43.12 80.18,43.75 80.18,48.24 82.33,50.39 82.33,56.39 85.32,59.38 85.32,59.93 86.07,60.68 86.07,64.65 86.35,64.93 86.87,64.93 86.99,65.05 86.99,65.44 86.87,65.56 86.35,65.56 86.07,65.84 86.07,66.46 86.35,66.73 86.87,66.73 86.99,66.86 86.99,67.24 86.87,67.37 86.35,67.37 86.07,67.65 86.07,68.24 86.35,68.51 86.84,68.51 86.97,68.64 86.97,69.02 86.84,69.15 86.35,69.15 86.07,69.42 86.07,70.02 86.35,70.29 86.87,70.29 86.99,70.42 86.99,70.8 86.87,70.93 86.35,70.93 86.07,71.2 86.07,71.79 86.35,72.07 86.87,72.07 86.99,72.2 86.99,72.58 86.87,72.7 86.35,72.7 86.07,72.98 86.07,73.49 82.46,77.09 81.02,77.09 79.65,78.46 78.81,78.46 78.65,78.3
  BOTTOM w0.089: v2(75.04,81.41) 74.51,81.94 JCPU1.M3
  BOTTOM w0.102: v2(79.03,41.29) 79.03,41.05 78.88,40.91 78.39,40.91 78.04,41.26 78.04,42.74 77.52,43.25 77.52,43.42 77.72,43.61 JDIMM2.137
DDR_B_DQS5: length 72.9
  IN2 w0.089: 87.23,79.4 86.77,79.87 85.17,79.87 84.22,80.82 81.79,80.82 81.44,81.16 81.44,84.35 79.45,86.34 79.45,87.8 79.33,87.92 78.79,87.92 78.66,87.79 78.66,87.54 78.79,87.41 v2(79.04,87.41)
  IN2 w0.127: v2(83.17,33.7) 83.41,33.47 83.71,33.47 83.84,33.59 83.84,37.25 83.71,37.37 83.63,37.37 83.36,37.65 83.36,38.24 83.63,38.52 84.18,38.52 84.4,38.73 84.4,44.01 85.68,45.29 85.68,46.67 86.58,47.57 86.58,48.46 88.35,50.24 88.35,56.08 91.13,58.86 91.13,59.52 92.06,60.45 92.06,74.58 87.23,79.4
  BOTTOM w0.089: v2(79.04,87.41) 78.57,86.94 JCPU1.H8
  BOTTOM w0.102: v2(83.17,33.7) 83.17,33.49 83.04,33.36 82.83,33.36 82.62,33.57 82.62,35.19 82.81,35.39 JDIMM2.154
DDR_B_DQS6: length 76.8
  IN2 w0.089: 87.23,87.48 87.08,87.48 86.6,87.96 84.01,87.96 83.93,88.04 83.93,88.3 v2(84.04,88.41)
  IN2 w0.127: 87.23,87.48 95.61,87.48 98.71,84.39 98.71,66.02 98.43,65.74 97.3,65.74 97.17,65.62 97.17,65.24 97.3,65.11 98.5,65.11 98.78,64.83 98.78,64.24 98.5,63.97 97.3,63.97 97.17,63.84 97.17,63.46 97.3,63.33 98.58,63.33 98.85,63.06 98.85,62.27 98.58,61.99 97.38,61.99 97.17,61.79 97.17,58.26 94.48,55.57 94.48,50.15 92.64,48.31 92.64,47.35 90.71,45.42 90.71,44.02 89.14,42.44 89.14,41.19 89.28,41.05 89.42,41.05 v2(89.66,41.29)
  BOTTOM w0.089: JCPU1.C9 83.57,87.94 v2(84.04,88.41)
  BOTTOM w0.102: JDIMM2.171 87.91,43.66 87.72,43.47 87.72,43.32 87.88,43.17 88.15,43.17 88.63,42.69 88.63,41.16 88.77,41.02 89.39,41.02 v2(89.66,41.29)
DDR_B_DQS7: length 88.8
  IN2 w0.089: v2(84.04,94.41) 84.04,93.99 84.09,93.94 84.42,93.94 84.67,93.69 84.67,93.24 84.88,93.02 86.92,93.02 87.23,92.71
  IN2 w0.127: 87.23,92.71 87.7,92.24 88.75,92.24 89.3,92.79 96.17,92.79 103.28,85.67 103.28,50.95 97.17,44.84 96.95,44.84 95.58,43.48 95.58,38.24 95.18,37.84 93.34,37.84 93.22,37.71 93.22,37.16 93.34,37.04 94.31,37.04 94.58,36.76 94.58,35.96 94.31,35.68 92.77,35.68 92.64,35.56 92.64,34.08 92.9,33.82 93.4,33.82 93.46,33.89 v2(93.46,34.08)
  BOTTOM w0.089: JCPU1.C15 83.57,93.94 v2(84.04,94.41)
  BOTTOM w0.102: v2(93.46,34.08) 93.19,33.81 92.97,33.81 92.82,33.96 92.82,35.04 93.02,35.23 JDIMM2.188
DDR_B_DQS#0: length 85.5
  IN2 w0.089: 48.24,94.64 48.33,94.73 50.07,94.73 51.52,96.18 51.85,96.18 52.01,96.33 v2(52.01,96.46)
  IN2 w0.127: v2(37.57,32.91) 37.26,33.22 37.1,33.22 36.27,34.05 36.27,37.7 34.57,39.4 34.57,43.04 29.72,47.89 29.72,81.56 37.97,89.82 43.42,89.82 48.24,94.64
  BOTTOM w0.089: v2(52.01,96.46) 52.49,96.94 JCPU1.AP18
  BOTTOM w0.102: v2(37.57,32.91) 37.26,33.22 37.04,33.22 36.74,33.53 36.74,34.49 37.38,35.14 37.38,35.28 37.22,35.44 JDIMM2.10
DDR_B_DQS#1: length 77.9
  IN2 w0.089: v2(52.04,89.41) 52.21,89.41 52.43,89.64 52.43,89.9 52.3,90.03 51.96,90.03 51.62,89.69 51.62,89.14 51.26,88.78 49.22,88.78 48.42,87.99 48.43,87.98 48.43,87.97 48.42,87.96
  IN2 w0.127: v2(40.74,41.29) 40.47,41.02 40.32,41.02 40.19,41.15 40.19,45.55 36.55,49.19 36.55,58.68 35.83,59.4 35.83,69.23 35.56,69.51 34.24,69.51 34.11,69.63 34.11,70.01 34.24,70.14 35.56,70.14 35.83,70.42 35.83,71.01 35.56,71.28 34.24,71.28 34.11,71.41 34.11,71.79 34.24,71.92 35.56,71.92 35.83,72.2 35.83,72.79 35.56,73.06 34.24,73.06 34.11,73.19 34.11,79.73 39.8,85.42 45.89,85.42 48.42,87.96
  BOTTOM w0.089: JCPU1.AP11 52.51,89.88 v2(52.04,89.41)
  BOTTOM w0.102: JDIMM2.27 42.32,43.63 42.5,43.45 42.5,43.35 41.52,42.37 41.52,41.14 41.35,40.96 41.07,40.96 v2(40.74,41.29)
DDR_B_DQS#2: length 65.2
  IN2 w0.089: 48.24,79.2 48.84,79.8 51.27,79.8 51.63,80.16 51.63,83.75 51.79,83.91 52.16,83.91 52.27,83.8 52.27,83.49 52.19,83.41 v2(52.04,83.41)
  IN2 w0.127: 48.24,79.2 41.53,72.49 41.53,66.26 41.26,65.99 40.55,65.99 40.42,65.86 40.42,65.48 40.55,65.35 41.26,65.35 41.53,65.07 41.53,64.48 41.26,64.21 40.1,64.21 39.97,64.08 39.97,63.7 40.1,63.57 41.26,63.57 41.53,63.3 41.53,62.7 41.26,62.43 40.16,62.43 40.03,62.3 40.03,61.92 40.16,61.79 41.26,61.79 41.53,61.52 41.53,60.42 42.52,59.43 42.52,51.07 45.37,48.22 45.37,41.14 45.48,41.03 45.58,41.03 v2(45.85,41.31)
  BOTTOM w0.089: v2(52.04,83.41) 51.88,83.57 51.88,83.82 52,83.94 JCPU1.AP5
  BOTTOM w0.102: v2(45.85,41.31) 45.85,41.2 46.03,41.02 46.31,41.02 46.54,41.25 46.54,42.48 47.24,43.18 47.82,43.18 47.92,43.28 47.92,43.45 47.72,43.66 JDIMM2.45
DDR_B_DQS#3: length 61.7
  IN2 w0.089: v2(57.04,81.41) 57.04,81.73 56.91,81.86 56.72,81.86 56.59,81.73 56.59,81.41 56.62,81.39 56.62,81.02 56.39,80.79 55.9,80.79 55.67,80.57 55.67,79.68 53.73,77.74 52.58,77.74 51.98,77.14
  IN2 w0.127: v2(51.69,33.7) 51.45,33.46 51.28,33.46 51.12,33.62 51.12,35.38 50.48,36.02 50.48,38.53 50.2,38.8 49.9,38.8 49.77,38.93 49.77,39.31 49.9,39.44 50.2,39.44 50.48,39.72 50.48,43.56 49.98,44.06 49.98,49.47 48.78,50.67 48.78,57.19 47.54,58.42 47.54,72.65 51.86,76.97 51.86,76.99 51.91,77.04 51.91,77.07 51.98,77.14
  BOTTOM w0.089: JCPU1.AJ3 57.51,81.88 v2(57.04,81.41)
  BOTTOM w0.102: v2(51.69,33.7) 51.92,33.47 52.46,33.47 53,34.01 53,35.18 52.81,35.37 JDIMM2.62
DDR_B_DQS#4: length 64.4
  IN2 w0.089: v2(76.04,81.41) 75.91,81.41 75.79,81.29 75.79,81.07 75.86,81 76.36,81 76.63,80.73 76.63,80.11 76.75,79.99 77.43,79.99 77.68,79.75 77.68,78.63 77.85,78.46 78.44,78.46 78.46,78.48 78.47,78.48
  IN2 w0.127: 78.47,78.48 78.7,78.71 79.76,78.71 81.12,77.35 82.57,77.35 86.32,73.59 86.32,73.08 86.45,72.96 86.97,72.96 87.25,72.68 87.25,72.09 86.97,71.81 86.45,71.81 86.32,71.69 86.32,71.31 86.45,71.18 86.97,71.18 87.25,70.9 87.25,70.31 86.97,70.04 86.45,70.04 86.32,69.91 86.32,69.53 86.45,69.4 86.95,69.4 87.22,69.13 87.22,68.53 86.95,68.26 86.45,68.26 86.32,68.13 86.32,67.75 86.45,67.62 86.97,67.62 87.25,67.35 87.25,66.76 86.97,66.48 86.45,66.48 86.32,66.35 86.32,65.94 86.45,65.82 86.97,65.82 87.25,65.54 87.25,64.95 86.97,64.67 86.45,64.67 86.32,64.55 86.32,60.57 85.57,59.82 85.57,59.27 82.59,56.28 82.59,50.29 80.44,48.14 80.44,43.65 79.8,43.01 79.8,41.01 79.55,40.76 79.26,40.76 v2(79.03,40.53)
  BOTTOM w0.089: v2(76.04,81.41) 75.51,81.94 JCPU1.L3
  BOTTOM w0.102: JDIMM2.135 77.12,43.66 77.31,43.47 77.31,43.16 77.82,42.65 77.82,41.17 78.3,40.69 78.87,40.69 v2(79.03,40.53)
DDR_B_DQS#5: length 73
  IN2 w0.089: v2(79.04,88.41) 79.04,88.28 79.17,88.15 79.4,88.15 79.67,87.89 79.67,86.43 81.66,84.44 81.66,81.25 81.88,81.03 84.31,81.03 85.26,80.08 86.91,80.08 87.23,79.76
  IN2 w0.127: v2(83.17,32.94) 83.45,33.21 83.82,33.21 84.09,33.49 84.09,37.35 83.82,37.63 83.74,37.63 83.61,37.75 83.61,38.13 83.74,38.26 84.29,38.26 84.65,38.63 84.65,43.9 85.94,45.19 85.94,46.57 86.83,47.46 86.83,48.36 88.61,50.13 88.61,55.97 91.39,58.76 91.39,59.42 92.31,60.34 92.31,74.68 87.23,79.76
  BOTTOM w0.089: v2(79.04,88.41) 78.57,87.94 JCPU1.H9
  BOTTOM w0.102: v2(83.17,32.94) 82.99,33.12 82.76,33.12 82.41,33.48 82.41,35.23 82.21,35.42 JDIMM2.152
DDR_B_DQS#6: length 76.7
  IN2 w0.089: v2(84.04,87.41) 84.38,87.75 86.51,87.75 86.99,87.27 87.11,87.27 87.13,87.25 87.2,87.25 87.22,87.23 87.23,87.23
  IN2 w0.127: 87.23,87.23 95.5,87.23 98.45,84.28 98.45,66.13 98.33,66 97.19,66 96.92,65.72 96.92,65.13 97.19,64.86 98.39,64.86 98.52,64.73 98.52,64.35 98.39,64.22 97.19,64.22 96.92,63.95 96.92,63.35 97.19,63.08 98.47,63.08 98.6,62.95 98.6,62.37 98.47,62.25 97.27,62.25 96.92,61.89 96.92,58.37 94.23,55.68 94.23,50.26 92.39,48.42 92.39,47.46 90.46,45.53 90.46,44.12 88.88,42.55 88.88,41.08 89.17,40.79 89.4,40.79 v2(89.66,40.53)
  BOTTOM w0.089: v2(84.04,87.41) 83.57,86.94 JCPU1.C8
  BOTTOM w0.102: v2(89.66,40.53) 89.39,40.81 88.68,40.81 88.41,41.07 88.41,42.6 88.06,42.95 87.79,42.95 87.51,43.24 87.51,43.48 87.32,43.67 JDIMM2.169
DDR_B_DQS#7: length 88.9
  IN2 w0.089: v2(84.04,93.41) 84.04,93.6 84.16,93.72 84.33,93.72 84.45,93.6 84.45,93.15 84.79,92.81 86.77,92.81 87.14,92.44
  IN2 w0.127: 87.14,92.44 87.6,91.99 88.86,91.99 89.4,92.53 96.06,92.53 103.03,85.57 103.03,51.06 97.07,45.1 96.84,45.1 95.33,43.58 95.33,38.35 95.07,38.09 93.24,38.09 92.96,37.82 92.96,37.06 93.24,36.78 94.2,36.78 94.33,36.65 94.33,36.06 94.2,35.94 92.66,35.94 92.39,35.66 92.39,33.97 92.79,33.57 93.22,33.57 v2(93.46,33.32)
  BOTTOM w0.089: JCPU1.C14 83.57,92.94 v2(84.04,93.41)
  BOTTOM w0.102: JDIMM2.186 92.42,35.23 92.61,35.04 92.61,33.87 92.88,33.59 93.19,33.59 v2(93.46,33.32)
DDR_B_MA0: length 73.5
  IN2 w0.089: v2(72.04,86.41) 71.61,86.84 68.88,86.84 68.64,86.6 68.64,84.2 68.33,83.89 67.74,83.89 67.52,83.68 67.52,83.17 67.36,83 65.97,83 65.34,82.37 65.34,81.86 65.16,81.69 65.16,79.03 66,78.19 66,77.14
  IN2 w0.208: 66,77.14 66,64.13 66.2,63.92 69,63.92 69.21,63.72 69.21,59.29 68.14,58.22 66.74,58.22 65.48,56.96 65.48,48.93 65.79,48.62 65.79,43.03 65.06,42.29 65.06,36.34 65.26,36.13 66.12,36.13 66.24,36.01 66.24,32.79 v2(65.63,32.18)
  BOTTOM w0.089: v2(72.04,86.41) 71.51,86.94 JCPU1.R8
  BOTTOM w0.165: JDIMM2.98 66.02,35.2 66.21,35 66.21,32.45 65.94,32.18 v2(65.63,32.18)
DDR_B_MA1: length 70.9
  IN2 w0.089: 64.73,78.1 64.73,78.95 64.8,79.02 64.8,81.84 64.98,82.01 64.98,82.52 65.56,83.11 65.56,83.55 65.86,83.84 66.2,83.84 66.64,83.4 v2(67.04,83.4)
  IN2 w0.208: 64.73,78.1 64.73,68.81 64.25,68.32 64.25,65.04 64.12,64.91 63.11,64.91 62.98,64.79 62.98,64.21 63.11,64.08 64.12,64.08 64.25,63.95 64.25,63.38 64.12,63.25 62.24,63.25 62.11,63.12 62.11,62.54 62.24,62.42 64.12,62.42 64.25,62.29 64.25,61.71 64.12,61.58 62.24,61.58 62.11,61.46 62.11,60.88 62.24,60.75 64.12,60.75 64.25,60.62 64.25,60.04 64.12,59.92 62.24,59.92 62.11,59.79 62.11,59.21 62.24,59.08 64.12,59.08 64.25,58.96 64.25,58.38 64.12,58.25 62.91,58.25 62.78,58.12 62.78,57.54 62.91,57.42 63.59,57.42 63.8,57.21 63.8,52.6 64.17,52.23 64.17,46.58 63.38,45.78 63.38,41.64 v2(64.48,40.53)
  BOTTOM w0.089: v2(67.04,83.4) 66.51,83.93 JCPU1.Y5
  BOTTOM w0.165: JDIMM2.97 65.72,42.61 65.01,41.9 65.01,39.66 64.68,39.32 64.29,39.32 64.03,39.59 64.03,40.07 v2(64.48,40.53)
DDR_B_MA2: length 67.8
  IN2 w0.089: 64.12,77.75 64.12,78.66 64.62,79.17 64.62,81.91 64.8,82.09 64.8,82.6 65.39,83.18 65.39,83.63 65.83,84.07 66.25,84.07 66.5,83.82 67.32,83.82 67.63,84.13 67.63,87.88 v2(67.04,88.47)
  IN2 w0.208: v2(65.63,33.7) 64.79,33.7 64.67,33.83 64.67,35.34 64.44,35.56 64.44,39.13 62.76,40.82 62.76,46.04 63.55,46.83 63.55,51.97 63.18,52.34 63.18,56.27 62.17,57.29 62.17,58 61.5,58.67 61.5,63.86 61.71,64.07 62.24,64.07 62.36,64.2 62.36,64.78 62.24,64.9 61.63,64.9 61.5,65.03 61.5,65.68 61.63,65.81 63.5,65.81 63.63,65.93 63.63,68.58 64.12,69.06 64.12,77.75
  BOTTOM w0.089: JCPU1.Y10 66.57,88.94 v2(67.04,88.47)
  BOTTOM w0.165: JDIMM2.96 65.42,35.01 65.19,34.78 65.19,34.14 v2(65.63,33.7)
DDR_B_MA3: length 69
  IN2 w0.089: v2(66.04,83.44) 66.04,83.33 65.16,82.45 65.16,81.94 64.98,81.76 64.98,78.67 65.22,78.43
  IN2 w0.208: 65.22,78.43 65.35,78.31 65.35,68.55 64.86,68.07 64.86,66.59 65.07,66.38 65.17,66.38 65.38,66.18 65.38,65.76 65.17,65.55 65.07,65.55 64.86,65.34 64.86,64.93 65.07,64.72 65.17,64.72 65.38,64.51 65.38,64.09 65.17,63.88 65.07,63.88 64.86,63.68 64.86,63.31 65.07,63.1 68.47,63.1 68.59,62.97 68.59,62.4 68.47,62.27 65.07,62.27 64.86,62.06 64.86,61.64 65.07,61.43 68.47,61.43 68.59,61.31 68.59,60.73 68.47,60.6 65.07,60.6 64.86,60.39 64.86,59.98 65.07,59.77 67.99,59.77 68.12,59.64 68.12,59.06 67.99,58.94 65.07,58.94 64.86,58.73 64.86,48.68 65.18,48.36 65.18,45.2 64.78,44.81 64.78,44.37 65.18,43.97 65.18,43.48 65.05,43.35 64.31,43.35 63.99,43.03 63.99,42.18 64.12,42.05 v2(64.48,42.05)
  BOTTOM w0.089: v2(66.04,83.44) 65.53,83.94 JCPU1.AA5
  BOTTOM w0.165: v2(64.48,42.05) 64.48,42.11 65.22,42.84 65.22,43.52 65.11,43.62 JDIMM2.95
