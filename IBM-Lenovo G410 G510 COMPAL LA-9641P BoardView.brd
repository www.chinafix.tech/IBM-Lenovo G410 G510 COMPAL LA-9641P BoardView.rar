# Allegro board IBM-Lenovo G410 G510 COMPAL LA-9641P BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D51: length 58.1
  IN1 w0.089: 87.23,85.26 86.79,84.82 85.03,84.82 84.48,85.38 84.48,85.65 84.3,85.82 83.46,85.82 v2(83.04,85.41)
  IN1 w0.127: 87.23,85.26 88.69,86.72 95.93,86.72 99.62,83.03 99.62,71.99 100.44,71.17 100.44,66.58 94.14,60.28 94.14,59.53 90.88,56.26 90.88,54.66 v2(90.32,54.11)
  BOTTOM w0.089: v2(83.04,85.41) 82.57,84.94 JCPU1.D6
  BOTTOM w0.102: v2(90.32,54.11) 90.74,54.52 90.74,56.02 90.54,56.22 90.17,56.22 89.72,56.68 JDIMM1.177
DDR_A_D52: length 57.4
  IN1 w0.089: v2(83.04,84.41) 82.63,84 82.63,83.23 82.88,82.99 84.2,82.99 84.67,82.51 85.18,82.51 85.64,82.05 87.23,82.05
  IN1 w0.127: 87.23,82.05 87.95,82.05 90.14,84.25 94.92,84.25 97.16,82.01 97.16,77.93 96.28,77.05 96.28,66.12 90.98,60.81 89.66,59.49 89.66,58.53 87.37,56.24 87.37,52.35 87.49,52.22 87.66,52.22 87.78,52.35 v2(87.78,52.59)
  BOTTOM w0.089: JCPU1.D5 82.57,83.94 v2(83.04,84.41)
  BOTTOM w0.102: v2(87.78,52.59) 85.82,50.62 JDIMM1.164
DDR_A_D53: length 58
  IN1 w0.089: 87.23,81.67 86.93,81.67 86.79,81.81 85.12,81.81 84.12,82.81 82.81,82.81 82.44,83.17 82.44,84.01 v2(82.04,84.41)
  IN1 w0.127: v2(87.78,51.06) 87.78,50.73 87.66,50.6 87.11,50.6 86.98,50.73 86.98,56.4 89.28,58.69 89.28,59.65 95.9,66.27 95.9,77.21 96.78,78.09 96.78,81.85 94.76,83.87 90.3,83.87 88.1,81.67 87.23,81.67
  BOTTOM w0.089: JCPU1.E5 81.57,83.94 v2(82.04,84.41)
  BOTTOM w0.102: v2(87.78,51.06) 87,51.06 86.42,50.48 JDIMM1.166
DDR_A_D54: length 57.6
  IN1 w0.089: 87.23,85.8 86.43,85 85.53,85 v2(85.02,85.51)
  IN1 w0.127: 87.23,85.8 88.54,87.1 96.12,87.1 100,83.22 100,72.15 100.82,71.33 100.82,66.42 94.52,60.12 94.52,59.37 91.26,56.1 91.26,53.52 v2(90.32,52.59)
  BOTTOM w0.089: JCPU1.B6 84.51,85 v2(85.02,85.51)
  BOTTOM w0.102: v2(90.32,52.59) 88.82,51.08 JDIMM1.174
DDR_A_D55: length 57.1
  IN1 w0.089: 87.23,86.58 v2(86.08,85.42)
  IN1 w0.127: 87.23,86.58 88.14,87.48 96.28,87.48 100.38,83.38 100.38,72.31 101.2,71.49 101.2,66.27 94.9,59.97 94.9,59.21 91.83,56.14 91.83,52.56 v2(90.32,51.06)
  BOTTOM w0.089: v2(86.08,85.42) 86.05,85.42 85.57,84.94 JCPU1.A6
  BOTTOM w0.102: JDIMM1.176 89.42,50.57 89.91,51.06 v2(90.32,51.06)
DDR_A_D56: length 66.3
  IN1 w0.089: 87.23,88.02 86.82,88.02 86.63,87.83 83.79,87.83 83.46,88.16 83.46,88.65 83.29,88.82 82.81,88.82 82.43,89.2 82.43,89.59 82.18,89.84 81.86,89.84 81.53,90.18 81.53,91.58 81.65,91.71 81.93,91.71 82.05,91.58 v2(82.05,91.41)
  IN1 w0.127: 87.23,88.02 96.5,88.02 100.92,83.6 100.92,72.53 101.74,71.71 101.74,66.05 97.11,61.42 97.11,61.07 97.62,60.56 97.62,60.38 97.39,60.15 97.21,60.15 96.62,60.75 96.44,60.75 96.26,60.57 96.26,60.39 97.62,59.03 97.62,58.85 97.44,58.67 97.26,58.67 96.08,59.84 95.9,59.84 95.72,59.66 95.72,59.48 95.95,59.25 95.95,59.07 95.37,58.48 94.93,58.48 v2(92.36,55.91)
  BOTTOM w0.089: v2(82.05,91.41) 81.59,90.94 JCPU1.E12
  BOTTOM w0.102: JDIMM1.181 90.91,56.59 91.59,55.91 v2(92.36,55.91)
DDR_A_D57: length 66.4
  IN1 w0.089: 87.23,88.4 86.8,88.4 86.41,88.01 83.87,88.01 83.64,88.24 83.64,88.72 83.36,89 82.88,89 82.61,89.28 82.61,89.66 82.25,90.02 81.94,90.02 81.7,90.25 81.7,90.59 82.06,90.94 82.57,90.94 v2(83.04,91.41)
  IN1 w0.127: v2(92.36,54.39) 92.78,54.81 92.78,55.48 95.4,58.1 95.97,58.1 96.1,58.23 96.1,58.67 96.22,58.8 96.48,58.8 96.6,58.67 96.6,58.23 96.73,58.1 97.73,58.1 98.71,59.09 98.71,62.48 102.12,65.89 102.12,71.87 101.3,72.69 101.3,83.76 96.66,88.4 87.23,88.4
  BOTTOM w0.089: v2(83.04,91.41) 82.57,90.94 JCPU1.D12
  BOTTOM w0.102: v2(92.36,54.39) 92.77,54.8 92.77,56.1 92.46,56.4 91.69,56.4 91.51,56.57 JDIMM1.183
DDR_A_D58: length 65.8
  IN1 w0.089: v2(85.04,90.41) 85.04,90.42 85.44,90.81 86.36,90.81 87.05,91.5 87.23,91.5
  IN1 w0.127: v2(96.17,54.39) 98.17,54.39 101.17,57.39 101.17,61.38 104.6,64.81 104.6,78.38 104.48,78.51 103.89,78.51 103.76,78.64 103.76,78.89 103.89,79.02 104.48,79.02 104.6,79.15 104.6,79.4 104.48,79.53 103.89,79.53 103.76,79.65 103.76,79.91 103.89,80.04 104.48,80.04 104.6,80.16 104.6,80.42 104.48,80.54 103.89,80.54 103.76,80.67 103.76,84.81 97.08,91.5 87.23,91.5
  BOTTOM w0.089: JCPU1.B11 84.57,89.94 v2(85.04,90.41)
  BOTTOM w0.102: v2(96.17,54.39) 95.34,54.39 93.91,55.81 JDIMM1.191
DDR_A_D59: length 65.1
  IN1 w0.089: v2(86.04,90.41) 86.05,90.42 86.58,90.42 87.23,91.07
  IN1 w0.127: v2(96.17,55.91) 96.28,56.02 96.46,56.02 96.59,55.89 96.59,55.05 96.72,54.92 96.95,54.92 97.08,55.05 97.08,55.89 97.2,56.02 97.41,56.02 97.53,55.89 97.53,55.05 97.66,54.92 98.17,54.92 99.18,55.93 99.18,56.11 99.02,56.27 99.02,56.45 99.2,56.63 99.38,56.63 99.54,56.47 99.72,56.47 100.79,57.55 100.79,61.54 104.22,64.97 104.22,75.84 104.1,75.97 103.67,75.97 103.54,76.1 103.54,76.35 103.67,76.48 104.1,76.48 104.22,76.61 104.22,76.86 104.1,76.99 103.51,76.99 103.38,77.11 103.38,77.37 103.51,77.5 104.1,77.5 104.22,77.62 104.22,77.88 104.1,78 103.51,78 103.38,78.13 103.38,84.65 96.92,91.12 87.27,91.12 87.23,91.07
  BOTTOM w0.089: v2(86.04,90.41) 85.57,89.94 JCPU1.A11
  BOTTOM w0.102: JDIMM1.193 94.51,56.29 94.9,55.91 96.17,55.91 v2(96.17,55.91)
DDR_A_D60: length 66.3
  IN1 w0.089: 87.23,88.82 83.79,88.82 83.44,89.17 83.44,89.57 83.1,89.91 82.61,89.91 v2(82.1,90.42)
  IN1 w0.127: v2(92.36,52.87) 93.16,53.67 93.16,55.32 95.56,57.72 97.88,57.72 99.09,58.93 99.09,62.32 102.5,65.73 102.5,72.53 102.37,72.65 101.87,72.65 101.74,72.78 101.74,73.03 101.87,73.16 102.37,73.16 102.5,73.29 102.5,73.54 102.37,73.67 101.81,73.67 101.68,73.8 101.68,83.92 96.36,89.24 87.71,89.24 87.29,88.82 87.23,88.82
  BOTTOM w0.089: v2(82.1,90.42) 81.63,89.94 JCPU1.E11
  BOTTOM w0.102: v2(92.36,52.87) 91.94,52.45 91.94,51.96 90.62,50.63 JDIMM1.180
DDR_A_D61: length 66
  IN1 w0.089: v2(83.04,90.41) 83.04,90.23 83.62,89.65 83.62,89.25 83.87,89 86.84,89 87.23,89.39
  IN1 w0.127: 87.23,89.39 87.46,89.62 96.52,89.62 102.06,84.07 102.06,75.32 102.19,75.19 102.53,75.19 102.65,75.07 102.65,74.81 102.53,74.68 102.19,74.68 102.06,74.56 102.06,74.3 102.19,74.18 102.75,74.18 102.88,74.05 102.88,65.57 99.47,62.16 99.47,58.77 98.04,57.34 95.72,57.34 93.54,55.17 93.54,52.52 v2(92.36,51.34)
  BOTTOM w0.089: JCPU1.D11 82.57,89.94 v2(83.04,90.41)
  BOTTOM w0.102: JDIMM1.182 91.21,50.72 91.84,51.34 v2(92.36,51.34)
DDR_A_D62: length 66.4
  IN1 w0.089: 87.23,91.88 87.1,91.88 86.22,90.99 85.46,90.99 v2(85.04,91.41)
  IN1 w0.127: v2(96.17,52.87) 97.19,52.87 101.55,57.23 101.55,61.23 104.99,64.66 104.99,80.92 104.86,81.05 104.27,81.05 104.14,81.18 104.14,81.43 104.27,81.56 104.86,81.56 104.99,81.69 104.99,81.94 104.86,82.07 104.27,82.07 104.14,82.19 104.14,84.97 96.69,92.42 93.74,92.42 93.2,91.88 87.23,91.88
  BOTTOM w0.089: JCPU1.B12 84.57,90.94 v2(85.04,91.41)
  BOTTOM w0.102: v2(96.17,52.87) 95.52,52.22 95.52,51.77 94.21,50.46 JDIMM1.192
DDR_A_D63: length 65.8
  IN1 w0.089: 87.23,92.26 87.06,92.26 86.21,91.41 v2(86.04,91.41)
  IN1 w0.127: v2(96.17,51.34) 96.2,51.34 101.94,57.07 101.94,61.07 105.37,64.5 105.37,82.45 105.24,82.58 104.65,82.58 104.52,82.7 104.52,83.02 104.65,83.14 105.28,83.14 105.41,83.27 105.41,83.53 105.28,83.65 104.65,83.65 104.52,83.78 104.52,85.13 96.85,92.8 93.58,92.8 93.04,92.26 87.23,92.26
  BOTTOM w0.089: v2(86.04,91.41) 85.57,90.94 JCPU1.A12
  BOTTOM w0.102: JDIMM1.194 94.82,50.63 95.69,51.51 96,51.51 v2(96.17,51.34)
DDR_A_DQS0: length 65.5
  IN1 w0.089: 48.24,91.62 48.48,91.62 48.67,91.81 51.3,91.81 51.63,92.14 51.63,92.78 51.77,92.91 52.03,92.91 52.13,92.81 52.13,92.5 v2(52.04,92.41)
  IN1 w0.127: 48.24,91.62 47.44,91.62 47.31,91.49 47.31,90.89 47.08,90.66 46.4,90.66 46.17,90.89 46.17,91.49 46.04,91.62 45.66,91.62 45.53,91.49 45.53,91.23 45.31,91 44.62,91 44.39,91.23 44.39,91.49 44.26,91.62 40.08,91.62 31.76,83.3 31.76,61.06 36.11,56.71 36.11,53.32 36.44,52.99 36.71,52.99 v2(36.97,53.24)
  BOTTOM w0.089: v2(52.04,92.41) 52.51,92.88 JCPU1.AP14
  BOTTOM w0.102: v2(36.97,53.24) 36.97,53.14 37.21,52.91 37.43,52.91 37.64,52.71 37.64,50.56 37.82,50.38 JDIMM1.12
DDR_A_DQS1: length 56.2
  IN1 w0.089: v2(53.04,87.41) 53.04,87.49 52.91,87.62 52.7,87.62 52.58,87.49 52.58,87.05 52.32,86.79 50.83,86.79 50.21,86.17 48.24,86.17
  IN1 w0.127: v2(42.94,54.77) 42.7,54.53 42.7,54.52 42.58,54.52 42.45,54.65 42.45,57.67 35.96,64.16 35.96,81.58 39.8,85.42 44.97,85.42 45.25,85.7 45.25,86.23 45.37,86.36 45.76,86.36 45.88,86.23 45.88,85.92 46.16,85.65 46.86,85.65 47.14,85.92 47.14,86.02 47.27,86.15 48.19,86.15 48.2,86.17 48.24,86.17
  BOTTOM w0.089: JCPU1.AP9 52.51,87.94 v2(53.04,87.41)
  BOTTOM w0.102: JDIMM1.29 42.92,56.57 42.66,56.32 42.66,56.23 42.43,55.99 42.43,54.59 42.61,54.4 42.82,54.4 42.94,54.52 v2(42.94,54.77)
DDR_A_DQS2: length 53.6
  IN1 w0.089: 48.24,79.91 48.38,79.91 49.49,81.01 51.2,81.01 51.44,81.25 51.44,81.67 51.77,82 52.24,82 52.43,82.19 52.43,82.72 52.74,83.03 53.21,83.03 53.42,83.25 53.42,83.68 53.78,84.03 54.24,84.03 54.41,84.21 54.41,84.63 54.82,85.04 55.21,85.04 55.42,85.24 55.42,85.62 55.79,85.99 57.26,85.99 57.34,86.07 57.34,86.32 57.24,86.41 v2(57.04,86.41)
  IN1 w0.127: 48.24,79.91 48.19,79.91 40.57,72.29 40.57,71.86 40.45,71.73 40.08,71.73 39.85,71.5 39.85,70.82 40.08,70.59 40.45,70.59 40.57,70.46 40.57,70.08 40.45,69.95 40.08,69.95 39.85,69.73 39.85,69.04 40.08,68.81 40.45,68.81 40.57,68.68 40.57,68.3 40.45,68.18 40.32,68.18 40.09,67.95 40.09,67.26 40.32,67.03 40.45,67.03 40.57,66.91 40.57,65.04 47.16,58.46 47.16,54.49 47.41,54.24 47.69,54.24 v2(47.93,54)
  BOTTOM w0.089: JCPU1.AK8 56.51,86.94 v2(57.04,86.41)
  BOTTOM w0.102: JDIMM1.47 48.32,56.58 48.14,56.4 48.14,56.26 48.69,55.72 48.69,54.49 48.43,54.23 48.16,54.23 v2(47.93,54)
DDR_A_DQS3: length 45.4
  IN1 w0.089: 51.95,77.32 51.95,77.32 51.97,77.32 51.97,77.32 52.03,77.37 52.06,77.37 52.54,77.86 53.05,77.86 55.42,80.22 55.42,80.69 55.73,81 59.33,81 59.42,81.09 59.42,81.19 59.2,81.41 v2(59.04,81.41)
  IN1 w0.127: v2(52.76,54) 52.5,54.27 52.29,54.27 52.03,54.53 52.03,60.12 47.08,65.06 47.08,65.82 46.95,65.95 46.61,65.95 46.38,66.18 46.38,66.86 46.61,67.09 47,67.09 47.08,67.17 47.08,72.45 51.95,77.32
  BOTTOM w0.089: v2(59.04,81.41) 59.51,81.88 JCPU1.AG3
  BOTTOM w0.102: v2(52.76,54) 52.76,54.14 52.62,54.28 52.39,54.28 52.33,54.22 52.33,52.99 53.21,52.12 53.21,52.12 53.21,50.72 53.41,50.52 JDIMM1.64
DDR_A_DQS4: length 44.1
  IN1 w0.089: v2(79.04,81.42) 78.73,81.42 78.64,81.52 78.64,81.83 78.42,82.05 77.72,82.05 77.41,81.75 77.41,81.13 77.75,80.79 79.23,80.79 79.44,80.58 79.44,79.63 80.22,78.85 80.22,78.05 80.2,78.04 80.2,78.03
  IN1 w0.127: 80.2,78.03 80.2,77.85 83.01,75.04 83.99,75.04 86.44,72.58 86.44,66.29 79.92,59.77 79.92,54.32 79.8,54.2 79.62,54.2 79.48,54.34 v2(79.48,54.47)
  BOTTOM w0.089: JCPU1.H3 78.52,81.94 v2(79.04,81.42)
  BOTTOM w0.102: v2(79.48,54.47) 79.48,54.31 79.32,54.14 78.6,54.14 78.37,54.37 78.37,55.92 77.93,56.35 77.66,56.35 77.58,56.43 77.58,56.54 77.72,56.68 JDIMM1.137
DDR_A_DQS5: length 51.6
  IN1 w0.089: 87.23,79.46 87.2,79.46 87.19,79.48 87.16,79.48 87.16,79.48 84.35,79.48 83.66,80.16 83.66,80.78 83.44,81 82.85,81 82.66,81.19 82.66,81.76 82.39,82.03 82.17,82.03 82.04,82.16 v2(82.04,82.41)
  IN1 w0.127: v2(81.62,46.7) 81.77,46.86 82.46,46.86 84.7,49.1 84.7,58.34 92.62,66.26 92.62,74.43 87.59,79.46 87.23,79.46
  BOTTOM w0.089: v2(82.04,82.41) 81.57,81.94 JCPU1.E3
  BOTTOM w0.102: JDIMM1.154 82.81,47.48 82.22,46.88 81.8,46.88 v2(81.62,46.7)
DDR_A_DQS6: length 57.1
  IN1 w0.089: v2(84.04,85.41) 84.04,85.24 84.24,85.04 84.53,85.04 84.89,84.68 85.56,84.01 86.38,84.01 86.53,83.86 87.23,83.86
  IN1 w0.127: 87.23,83.86 87.56,83.86 89.5,85.8 95.56,85.8 98.71,82.65 98.71,66.14 91.98,59.42 91.98,58.66 89.73,56.41 89.73,54.19 89.47,53.93 89.25,53.93 v2(89.05,53.73)
  BOTTOM w0.089: v2(84.04,85.41) 83.57,84.94 JCPU1.C6
  BOTTOM w0.102: v2(89.05,53.73) 89.25,53.93 89.42,53.93 89.86,54.37 89.86,55.34 89.3,55.91 88.73,55.91 88.27,56.36 87.83,56.36 87.78,56.42 87.78,56.54 87.91,56.68 JDIMM1.171
DDR_A_DQS7: length 67.3
  IN1 w0.089: v2(84.04,91.41) 84.04,91.16 83.91,91.03 83.72,91.03 83.41,90.71 83.41,90.14 83.76,89.78 86.88,89.78 87.23,90.13
  IN1 w0.127: 87.23,90.13 87.25,90.15 96.77,90.15 102.59,84.33 102.59,75.93 103.44,75.09 103.44,65.3 100,61.87 100,58.55 98.26,56.81 95.94,56.81 94.1,54.97 94.1,52.99 94.37,52.72 94.67,52.72 v2(94.9,52.48)
  BOTTOM w0.089: v2(84.04,91.41) 83.57,90.94 JCPU1.C12
  BOTTOM w0.102: JDIMM1.188 93.02,50.44 92.88,50.57 92.88,50.83 93.1,51.04 93.1,52.22 93.62,52.74 94.64,52.74 v2(94.9,52.48)
DDR_A_DQS#0: length 65.5
  IN1 w0.089: v2(52.04,93.41) 52.04,93.19 51.98,93.13 51.68,93.13 51.42,92.87 51.42,92.23 51.21,92.02 48.58,92.02 48.41,91.85 48.27,91.85 48.25,91.87 48.24,91.87
  IN1 w0.127: v2(36.97,52.48) 36.97,52.49 36.73,52.73 36.34,52.73 35.86,53.21 35.86,56.61 31.51,60.96 31.51,83.41 39.97,91.87 44.37,91.87 44.65,91.59 44.65,91.33 44.73,91.25 45.2,91.25 45.28,91.33 45.28,91.59 45.56,91.87 46.15,91.87 46.42,91.59 46.42,90.99 46.5,90.91 46.98,90.91 47.06,90.99 47.06,91.59 47.33,91.87 48.24,91.87
  BOTTOM w0.089: JCPU1.AP15 52.51,93.88 v2(52.04,93.41)
  BOTTOM w0.102: v2(36.97,52.48) 36.97,52.49 37.18,52.69 37.34,52.69 37.42,52.62 37.42,50.56 37.22,50.35 JDIMM1.10
DDR_A_DQS#1: length 56.3
  IN1 w0.089: v2(52.04,87.41) 52.27,87.41 52.36,87.32 52.36,87.13 52.23,87 50.74,87 50.12,86.38 48.36,86.38 48.34,86.4 48.27,86.4 48.25,86.42 48.24,86.42
  IN1 w0.127: v2(42.94,54) 42.68,54.27 42.47,54.27 42.2,54.54 42.2,57.56 35.71,64.05 35.71,81.69 39.7,85.68 44.87,85.68 44.99,85.8 44.99,86.34 45.27,86.61 45.86,86.61 46.14,86.34 46.14,86.03 46.26,85.9 46.76,85.9 46.89,86.03 46.89,86.13 47.17,86.41 48.09,86.41 48.1,86.42 48.24,86.42
  BOTTOM w0.089: v2(52.04,87.41) 52.51,86.94 JCPU1.AP8
  BOTTOM w0.102: JDIMM1.27 42.32,56.57 42.44,56.44 42.44,56.32 42.21,56.08 42.21,54.5 42.52,54.18 42.76,54.18 v2(42.94,54)
DDR_A_DQS#2: length 53.6
  IN1 w0.089: v2(58.04,86.41) 58.04,86.63 57.96,86.71 57.69,86.71 57.55,86.58 57.55,85.98 57.35,85.77 55.87,85.77 55.63,85.53 55.63,85.15 55.3,84.82 54.91,84.82 54.63,84.54 54.63,84.12 54.33,83.82 53.87,83.82 53.64,83.59 53.64,83.16 53.3,82.81 52.83,82.81 52.65,82.63 52.65,82.1 52.33,81.79 51.86,81.79 51.66,81.58 51.66,81.16 51.29,80.79 49.58,80.79 48.47,79.69 48.38,79.69 48.36,79.71 48.35,79.71 48.24,79.6
  IN1 w0.127: v2(47.93,54.77) 47.66,54.5 47.52,54.5 47.42,54.6 47.42,58.56 40.83,65.15 40.83,67.01 40.55,67.29 40.42,67.29 40.34,67.37 40.34,67.84 40.42,67.92 40.55,67.92 40.83,68.2 40.83,68.79 40.55,69.07 40.18,69.07 40.1,69.15 40.1,69.62 40.18,69.7 40.55,69.7 40.83,69.98 40.83,70.57 40.55,70.84 40.18,70.84 40.1,70.92 40.1,71.4 40.18,71.48 40.55,71.48 40.83,71.75 40.83,72.18 48.24,79.6
  BOTTOM w0.089: JCPU1.AJ8 57.51,86.94 v2(58.04,86.41)
  BOTTOM w0.102: v2(47.93,54.77) 47.93,54.58 48.06,54.45 48.06,54.45 48.07,54.45 48.34,54.45 48.47,54.58 48.47,55.63 47.92,56.17 47.92,56.39 47.72,56.6 JDIMM1.45
DDR_A_DQS#3: length 45.3
  IN1 w0.089: 52.13,77.14 52.15,77.16 52.63,77.64 53.14,77.64 55.63,80.13 55.63,80.6 55.82,80.78 59.42,80.78 59.63,81 59.63,81.34 59.71,81.41 v2(60.04,81.41)
  IN1 w0.127: v2(52.76,54.77) 52.76,54.62 52.66,54.52 52.4,54.52 52.28,54.64 52.28,60.22 47.34,65.17 47.34,65.93 47.06,66.2 46.72,66.2 46.64,66.28 46.64,66.76 46.72,66.84 47.11,66.84 47.34,67.07 47.34,72.35 52.13,77.14
  BOTTOM w0.089: JCPU1.AF3 60.51,81.88 v2(60.04,81.41)
  BOTTOM w0.102: v2(52.76,54.77) 52.49,54.5 52.31,54.5 52.12,54.31 52.12,52.9 53,52.02 53,50.72 52.81,50.54 JDIMM1.62
DDR_A_DQS#4: length 44.1
  IN1 w0.089: v2(78.04,81.42) 78.11,81.35 78.32,81.35 78.42,81.46 78.42,81.74 78.33,81.84 77.81,81.84 77.63,81.66 77.63,81.22 77.84,81.01 79.32,81.01 79.66,80.67 79.66,79.72 80.44,78.94 80.44,78.05 80.45,78.04 80.45,78.03
  IN1 w0.127: v2(79.48,53.7) 79.73,53.95 79.9,53.95 80.17,54.22 80.17,59.66 86.7,66.19 86.7,72.69 84.09,75.29 83.11,75.29 80.45,77.95 80.45,78.03
  BOTTOM w0.089: v2(78.04,81.42) 77.52,81.94 JCPU1.J3
  BOTTOM w0.102: JDIMM1.135 77.12,56.66 77.32,56.45 77.32,56.38 77.57,56.14 77.84,56.14 78.15,55.83 78.15,54.28 78.51,53.92 79.27,53.92 v2(79.48,53.7)
DDR_A_DQS#5: length 51.6
  IN1 w0.089: v2(82.04,81.41) 81.7,81.41 81.58,81.53 81.58,81.69 81.7,81.81 82.3,81.81 82.44,81.67 82.44,81.1 82.76,80.78 83.35,80.78 83.45,80.69 83.45,80.07 84.26,79.26 87.04,79.26 87.09,79.21 87.23,79.21
  IN1 w0.127: v2(81.62,47.33) 81.84,47.11 82.36,47.11 84.45,49.2 84.45,58.45 92.37,66.36 92.37,74.32 87.48,79.21 87.23,79.21
  BOTTOM w0.089: v2(82.04,81.41) 81.57,80.94 JCPU1.E2
  BOTTOM w0.102: JDIMM1.152 82.21,48.41 82.33,48.29 82.49,48.29 82.6,48.19 82.6,47.57 82.13,47.1 81.77,47.1 81.62,47.25 v2(81.62,47.33)
DDR_A_DQS#6: length 57
  IN1 w0.089: 87.23,83.59 87.15,83.59 87.09,83.64 86.44,83.64 86.29,83.79 85.47,83.79 84.44,84.82 83.83,84.82 83.71,84.7 83.71,84.54 83.83,84.41 v2(84.04,84.41)
  IN1 w0.127: v2(89.05,54.49) 89.05,54.3 89.18,54.18 89.36,54.18 89.47,54.29 89.47,56.51 91.73,58.76 91.73,59.52 98.45,66.25 98.45,82.54 95.46,85.54 89.6,85.54 87.65,83.59 87.23,83.59
  BOTTOM w0.089: v2(84.04,84.41) 83.9,84.41 83.51,84.02 JCPU1.C5
  BOTTOM w0.102: JDIMM1.169 87.32,56.74 87.5,56.55 87.5,56.39 87.74,56.15 88.18,56.15 88.64,55.69 89.21,55.69 89.65,55.25 89.65,54.46 89.33,54.14 89.17,54.14 89.05,54.26 v2(89.05,54.49)
DDR_A_DQS#7: length 67.2
  IN1 w0.089: 87.23,90.41 87.21,90.41 86.8,90 83.85,90 83.62,90.23 83.62,90.62 83.81,90.81 84.02,90.81 84.13,90.71 84.13,90.5 v2(84.04,90.41)
  IN1 w0.127: v2(94.9,53.25) 94.63,52.97 94.47,52.97 94.36,53.09 94.36,54.86 96.04,56.55 98.37,56.55 100.26,58.44 100.26,61.76 103.69,65.19 103.69,75.2 102.85,76.04 102.85,84.43 96.87,90.41 87.23,90.41
  BOTTOM w0.089: JCPU1.C11 83.57,89.94 v2(84.04,90.41)
  BOTTOM w0.102: JDIMM1.186 92.42,50.33 92.67,50.59 92.67,50.92 92.88,51.13 92.88,52.31 93.53,52.96 94.61,52.96 v2(94.9,53.25)
DDR_A_MA0: length 44.6
  IN1 w0.089: v2(68.04,86.41) 67.62,85.99 67.62,78.21 68.69,77.14
  IN1 w0.208: 68.69,77.14 68.75,77.08 68.75,67.88 67.23,66.35 67.23,50.95 66.61,50.34 66.61,47.52 v2(67.07,47.06)
  BOTTOM w0.089: JCPU1.V8 68.51,86.88 v2(68.04,86.41)
  BOTTOM w0.165: v2(67.07,47.06) 66.02,48.12 JDIMM1.98
DDR_A_MA1: length 54.9
  IN1 w0.089: v2(64.04,84.41) 63.85,84.41 63.72,84.54 63.72,84.82 63.85,84.95 64.37,84.95 64.5,84.82 64.5,84.15 64.61,84.03 66.3,84.03 66.63,83.7 66.63,78.18 67.46,77.36
  IN1 w0.208: v2(65.94,55.03) 65.47,55.5 65.47,56.11 65.67,56.32 65.87,56.32 66,56.44 66,57.02 65.87,57.15 65.2,57.15 65.08,57.28 65.08,57.86 65.2,57.98 65.87,57.98 66,58.11 66,58.69 65.87,58.82 64.48,58.82 64.35,58.94 64.35,59.52 64.48,59.65 65.87,59.65 66,59.78 66,60.36 65.87,60.49 63.96,60.49 63.84,60.62 63.84,61.16 63.96,61.29 65.87,61.29 66,61.42 66,62.06 65.87,62.18 63.96,62.18 63.84,62.31 63.84,62.89 63.96,63.02 65.87,63.02 66,63.14 66,63.72 65.87,63.85 63.96,63.85 63.84,63.98 63.84,64.71 63.96,64.83 65.87,64.83 66,64.96 66,66.86 67.46,68.32 67.46,77.36
  BOTTOM w0.089: JCPU1.AC6 63.51,84.94 v2(64.04,84.41)
  BOTTOM w0.165: v2(65.94,55.03) 65.48,55.49 65.48,56.38 65.72,56.62 JDIMM1.97
DDR_A_MA2: length 65.7
  IN1 w0.089: 65.55,77.14 65.55,77.53 65.32,77.76 65.32,82.88 65.19,83 62.83,83 62.62,83.22 62.62,84.2 63.62,85.2 63.62,86.52 64.1,86.99 68.62,86.99 v2(69.04,87.41)
  IN1 w0.208: v2(64.65,47.06) 64.35,47.06 64.11,46.82 64.11,44.4 64.23,44.27 65.05,44.27 65.17,44.15 65.17,43.57 65.05,43.44 63.6,43.44 63.36,43.68 63.36,47.98 62.75,48.59 62.75,50.6 63.3,51.15 63.3,54.28 63.15,54.42 63.15,57.53 61.99,58.69 61.99,70.14 62.26,70.41 62.74,70.41 62.91,70.58 62.91,71.58 63.43,72.1 65.28,72.1 65.55,72.37 65.55,77.14
  BOTTOM w0.089: v2(69.04,87.41) 68.51,87.94 JCPU1.V9
  BOTTOM w0.165: v2(64.65,47.06) 65.42,47.83 JDIMM1.96
DDR_A_MA3: length 65.7
  IN1 w0.089: 68.08,77.22 67.44,77.86 67.44,86.38 67.88,86.81 69.44,86.81 v2(70.04,87.42)
  IN1 w0.208: 68.08,77.22 68.08,68.08 66.61,66.61 66.61,51.21 66.48,51.08 66.13,51.08 66,50.95 66,45.96 66.21,45.75 67.57,45.75 67.72,45.6 67.72,43.94 67.59,43.82 67.02,43.82 66.89,43.94 66.89,44.77 66.76,44.9 65.43,44.9 65.26,45.07 65.26,51.16 65.48,51.38 65.48,53.05 v2(65.94,53.5)
  BOTTOM w0.089: v2(70.04,87.42) 69.51,87.94 JCPU1.U9
  BOTTOM w0.165: v2(65.94,53.5) 65.11,54.33 JDIMM1.95
DDR_A_MA4: length 55.2
  IN1 w0.089: v2(64.04,83.41) 65.43,83.41 65.63,83.21 65.63,77.98 66.22,77.39
  IN1 w0.208: v2(64.39,53.5) 64.65,53.5 64.87,53.29 64.87,51.63 64.65,51.41 64.65,48.67 64.43,48.45 63.76,48.45 63.37,48.84 63.37,50.35 63.91,50.9 63.91,54.53 63.78,54.67 63.78,57.78 62.61,58.95 62.61,69.66 62.73,69.79 63.4,69.79 63.53,69.92 63.53,71.09 63.92,71.49 66,71.49 66.22,71.71 66.22,77.39
  BOTTOM w0.089: JCPU1.AC5 63.51,83.94 v2(64.04,83.41)
  BOTTOM w0.165: JDIMM1.92 64.22,50.63 64.38,50.8 65.61,50.8 65.73,50.92 65.73,51.33 65.61,51.46 64.37,51.46 64.25,51.58 64.25,52 64.37,52.12 64.73,52.12 64.85,52.25 64.85,53.04 v2(64.39,53.5)
DDR_A_MA5: length 58.1
  IN1 w0.089: 66.83,77.41 66.45,77.79 66.45,83.63 66.23,83.86 62.92,83.86 62.8,83.73 62.8,83.54 62.92,83.41 v2(63.04,83.41)
  IN1 w0.208: v2(64.39,55.03) 64.39,54.92 64.85,54.46 64.85,54.19 64.98,54.06 65.27,54.06 65.4,54.19 65.4,54.7 64.85,55.25 64.85,55.98 64.46,56.37 64.46,57.96 63.22,59.2 63.22,65.13 63.54,65.45 65.25,65.45 65.38,65.57 65.38,66.26 65.25,66.39 63.35,66.39 63.22,66.52 63.22,67.25 63.35,67.38 65.64,67.38 66.11,67.84 66.11,68.15 65.86,68.39 63.35,68.39 63.22,68.52 63.22,69.05 63.35,69.18 66.72,69.18 66.84,69.3 66.84,69.87 66.72,70 64.27,70 64.14,70.12 64.14,70.75 64.27,70.87 66.72,70.87 66.84,71 66.84,76.48 66.83,76.49 66.83,77.41
  BOTTOM w0.089: v2(63.04,83.41) 63.51,82.94 JCPU1.AC4
  BOTTOM w0.165: v2(64.39,55.03) 64.29,54.92 63.98,54.92 63.81,55.09 63.81,55.52 63.92,55.64 63.92,57.58 JDIMM1.91
DDR_A_MA6: length 55.4
  IN1 w0.089: v2(62.04,85.49) 62.04,85.87 61.91,86 61.58,86 61.45,85.87 61.45,83.23 61.87,82.81 62.27,82.81 63.28,81.8 63.28,80.14 63.62,79.8 63.62,78.65 62.1,77.14
  IN1 w0.208: v2(62.74,47.31) 62.74,47.24 62.62,47.11 62.07,47.11 61.94,47.24 61.94,48.36 60.84,49.46 60.84,52.88 60.26,53.46 60.26,56.95 59.53,57.67 59.53,62.24 56.38,65.4 56.38,70.39 56.66,70.67 57.62,70.67 57.88,70.93 57.88,72.92 62.1,77.14
  BOTTOM w0.089: JCPU1.AD6 62.51,85.02 v2(62.04,85.49)
  BOTTOM w0.165: JDIMM1.90 63.62,48.16 63.87,47.91 63.87,46.08 63.74,45.95 62.3,45.95 62.17,46.08 62.17,47.17 62.32,47.32 62.73,47.32 v2(62.74,47.31)
DDR_A_MA7: length 56.2
  IN1 w0.089: 61.23,77.14 61.34,77.14 63.44,79.24 63.44,79.62 63.04,80.02 63.04,81.26 v2(62.86,81.44)
  IN1 w0.208: v2(60.71,46.58) 60.38,46.58 60.25,46.45 60.25,43.02 60.38,42.9 60.97,42.9 61.1,43.02 61.1,45.06 61.22,45.18 62.62,45.18 62.74,45.31 62.74,45.89 62.62,46.02 61.54,46.02 61.33,46.23 61.33,48.1 60.23,49.2 60.23,52.62 59.64,53.21 59.64,56.69 58.92,57.42 58.92,61.99 55.77,65.14 55.77,70.64 57.27,72.15 57.27,73.17 61.23,77.14
  BOTTOM w0.089: JCPU1.AC3 63.37,81.94 62.87,81.44 v2(62.86,81.44)
  BOTTOM w0.165: JDIMM1.86 62.42,48.27 60.72,46.58 v2(60.71,46.58)
DDR_A_MA8: length 56.8
  IN1 w0.089: v2(62.04,84.45) 62.04,85.02 61.92,85.15 61.75,85.15 61.63,85.02 61.63,83.3 61.94,82.99 62.34,82.99 63.46,81.87 63.46,80.31 63.81,79.96 64.21,79.96 64.44,79.73 64.44,79.11 63.93,78.6 63.93,78.09 62.97,77.14
  IN1 w0.208: 62.97,77.14 58.5,72.66 58.5,70.18 58.37,70.06 57.12,70.06 56.99,69.93 56.99,69.35 57.12,69.22 58.37,69.22 58.5,69.1 58.5,68.52 58.37,68.4 57.22,68.4 56.99,68.17 56.99,65.65 60.15,62.5 60.15,57.93 60.87,57.2 60.87,53.72 61.46,53.13 61.46,49.71 61.58,49.59 61.98,49.59 62.11,49.71 62.11,52.11 62.24,52.23 62.48,52.23 62.61,52.11 v2(62.61,51.98)
  BOTTOM w0.089: JCPU1.AD5 62.51,83.98 v2(62.04,84.45)
  BOTTOM w0.165: JDIMM1.89 63.32,52.68 62.62,51.98 v2(62.61,51.98)
DDR_A_MA9: length 55.9
  IN1 w0.089: 64.93,77.99 64.93,82.64 64.81,82.76 64.62,82.76 64.49,82.64 64.49,81.53 64.36,81.4 v2(64.04,81.4)
  IN1 w0.208: 64.93,77.99 64.93,76.32 64.73,76.11 63.68,76.11 63.56,75.98 63.56,75.4 63.68,75.28 64.81,75.28 64.93,75.15 64.93,74.51 64.81,74.38 61.96,74.38 61.83,74.26 61.83,73.71 61.96,73.58 64.81,73.58 64.93,73.45 64.93,72.87 64.81,72.75 61.5,72.75 61.38,72.62 61.38,71.99 61.5,71.87 62.17,71.87 62.3,71.74 62.3,71.16 62.17,71.03 61.5,71.03 61.38,70.91 61.38,68.48 61.17,68.27 59.85,68.27 59.73,68.14 59.73,67.56 59.85,67.44 61.17,67.44 61.38,67.23 61.38,66.81 61.17,66.6 59.85,66.6 59.73,66.48 59.73,65.9 59.85,65.77 61.17,65.77 61.38,65.56 61.38,65.14 61.17,64.94 60.28,64.94 60.15,64.81 60.15,64.23 60.28,64.1 61.17,64.1 61.38,63.89 61.38,58.44 62.11,57.7 62.11,55.08 62.32,54.87 62.45,54.87 v2(62.61,55.03)
  BOTTOM w0.089: JCPU1.AC2 63.58,80.94 v2(64.04,81.4)
  BOTTOM w0.165: JDIMM1.85 62.11,55.56 62.01,55.45 62.01,54.98 62.18,54.82 62.39,54.82 v2(62.61,55.03)
DDR_A_MA10: length 59.6
  IN1 w0.089: 71.62,78.52 71.62,82.43 71.42,82.64 70.7,82.64 70.33,83 69.85,83 69.68,83.18 69.68,84.9 69.46,85.12 69.46,85.87 69.33,86 68.52,86 68.39,85.87 68.39,85.57 68.52,85.45 v2(69.04,85.45)
  IN1 w0.208: 71.62,78.52 71.81,78.34 72.55,78.34 72.68,78.21 72.68,77.52 72.55,77.39 71.7,77.39 71.58,77.27 71.58,76.69 71.7,76.56 72.29,76.56 72.42,76.43 72.42,75.85 72.29,75.73 71.7,75.73 71.58,75.6 71.58,75.02 71.7,74.89 72.25,74.89 72.38,74.77 72.38,74.19 72.25,74.06 71.7,74.06 71.58,73.93 71.58,73.26 71.7,73.13 73.36,73.13 73.61,72.88 73.61,70.01 73.82,69.8 74.96,69.8 75.09,69.68 75.09,69.1 74.96,68.97 73.82,68.97 73.61,68.76 73.61,68.35 73.82,68.14 74.96,68.14 75.09,68.01 75.09,67.43 74.96,67.31 73.82,67.31 73.61,67.1 73.61,66.68 73.82,66.47 74.78,66.47 74.9,66.35 74.9,65.77 74.78,65.64 73.82,65.64 73.61,65.43 73.61,64.47 71.58,62.45 71.58,58.2 70.93,57.54 70.93,55.21 70.4,54.69 70.4,54.07 v2(69.84,53.5)
  BOTTOM w0.089: v2(69.04,85.45) 68.54,84.94 JCPU1.V6
  BOTTOM w0.165: v2(69.84,53.5) 68.87,52.54 68.69,52.54 68.11,53.12 68.11,53.3 69.26,54.44 69.26,55.03 68.72,55.57 JDIMM1.107
DDR_A_MA11: length 55
  IN1 w0.089: v2(63.04,79.41) 62.97,79.41 62.34,78.78 61.99,78.78 60.36,77.15 60.36,77.14
  IN1 w0.208: 60.36,77.14 56.65,73.43 56.65,72.4 55.15,70.9 55.15,64.89 58.3,61.73 58.3,57.16 59.03,56.44 59.03,52.95 59.61,52.37 59.61,48.82 58.89,48.1 58.89,44.54 58.77,44.41 57.26,44.41 57.13,44.28 57.13,43.7 57.26,43.58 58.77,43.58 58.89,43.45 58.89,43 59.02,42.88 59.51,42.88 59.64,43 59.64,47.72 59.77,47.85 v2(60.71,47.85)
  BOTTOM w0.089: JCPU1.AC1 63.51,79.88 v2(63.04,79.41)
  BOTTOM w0.165: JDIMM1.84 61.81,48.44 61.23,47.85 v2(60.71,47.85)
DDR_A_MA12: length 56.8
  IN1 w0.089: 64.35,78.03 64.35,78.61 64.62,78.88 64.62,80.45 64.26,80.81 63.98,80.81 63.63,81.15 63.63,81.95 62.44,83.14 62.44,83.99 62.32,84.11 62.16,84.11 62.04,83.99 v2(62.04,83.4)
  IN1 w0.208: v2(62.61,53.5) 61.49,54.62 61.49,57.46 60.76,58.18 60.76,62.75 59.11,64.4 59.11,65.08 58.9,65.28 58.23,65.28 58.1,65.41 58.1,65.99 58.23,66.12 58.99,66.12 59.11,66.24 59.11,66.82 58.99,66.95 57.74,66.95 57.61,67.08 57.61,67.66 57.74,67.78 58.9,67.78 59.11,67.99 59.11,68.64 59.36,68.88 60.63,68.88 60.76,69.01 60.76,69.59 60.63,69.72 59.28,69.72 59.15,69.84 59.15,70.42 59.28,70.55 60.63,70.55 60.76,70.68 60.76,71.25 60.63,71.38 59.35,71.38 59.22,71.51 59.22,72.02 59.35,72.15 60.63,72.15 60.76,72.28 60.76,72.8 60.63,72.92 60.29,72.92 60.16,73.05 60.16,73.45 60.29,73.58 61.04,73.58 61.2,73.75 61.2,74.5 61.71,75.01 62.69,75.01 62.91,75.23 62.91,76.2 64.35,77.64 64.35,78.03
  BOTTOM w0.089: JCPU1.AD4 62.49,82.94 62.04,83.39 v2(62.04,83.4)
  BOTTOM w0.165: v2(62.61,53.5) 62.12,53.5 61.28,52.67 61.1,52.67 60.7,53.07 60.7,53.25 61.51,54.07 JDIMM1.83
DDR_A_MA13: length 52.6
  IN1 w0.089: 75.49,77.14 75.49,78.45 74.44,79.49 74.44,83.59 74.14,83.89 73.86,83.89 73.49,84.26 73.49,86.59 73.22,86.85 69.92,86.85 69.47,86.41 v2(69.04,86.41)
  IN1 w0.208: 75.49,77.14 75.49,75.86 79.28,72.07 79.28,65.8 74.69,61.2 74.69,56.95 74.07,56.33 74.07,52.83 74.19,52.7 74.61,52.7 74.74,52.83 74.74,53.16 74.87,53.29 v2(75.14,53.29)
  BOTTOM w0.089: JCPU1.V7 68.57,85.94 v2(69.04,86.41)
  BOTTOM w0.165: JDIMM1.119 72.32,55.56 72.95,54.93 72.95,53.16 73.18,52.92 74.78,52.92 v2(75.14,53.29)
DDR_A_MA14: length 57
  IN1 w0.089: 59.49,77.14 59.84,77.48 60.44,77.48 61.92,78.96 62.26,78.96 62.64,79.33 62.64,79.52 62.86,79.74 62.86,80.97 62.73,81.1 62.41,81.1 62.29,81.23 62.29,81.58 62.41,81.71 62.62,81.71 62.74,81.83 62.74,82.01 62.62,82.13 62.17,82.13 62.04,82.26 v2(62.04,82.39)
  IN1 w0.208: 59.49,77.14 56.04,73.68 56.04,72.66 54.54,71.15 54.54,64.63 57.69,61.48 57.69,56.91 58.41,56.19 58.41,52.4 58.29,52.28 56.59,52.28 56.46,52.15 56.46,51.55 56.59,51.42 57.39,51.42 57.52,51.3 57.52,50.74 57.39,50.62 56.59,50.62 56.46,50.49 56.46,49.91 56.59,49.78 57.43,49.78 57.56,49.66 57.56,49.04 57.69,48.92 58.82,48.92 58.95,49.04 58.95,49.76 58.82,49.89 58.41,49.89 58.33,49.96 58.33,51.3 58.46,51.42 v2(59,51.42)
  BOTTOM w0.089: v2(62.04,82.39) 62.49,81.94 JCPU1.AD3
  BOTTOM w0.165: JDIMM1.80 60.62,52.3 60.49,52.43 60.16,52.43 60.04,52.3 60.04,50.93 59.91,50.81 59.57,50.81 59.45,50.93 59.45,51.3 59.32,51.42 v2(59,51.42)
DDR_A_MA15: length 55.2
  IN1 w0.089: 55.89,77.25 56.99,78.36 59.77,78.36 61.9,80.49 v2(61.99,80.49)
  IN1 w0.208: 55.89,77.25 50.49,71.86 50.49,65.2 55.23,60.46 55.23,48.56 55.36,48.43 56.2,48.43 56.33,48.3 56.33,47.73 56.2,47.6 55.25,47.6 55.13,47.47 55.13,46.9 55.25,46.78 55.92,46.78 56.13,46.57 56.13,45.03 56.26,44.9 56.84,44.9 56.96,45.03 56.96,46.57 57.17,46.78 v2(58.28,46.78)
  BOTTOM w0.089: JCPU1.AD2 62.44,80.94 v2(61.99,80.49)
  BOTTOM w0.165: v2(58.28,46.78) 59.33,46.78 60.02,47.46 JDIMM1.78
DDR_A_RAS#: length 56.8
  IN1 w0.089: v2(70.04,84.41) 70.04,84.23 70.62,83.65 70.62,83.23 70.86,82.99 72.3,82.99 72.64,82.65 72.64,79.3 73.65,78.29 73.65,77.14
  IN1 w0.208: v2(70.31,47.06) 70.68,47.06 70.8,46.94 70.8,45.97 70.6,45.76 69.31,45.76 69.19,45.63 69.19,45.05 69.31,44.93 70.6,44.93 70.8,44.72 70.8,44.31 70.93,44.19 71.51,44.19 71.63,44.31 71.63,54.18 72.16,54.7 72.16,57.03 72.84,57.71 72.84,61.96 77.44,66.56 77.44,71.3 73.65,75.09 73.65,77.14
  BOTTOM w0.089: JCPU1.U6 69.51,84.94 v2(70.04,84.41)
  BOTTOM w0.165: JDIMM1.110 69.62,47.54 70.09,47.06 v2(70.31,47.06)
DDR_A_WE#: length 52.4
  IN1 w0.089: 74.88,77.14 74.88,78.05 73.63,79.3 73.63,82.25 71.87,84.01 70.83,84.01 70.64,84.2 70.64,84.81 v2(70.04,85.41)
  IN1 w0.208: 74.88,77.14 74.88,75.6 78.67,71.81 78.67,66.05 74.07,61.46 74.07,57.2 73.45,56.58 73.45,52.37 73.58,52.24 73.75,52.24 73.88,52.12 73.88,50.6 73.75,50.47 73.05,50.47 72.92,50.6 72.92,51.6 72.79,51.73 v2(72.33,51.73)
  BOTTOM w0.089: v2(70.04,85.41) 69.51,85.94 JCPU1.U7
  BOTTOM w0.165: JDIMM1.113 70.51,52 70.78,51.73 v2(72.33,51.73)
DDR_B_BS0: length 73.4
  IN2 w0.089: 69.08,78.03 68.45,78.66 68.45,82.98 69.63,84.16 69.63,84.78 69.84,85 71.63,85 v2(72.04,85.41)
  IN2 w0.208: 69.08,78.03 69.08,72.7 72.01,69.77 72.01,68.12 72.22,67.91 73.96,67.91 74.08,67.79 74.08,67.21 73.96,67.08 72.22,67.08 72.01,66.87 72.01,66.46 72.22,66.25 73.96,66.25 74.08,66.12 74.08,65.54 73.96,65.42 72.22,65.42 72.01,65.21 72.01,64.79 72.22,64.58 73.96,64.58 74.08,64.46 74.08,63.88 73.96,63.75 72.22,63.75 72.01,63.54 72.01,63.12 72.22,62.92 73.96,62.92 74.08,62.79 74.08,62.21 73.96,62.08 72.22,62.08 72.01,61.87 72.01,61.46 72.22,61.25 73.96,61.25 74.08,61.12 74.08,60.54 73.96,60.42 72.22,60.42 72.01,60.21 72.01,59.79 72.22,59.58 73.08,59.58 73.21,59.46 73.21,58.88 73.08,58.75 72.22,58.75 72.01,58.54 72.01,58.12 70.31,56.42 70.31,50.6 70.77,50.14 70.77,46.23 69.13,44.59 69.13,42.54 v2(69.62,42.05)
  BOTTOM w0.089: JCPU1.R7 71.51,85.94 v2(72.04,85.41)
  BOTTOM w0.165: v2(69.62,42.05) 69.13,42.54 69.13,43.17 69.32,43.35 JDIMM2.109
DDR_B_BS1: length 76.5
  IN2 w0.089: 70.32,77.89 69.45,78.76 69.45,83.48 69.8,83.83 70.59,83.83 70.77,84.01 71.38,84.01 71.61,84.24 71.61,84.6 71.84,84.83 72.14,84.83 72.4,85.09 72.4,85.77 v2(73.04,86.41)
  IN2 w0.208: v2(69.92,32.18) 70.57,32.18 70.69,32.05 70.69,31.02 70.48,30.81 69.53,30.81 69.4,30.68 69.4,30.1 69.53,29.98 70.48,29.98 70.69,29.77 70.69,29.43 70.82,29.31 71.49,29.31 71.62,29.43 71.62,32.58 70.87,33.33 70.87,44.46 72.02,45.61 72.02,50.64 71.67,50.98 71.67,55.6 75.31,59.24 75.31,68.3 70.32,73.29 70.32,77.89
  BOTTOM w0.089: JCPU1.P8 72.51,86.94 v2(73.04,86.41)
  BOTTOM w0.165: JDIMM2.108 69.02,35.25 68.8,35.04 68.8,34.24 69.35,33.69 69.35,32.75 v2(69.92,32.18)
DDR_B_BS2: length 70.4
  IN2 w0.089: v2(65.04,88.41) 65.04,88.67 64.89,88.82 59.91,88.82 59.63,88.54 59.63,78.92 57.85,77.14
  IN2 w0.208: 57.85,77.14 57.85,76.32 56.85,75.32 56.85,75.02 57.31,74.57 57.31,74.39 56.9,73.98 56.72,73.98 56.26,74.44 55.97,74.44 53.92,72.39 53.92,66.3 53.78,66.16 53.51,66.16 53.38,66.04 53.38,65.54 53.51,65.42 53.79,65.42 53.92,65.29 53.92,64.77 53.79,64.65 53.37,64.65 53.24,64.52 53.24,57.96 55.2,55.99 55.2,51.13 54.69,50.62 54.69,45.73 54.93,45.5 54.93,41.96 55.08,41.81 55.41,41.81 55.54,41.68 55.54,41.1 55.41,40.98 55.06,40.98 54.93,40.85 54.93,40.03 55.06,39.91 55.41,39.91 v2(56.04,40.53)
  BOTTOM w0.089: v2(65.04,88.41) 65.51,87.94 JCPU1.AA9
  BOTTOM w0.165: v2(56.04,40.53) 56.56,41.05 56.56,41.4 57.86,42.7 59.32,42.7 60.32,43.7 JDIMM2.79
DDR_B_CAS#: length 75
  IN2 w0.089: 70.93,77.67 69.63,78.97 69.63,82.59 70.04,82.99 71.37,82.99 72.41,84.03 72.41,84.85 72.58,85.02 72.58,85.7 72.71,85.82 72.91,85.82 73.04,85.7 v2(73.04,85.41)
  IN2 w0.208: 70.93,77.67 70.93,73.55 75.47,69.01 77.52,69.01 77.65,68.89 77.65,68.31 77.52,68.18 76.14,68.18 75.93,67.97 75.93,67.54 76.14,67.33 78.18,67.33 78.31,67.21 78.31,66.63 78.18,66.5 76.14,66.5 75.93,66.29 75.93,65.88 76.14,65.67 78.18,65.67 78.31,65.54 78.31,64.96 78.18,64.83 76.14,64.83 75.93,64.63 75.93,64.21 76.14,64 78.18,64 78.31,63.87 78.31,63.29 78.18,63.17 76.14,63.17 75.93,62.96 75.93,62.54 76.14,62.33 78.18,62.33 78.31,62.21 78.31,61.63 78.18,61.5 76.14,61.5 75.93,61.29 75.93,58.99 73.06,56.12 73.06,45.78 71.48,44.2 71.48,42.93 v2(71.98,42.43)
  BOTTOM w0.089: JCPU1.P7 72.51,85.94 v2(73.04,85.41)
  BOTTOM w0.165: v2(71.98,42.43) 71.93,42.43 71.12,43.25 71.12,44.58 JDIMM2.115
DDR_B_D0: length 85.1
  IN2 w0.089: 48.24,95.37 50.34,95.37 51.3,96.32 51.3,96.67 v2(52.04,97.41)
  IN2 w0.127: 48.24,95.37 48.13,95.37 43.12,90.35 42.14,90.35 42.01,90.48 42.01,91.8 41.89,91.93 41.63,91.93 41.51,91.8 41.51,90.48 41.38,90.35 41.12,90.35 41,90.48 41,91.82 40.87,91.95 40.62,91.95 40.49,91.82 40.49,90.48 40.36,90.35 40.11,90.35 39.98,90.48 39.98,91.83 39.85,91.96 39.6,91.96 39.47,91.83 39.47,90.48 39.35,90.35 39.09,90.35 38.96,90.48 38.96,91.05 38.83,91.17 38.58,91.17 38.45,91.05 38.45,90.48 38.32,90.35 37.75,90.35 29.18,81.78 29.18,47.65 34.04,42.79 v2(34.04,42.45)
  BOTTOM w0.089: JCPU1.AR18 51.57,96.94 v2(52.04,97.41)
  BOTTOM w0.102: JDIMM2.5 35.71,43.03 35.13,42.45 v2(34.04,42.45)
DDR_B_D1: length 83.2
  IN2 w0.089: 48.24,96.01 48.67,96.44 v2(49.88,96.44)
  IN2 w0.127: v2(34.04,40.93) 33.62,41.34 33.62,41.6 33.49,41.73 32.49,41.73 32.36,41.85 32.36,42.11 32.49,42.23 33.49,42.23 33.62,42.36 33.62,42.67 33.08,43.21 32.9,43.21 32.54,42.85 32.37,42.85 32.19,43.03 32.19,43.21 32.54,43.57 32.54,43.75 28.8,47.49 28.8,81.94 39.2,92.34 42.33,92.34 42.46,92.21 42.46,90.86 42.58,90.73 42.84,90.73 42.96,90.86 42.96,92.21 43.09,92.34 43.35,92.34 43.47,92.21 43.47,91.75 43.6,91.63 43.85,91.63 43.98,91.75 43.98,92.21 44.11,92.34 44.57,92.34 48.24,96.01
  BOTTOM w0.089: JCPU1.AT18 50.38,96.94 v2(49.88,96.44)
  BOTTOM w0.102: JDIMM2.7 36.32,43.2 v2(34.04,40.93)
DDR_B_D2: length 88.9
  IN2 w0.089: v2(55.04,96.41) 54.99,96.46 54.81,96.46 54.68,96.33 54.68,93.53 53.97,92.82 49.69,92.82 48.24,91.37
  IN2 w0.127: v2(36.54,42.55) 36.56,42.57 36.56,43.78 34.65,45.69 34.65,47.39 31.65,50.4 31.65,53.95 32.86,55.16 32.86,57.58 32.99,57.7 33.32,57.7 33.45,57.83 33.45,58.09 33.32,58.21 32.99,58.21 32.86,58.34 32.86,60.02 32.96,60.11 33.19,60.11 33.32,60.24 33.32,60.5 33.19,60.62 31.77,60.62 31.65,60.75 31.65,61 31.77,61.13 33.24,61.13 33.37,61.26 33.37,61.51 33.24,61.64 31.77,61.64 31.65,61.77 31.65,62.02 31.77,62.15 33.24,62.15 33.37,62.27 33.37,62.53 33.24,62.65 31.77,62.65 31.65,62.78 31.65,63.04 31.77,63.16 33.24,63.16 33.37,63.29 33.37,63.54 33.24,63.67 31.77,63.67 31.65,63.8 31.65,80.76 38.77,87.89 44.75,87.89 48.24,91.37
  BOTTOM w0.089: JCPU1.AM17 54.57,95.94 v2(55.04,96.41)
  BOTTOM w0.102: JDIMM2.15 38.71,43.43 38.53,43.25 37.23,43.25 v2(36.54,42.55)
DDR_B_D3: length 87.9
  IN2 w0.089: v2(55.04,97.41) 54.5,96.87 54.5,93.6 53.9,93 49.31,93 48.24,91.93
  IN2 w0.127: v2(36.54,41.03) 36.12,41.45 36.12,43.68 34.27,45.53 34.27,47.23 31.27,50.24 31.27,54.1 32.38,55.21 32.38,56.94 32.25,57.07 31.39,57.07 31.27,57.19 31.27,57.45 31.39,57.57 32.25,57.57 32.38,57.7 32.38,57.96 32.25,58.08 31.39,58.08 31.27,58.21 31.27,58.46 31.39,58.59 32.35,58.59 32.48,58.72 32.48,58.97 32.35,59.1 31.39,59.1 31.27,59.23 31.27,59.48 31.39,59.61 32.35,59.61 32.48,59.73 32.48,59.99 32.35,60.11 31.39,60.11 31.27,60.24 31.27,80.92 38.62,88.27 44.58,88.27 48.24,91.93
  BOTTOM w0.089: JCPU1.AM18 54.57,96.94 v2(55.04,97.41)
  BOTTOM w0.102: v2(36.54,41.03) 36.54,41.12 38.36,42.94 38.79,42.94 39.32,43.46 JDIMM2.17
DDR_B_D4: length 85.5
  IN2 w0.089: v2(50.93,96.47) 50.41,97 48.24,97
  IN2 w0.127: v2(35.27,33.29) 34.85,33.71 34.85,36.28 31.27,39.86 31.27,43.52 28.04,46.75 28.04,82.25 38.89,93.1 44.25,93.1 48.15,97 48.24,97
  BOTTOM w0.089: JCPU1.AR17 51.46,95.94 v2(50.93,96.47)
  BOTTOM w0.102: JDIMM2.4 35.41,35.55 34.86,35 34.86,33.7 v2(35.27,33.29)
DDR_B_D5: length 83.2
  IN2 w0.089: 48.24,96.55 48.51,96.82 50.26,96.82 50.39,96.7 50.39,95.86 50.26,95.73 v2(49.89,95.73)
  IN2 w0.127: 48.24,96.55 44.41,92.72 39.05,92.72 28.42,82.1 28.42,46.9 31.65,43.68 31.65,40.02 35.27,36.4 v2(35.27,34.82)
  BOTTOM w0.089: JCPU1.AT17 50.11,95.94 v2(49.89,95.73)
  BOTTOM w0.102: v2(35.27,34.82) 35.27,34.57 35.4,34.44 35.89,34.44 36.02,34.57 JDIMM2.6
DDR_B_D6: length 88
  IN2 w0.089: 48.24,93.33 48.9,93.99 52.44,93.99 v2(53.92,95.47)
  IN2 w0.127: v2(38.83,34.82) 38.83,36.25 35.36,39.72 35.36,43.36 32.94,45.78 32.37,46.36 32.37,46.7 32.94,47.28 32.94,47.48 32.74,47.69 32.56,47.69 31.89,47.01 31.71,47.01 31.53,47.19 31.53,47.37 32.2,48.05 32.2,48.23 32.02,48.41 31.84,48.41 31.39,47.96 31.21,47.96 31.03,48.13 31.03,48.31 31.48,48.76 31.48,48.94 30.5,49.92 30.5,54.61 30.63,54.74 30.82,54.74 30.95,54.87 30.95,55.12 30.82,55.25 30.63,55.25 30.5,55.37 30.5,55.67 30.63,55.79 31.49,55.79 31.62,55.92 31.62,56.17 31.49,56.3 30.63,56.3 30.5,56.43 30.5,81.23 38.3,89.03 43.94,89.03 48.24,93.33
  BOTTOM w0.089: v2(53.92,95.47) 53.51,95.87 JCPU1.AN17
  BOTTOM w0.102: v2(38.83,34.82) 39.02,35 JDIMM2.16
DDR_B_D7: length 87.6
  IN2 w0.089: v2(54.05,96.31) 54.32,96.04 54.32,95.36 52.78,93.81 49.27,93.81 48.24,92.78
  IN2 w0.127: v2(38.83,33.29) 39.33,33.79 39.33,36.3 35.74,39.88 35.74,43.52 33.33,45.94 33.33,47.64 30.89,50.08 30.89,54.26 32,55.37 32,56.56 31.87,56.69 31.01,56.69 30.89,56.81 30.89,81.07 38.46,88.65 44.11,88.65 48.24,92.78
  BOTTOM w0.089: v2(54.05,96.31) 53.51,96.85 JCPU1.AN18
  BOTTOM w0.102: JDIMM2.18 39.62,34.08 v2(38.83,33.29)
DDR_B_D8: length 74.6
  IN2 w0.089: 48.24,89.99 50.22,89.99 50.35,90.12 50.35,90.28 50.22,90.41 v2(50.04,90.41)
  IN2 w0.127: v2(38.57,42.43) 38.57,43.06 35.57,46.07 35.57,47.77 34.49,48.85 34.49,58.34 33.77,59.06 33.77,59.4 34.28,59.91 34.28,64.46 34.16,64.58 32.69,64.58 32.56,64.71 32.56,64.97 32.69,65.09 34.16,65.09 34.28,65.22 34.28,65.47 34.16,65.6 32.69,65.6 32.56,65.73 32.56,65.98 32.69,66.11 34.16,66.11 34.28,66.24 34.28,66.49 34.16,66.62 32.69,66.62 32.56,66.74 32.56,80.37 39.16,86.97 45.15,86.97 47.81,89.64 48.16,89.99 48.24,89.99
  BOTTOM w0.089: JCPU1.AT12 50.51,90.88 v2(50.04,90.41)
  BOTTOM w0.102: v2(38.57,42.43) 39.58,42.43 40.52,43.37 JDIMM2.21
DDR_B_D9: length 76.7
  IN2 w0.089: v2(51.04,90.41) 50.64,90.81 49.87,90.81 49.51,90.45 48.24,90.45
  IN2 w0.127: v2(38.57,40.91) 38.18,40.91 38.06,40.78 38.06,40.16 37.93,40.03 37.59,40.03 37.46,40.16 37.46,41.23 37.59,41.35 38.03,41.35 38.15,41.48 38.15,41.74 38.03,41.86 37.59,41.86 37.46,41.99 37.46,42.24 37.59,42.37 38.03,42.37 38.16,42.5 38.16,42.75 38.03,42.88 37.59,42.88 37.46,43.01 37.46,43.64 35.19,45.91 35.19,47.61 34.1,48.69 34.1,58.19 33.39,58.9 33.39,59.56 33.9,60.07 33.9,64.08 33.77,64.2 32.31,64.2 32.18,64.33 32.18,80.54 39,87.35 44.98,87.35 48.08,90.45 48.24,90.45
  BOTTOM w0.089: v2(51.04,90.41) 51.51,90.88 JCPU1.AR12
  BOTTOM w0.102: JDIMM2.23 41.11,43.48 39.26,41.63 39.26,41.6 v2(38.57,40.91)
DDR_B_D10: length 80.9
  IN2 w0.089: v2(53.04,90.41) 53.04,90.48 53.54,90.98 54.33,90.98 54.62,90.69 54.62,89.13 54.3,88.81 53.87,88.81 53.64,88.58 53.64,87.16 53.3,86.81 50.88,86.81 48.24,84.17
  IN2 w0.127: v2(42.5,42.43) 42.85,42.78 42.85,46.49 39.52,49.82 39.52,58.95 37.51,60.96 37.51,75.68 37.63,75.8 38.48,75.8 38.6,75.93 38.6,76.18 38.48,76.31 37.63,76.31 37.51,76.44 37.51,76.69 37.63,76.82 38.71,76.82 38.83,76.95 38.83,77.2 38.71,77.33 37.63,77.33 37.51,77.45 37.51,77.71 37.63,77.83 38.78,77.83 38.9,77.96 38.9,78.22 38.78,78.34 37.63,78.34 37.51,78.47 37.51,78.72 37.63,78.85 38.74,78.85 38.86,78.98 38.86,79.23 38.74,79.36 37.63,79.36 37.51,79.49 37.51,79.74 37.63,79.87 38.44,79.87 38.56,79.99 38.56,80.25 38.44,80.37 37.65,80.37 37.53,80.5 37.53,80.77 37.65,80.9 38.33,80.9 38.45,81.03 38.45,81.7 40.5,83.75 47.81,83.75 48.24,84.17
  BOTTOM w0.089: JCPU1.AN12 53.51,90.88 v2(53.04,90.41)
  BOTTOM w0.102: v2(42.5,42.43) 43.16,42.43 44.11,43.38 JDIMM2.33
DDR_B_D11: length 81.6
  IN2 w0.089: v2(54.04,89.41) 54.04,89.23 53.46,88.65 53.46,87.23 53.24,87.01 50.51,87.01 48.24,84.74
  IN2 w0.127: 48.24,84.74 47.62,84.13 40.34,84.13 37.13,80.91 37.13,80.45 37,80.33 36.54,80.33 36.41,80.2 36.41,79.95 36.54,79.82 37,79.82 37.13,79.69 37.13,79.44 37,79.31 35.53,79.31 35.41,79.18 35.41,78.93 35.53,78.8 37,78.8 37.13,78.68 37.13,78.42 37,78.29 35.53,78.29 35.41,78.17 35.41,77.91 35.53,77.79 37,77.79 37.13,77.66 37.13,77.41 37,77.28 35.53,77.28 35.41,77.15 35.41,76.9 35.53,76.77 37,76.77 37.13,76.64 37.13,76.39 37,76.26 36.68,76.26 36.55,76.14 36.55,75.88 36.68,75.75 37,75.75 37.13,75.63 37.13,59.94 38.28,58.79 38.46,58.79 38.71,59.04 38.89,59.04 39.07,58.86 39.07,58.68 38.82,58.43 38.82,58.25 39.14,57.93 39.14,49.66 42.46,46.33 42.46,43.27 42.04,42.84 42.04,41.38 v2(42.5,40.91)
  BOTTOM w0.089: JCPU1.AM11 54.51,89.88 v2(54.04,89.41)
  BOTTOM w0.102: v2(42.5,40.91) 43.21,41.62 43.21,42 44.72,43.5 44.72,44.58 JDIMM2.35
DDR_B_D12: length 75.4
  IN2 w0.089: 48.24,88.93 48.73,89.41 v2(50.04,89.41)
  IN2 w0.127: 48.24,88.93 45.52,86.21 39.48,86.21 33.32,80.06 33.32,68.78 33.45,68.65 34.92,68.65 35.04,68.52 35.04,68.27 34.92,68.14 33.45,68.14 33.32,68.01 33.32,67.76 33.45,67.63 34.92,67.63 35.04,67.51 35.04,59.07 35.77,58.35 35.77,48.65 36.33,48.09 36.33,46.38 39.4,43.31 39.4,39.42 41.03,37.8 v2(41.03,34.84)
  BOTTOM w0.089: v2(50.04,89.41) 50.51,89.88 JCPU1.AT11
  BOTTOM w0.102: v2(41.03,34.84) 40.82,35.06 JDIMM2.22
DDR_B_D13: length 77.4
  IN2 w0.089: 48.24,89.49 48.56,89.81 50.64,89.81 v2(51.04,89.41)
  IN2 w0.127: 48.24,89.49 47.91,89.16 47.91,89.16 45.34,86.59 39.32,86.59 32.94,80.22 32.94,67.25 33.07,67.12 34.54,67.12 34.66,67 34.66,58.91 35.38,58.19 35.38,48.49 35.95,47.93 35.95,46.22 39.02,43.16 39.02,39.27 40.52,37.76 40.52,33.83 v2(41.03,33.32)
  BOTTOM w0.089: JCPU1.AR11 51.51,89.88 v2(51.04,89.41)
  BOTTOM w0.102: v2(41.03,33.32) 41.52,33.82 41.52,35.26 41.41,35.36 JDIMM2.24
DDR_B_D14: length 82.1
  IN2 w0.089: 48.24,85.86 50.38,88 51.11,88 51.12,87.99 52.21,87.99 52.46,88.24 52.46,89.4 52.99,89.93 53.55,89.93 v2(54.04,90.41)
  IN2 w0.127: v2(43.05,34.84) 43.05,37.35 41.27,39.12 41.27,45.58 41.15,45.71 41.15,46.57 37.71,50 37.71,56.33 37.84,56.46 38.11,56.46 38.24,56.58 38.24,56.9 38.11,57.02 37.52,57.02 37.39,57.15 37.39,57.4 37.52,57.53 37.94,57.53 38.07,57.66 38.07,57.91 37.94,58.04 37.52,58.04 37.39,58.17 37.39,58.59 36.36,59.62 36.36,73.6 36.24,73.72 34.77,73.72 34.64,73.85 34.64,74.1 34.77,74.23 36.24,74.23 36.36,74.36 36.36,74.61 36.24,74.74 34.77,74.74 34.64,74.87 34.64,79.51 40.02,84.89 47.27,84.89 48.24,85.86
  BOTTOM w0.089: v2(54.04,90.41) 54.51,90.88 JCPU1.AM12
  BOTTOM w0.102: v2(43.05,34.84) 43.94,34.84 44.41,35.32 JDIMM2.34
DDR_B_D15: length 80.4
  IN2 w0.089: v2(53.04,89.41) 52.64,89.01 52.64,88.16 52.29,87.81 50.75,87.81 48.24,85.3
  IN2 w0.127: 48.24,85.3 47.45,84.51 40.18,84.51 35.03,79.35 35.03,76.39 35.15,76.26 36.04,76.26 36.17,76.14 36.17,75.88 36.04,75.75 35.15,75.75 35.03,75.63 35.03,75.37 35.15,75.25 36.62,75.25 36.75,75.12 36.75,59.78 38.76,57.77 38.76,49.5 41.53,46.72 41.53,45.86 41.66,45.74 41.66,44.19 41.78,44.06 41.95,44.06 42.08,43.93 42.08,43.68 41.95,43.55 41.78,43.55 41.66,43.42 41.66,39.43 43.47,37.61 43.47,33.74 v2(43.05,33.32)
  BOTTOM w0.089: v2(53.04,89.41) 53.51,89.88 JCPU1.AN11
  BOTTOM w0.102: JDIMM2.36 45.02,35.43 43.05,33.47 v2(43.05,33.32)
DDR_B_D16: length 63.9
  IN2 w0.089: 48.24,80.32 48.35,80.42 50,80.42 50.63,81.05 50.63,83.95 50.75,84.07 50.92,84.07 51.04,83.95 v2(51.04,83.41)
  IN2 w0.127: 48.24,80.32 40.74,72.82 40.74,69.95 40.62,69.82 39.31,69.82 39.18,69.69 39.18,69.44 39.31,69.31 40.62,69.31 40.74,69.19 40.74,68.93 40.62,68.8 39.31,68.8 39.18,68.68 39.18,68.42 39.31,68.3 40.62,68.3 40.74,68.17 40.74,67.92 40.62,67.79 39.31,67.79 39.18,67.66 39.18,67.41 39.31,67.28 40.62,67.28 40.74,67.15 40.74,66.9 40.62,66.77 39.31,66.77 39.18,66.65 39.18,66.34 39.31,66.21 39.5,66.21 39.63,66.09 39.63,65.83 39.5,65.7 39.31,65.7 39.18,65.58 39.18,61.65 41.73,59.1 41.73,50.74 44.56,47.92 v2(44.56,42.39)
  BOTTOM w0.089: JCPU1.AR5 51.51,83.88 v2(51.04,83.41)
  BOTTOM w0.102: v2(44.56,42.39) 44.72,42.39 45.92,43.58 JDIMM2.39
DDR_B_D17: length 65.3
  IN2 w0.089: v2(51.04,84.41) 50.74,84.41 50.45,84.12 50.45,81.41 49.9,80.86 48.24,80.86 48.24,80.86
  IN2 w0.127: v2(44.56,40.86) 44.14,41.28 44.14,47.8 43.18,48.76 43,48.76 42.79,48.56 42.61,48.56 42.43,48.74 42.43,48.92 42.64,49.12 42.64,49.3 42.46,49.48 42.28,49.48 42.07,49.28 41.89,49.28 41.71,49.46 41.71,49.64 41.92,49.84 41.92,50.02 41.35,50.59 41.35,56.33 41.23,56.45 41,56.45 40.88,56.58 40.88,56.83 41,56.96 41.23,56.96 41.35,57.09 41.35,57.34 41.23,57.47 41,57.47 40.88,57.6 40.88,57.85 41,57.98 41.23,57.98 41.35,58.1 41.35,58.95 38.8,61.5 38.8,69.94 39.06,70.2 40.24,70.2 40.36,70.33 40.36,70.58 40.24,70.71 38.93,70.71 38.8,70.84 38.8,71.09 38.93,71.22 40.24,71.22 40.36,71.34 40.36,71.6 40.24,71.73 39.62,71.73 39.49,71.85 39.49,72.11 39.62,72.23 40.24,72.23 40.36,72.36 40.36,72.98 48.24,80.86
  BOTTOM w0.089: JCPU1.AR6 51.51,84.88 v2(51.04,84.41)
  BOTTOM w0.102: JDIMM2.41 46.52,43.64 45.03,42.15 45.03,41.33 v2(44.56,40.86)
DDR_B_D18: length 66.6
  IN2 w0.089: v2(54.04,83.41) 53.64,83.01 53.64,80.65 51.97,78.98 50.39,78.98 48.55,77.14
  IN2 w0.127: 48.55,77.14 44.51,73.1 44.51,67.35 44.38,67.23 43.33,67.23 43.21,67.1 43.21,66.85 43.33,66.72 44.38,66.72 44.51,66.59 44.51,66.34 44.38,66.21 43.33,66.21 43.21,66.08 43.21,65.83 43.33,65.7 44.38,65.7 44.51,65.58 44.51,65.32 44.38,65.19 43.33,65.19 43.21,65.07 43.21,64.81 43.33,64.69 44.38,64.69 44.51,64.56 44.51,64.3 44.38,64.18 43.33,64.18 43.21,64.05 43.21,63.8 43.33,63.67 44.38,63.67 44.51,63.54 44.51,63.29 44.38,63.16 43.33,63.16 43.21,63.03 43.21,62.78 43.33,62.65 44.38,62.65 44.51,62.53 44.51,62.27 44.38,62.15 43.33,62.15 43.21,62.02 43.21,61.76 43.33,61.64 44.38,61.64 44.51,61.51 44.51,61.26 44.38,61.13 43.7,61.13 43.58,61 43.58,60.75 43.7,60.62 44.38,60.62 44.51,60.49 44.51,56.78 45.08,56.21 45.08,50.88 47.49,48.47 47.49,42.57 v2(47.61,42.46)
  BOTTOM w0.089: v2(54.04,83.41) 54.04,83.47 JCPU1.AM5
  BOTTOM w0.102: JDIMM2.51 49.52,43.6 48.37,42.46 v2(47.61,42.46)
DDR_B_D19: length 67.4
  IN2 w0.089: v2(54.04,84.41) 54.04,84.12 53.46,83.54 53.46,80.73 51.91,79.18 50.05,79.18 48.24,77.37
  IN2 w0.127: 48.24,77.37 44.13,73.26 44.13,71.93 44,71.8 42.98,71.8 42.86,71.67 42.86,71.42 42.98,71.29 44,71.29 44.13,71.16 44.13,70.91 44,70.78 42.95,70.78 42.83,70.66 42.83,70.4 42.95,70.27 44,70.27 44.13,70.15 44.13,69.89 44,69.77 42.95,69.77 42.83,69.64 42.83,69.39 42.95,69.26 44,69.26 44.13,69.13 44.13,68.88 44,68.75 42.95,68.75 42.83,68.62 42.83,68.37 42.95,68.24 44,68.24 44.13,68.12 44.13,67.86 44,67.73 42.95,67.73 42.83,67.61 42.83,60.96 44.13,59.66 44.13,56.62 44.7,56.05 44.7,50.73 47.11,48.31 47.11,40.71 47.24,40.59 47.38,40.59 47.51,40.71 47.51,40.83 v2(47.61,40.93)
  BOTTOM w0.089: v2(54.04,84.41) 54.51,84.88 JCPU1.AM6
  BOTTOM w0.102: JDIMM2.53 50.11,43.3 49.89,43.08 49.42,43.08 48.31,41.96 48.31,41.63 v2(47.61,40.93)
DDR_B_D20: length 63.5
  IN2 w0.089: v2(50.03,83.39) 50.03,83.18 48.24,81.39
  IN2 w0.127: v2(45.34,34.84) 44.51,34.84 44.39,34.97 44.39,35.37 44.51,35.49 45.39,35.49 45.52,35.62 45.52,35.87 45.39,36 44.51,36 44.39,36.13 44.39,36.38 44.51,36.51 45.39,36.51 45.52,36.64 45.52,36.89 45.39,37.02 44.51,37.02 44.39,37.14 44.39,39.14 43.76,39.77 43.76,46.87 40.49,50.13 40.49,59.27 38.42,61.34 38.42,71.57 48.24,81.39
  BOTTOM w0.089: JCPU1.AT5 50.51,83.87 v2(50.03,83.39)
  BOTTOM w0.102: JDIMM2.40 46.22,35.29 45.77,34.84 v2(45.34,34.84)
DDR_B_D21: length 64.1
  IN2 w0.089: v2(50.03,84.39) 50.03,83.91 49.6,83.48 49.6,83.3 48.24,81.93
  IN2 w0.127: v2(45.34,33.32) 44.37,33.32 44.01,33.68 44.01,38.98 43.38,39.61 43.38,46.71 40.11,49.98 40.11,59.11 38.04,61.18 38.04,71.73 48.24,81.93
  BOTTOM w0.089: JCPU1.AT6 50.51,84.87 v2(50.03,84.39)
  BOTTOM w0.102: v2(45.34,33.32) 46.31,34.29 46.31,34.88 46.81,35.38 JDIMM2.42
DDR_B_D22: length 66.3
  IN2 w0.089: 48.24,77.91 49.71,79.37 51.82,79.37 52.64,80.19 52.64,83.3 52.74,83.41 v2(53.04,83.41)
  IN2 w0.127: v2(47.63,34.84) 47.47,35 47.47,35.6 47.35,35.73 46.86,35.73 46.73,35.86 46.73,36.1 46.86,36.23 47.39,36.23 47.52,36.36 47.52,36.61 47.39,36.74 46.86,36.74 46.73,36.86 46.73,37.12 46.86,37.24 47.39,37.24 47.52,37.37 47.52,37.63 47.39,37.75 46.86,37.75 46.73,37.88 46.73,38.13 46.86,38.26 47.39,38.26 47.52,38.39 47.52,38.64 47.39,38.77 46.86,38.77 46.73,38.9 46.73,39.15 46.86,39.28 47.39,39.28 47.52,39.4 47.52,39.66 47.39,39.78 46.86,39.78 46.73,39.91 46.73,48.15 43.75,51.14 43.75,59.5 42.45,60.8 42.45,72.11 48.24,77.91
  BOTTOM w0.089: JCPU1.AN5 53.51,83.88 v2(53.04,83.41)
  BOTTOM w0.102: v2(47.63,34.84) 48.46,34.84 48.58,34.72 48.58,34.56 48.71,34.44 48.95,34.44 49.08,34.56 49.08,35.2 49.22,35.34 JDIMM2.50
DDR_B_D23: length 67
  IN2 w0.089: 48.24,78.45 49.38,79.59 51.79,79.59 52.46,80.26 52.46,84.25 52.62,84.41 v2(53.04,84.41)
  IN2 w0.127: 48.24,78.45 42.06,72.27 42.06,60.64 43.37,59.34 43.37,50.98 46.06,48.29 46.35,48 46.35,35.35 46.48,35.22 46.96,35.22 47.09,35.09 47.09,34.84 46.96,34.71 46.48,34.71 46.35,34.59 46.35,33.6 46.63,33.32 v2(47.63,33.32)
  BOTTOM w0.089: v2(53.04,84.41) 53.51,84.88 JCPU1.AN6
  BOTTOM w0.102: v2(47.63,33.32) 49.25,33.32 49.38,33.45 49.38,35.08 49.81,35.51 JDIMM2.52
