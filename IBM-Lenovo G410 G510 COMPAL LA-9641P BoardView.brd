# Allegro board IBM-Lenovo G410 G510 COMPAL LA-9641P BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.5VS: length 157.5
  TOP w0.254: R244.1 113.09,81.94 113.93,81.94 114.68,81.19 116.02,81.19 116.68,81.85 U4.BE30 ; U4.AT45 v2(120.71,75.01) ; v2(116.15,87.94) 116.15,87.94 116.43,87.66 U4.BE16 ; U4.AM45 122.37,75.47 122.37,74.99 v2(121.95,74.56) ; v2(117.34,92.16) 117.32,92.18 U4.BD4
  TOP w0.508: 193.19,106.31 197.56,106.31 201.72,110.48 201.72,136.07 203.37,137.72 208.32,137.72 211.08,140.47 ; v2(110.83,81.59) 111.77,82.54 R244.1
  TOP w0.762: 118.58,104 118.58,105.38 119.95,106.74 123.68,106.74 125.15,105.27 128.09,105.27 128.72,104.63 129.37,104.63 129.86,104.14 138.39,104.14 139.55,105.31 139.55,109.45 139.57,109.46
  IN1 w0.508: v2(116.15,87.94) 116.15,87.71 110.83,82.38 v2(110.83,81.59) 110.05,80.81 110.05,71.2 110.54,70.71 ; 110.54,70.71 114.92,70.71 118.42,74.22 120.19,74.22 120.71,74.74 v2(120.71,75.01) ; 110.54,70.71 110.05,70.22 110.05,68.55 115.12,63.47 129.22,63.47 130.16,64.41 130.16,71.14 132.27,73.25 v2(132.51,73.25)
  BOTTOM w0.508: v2(121.95,74.56) 121.26,73.88 R145.2 120.23,74.52 v2(120.71,75.01) ; LH1.1 131.75,74.28 132.51,73.52 v2(132.51,73.25)
  vias: v2(118.68,102.87) v2(118.68,102.25) v2(191.08,107.02) v2(191.08,106.39) v2(191.08,105.75) v2(191.08,105.12) v2(191.08,104.48) v2(191.08,103.85) v2(191.71,107.02) v2(191.71,106.39) v2(191.71,105.75) v2(191.71,105.12) v2(191.71,104.48) v2(191.71,103.85) v2(210.5,143.06) v2(210.5,142.42) v2(211,142.73) v3(145.69,111.55) v4(194.62,24.98) v4(194.6,24.29) v4(194.57,23.59) v4(195.22,23.58) v4(195.27,24.95) v4(195.28,24.28) v4(195.93,24.96) v4(195.92,24.24) v4(195.92,23.61) v4(195.92,22.95)
+1.05VS: length 184.6
  TOP w0.254: U4.U36 128.04,79.23 v2(127.77,79.49) 128.11,79.83 U4.U35 ; U4.AN35 121.58,79.83 v2(121.33,80.07) 121.74,80.47 U4.AN34 ; U4.L17 130.99,87.08 131.39,87.47 v2(131.39,87.53)
  TOP w0.508: R595.2 169.92,70.57 170.34,70.15 170.34,68.23 172.61,65.96 v2(172.61,63.34) ; v2(89.52,111.2) R88.2 ; R78.2 89.38,100.47 v2(89.38,101.27) ; R659.1 113.04,56.02 v4(113.04,56.03) ; v2(108,85.31) 108,86.98 105.82,89.15 105.82,99.68 v2(106.29,100.15) ; R258.2 116.09,98.94 115.46,99.57 112.07,99.57 v2(111.93,99.7)
  TOP w1.016: 138.22,68.56 136.82,67.17 132.6,67.17 129.53,64.11 127.9,64.11 127.49,63.7 124.58,63.7
  IN1 w0.508: v2(131.39,87.53) 130.4,87.53 129.65,86.78 128.66,86.78 128.12,86.24 v2(128.12,85.77) ; v2(45.78,111.73) 45.78,114.56 47.76,116.55 64.13,116.55 67.5,119.91 75.15,119.91 76.92,118.15 84.5,118.15 89.52,113.13 v2(89.52,111.2) 89.38,111.06 v2(89.38,101.27) 89.66,101.27 90.3,101.91 100,101.91 100.94,100.97 105.47,100.97 v2(106.29,100.15) 106.33,100.11 110.87,100.11 111.27,99.7 v2(111.93,99.7)
  IN2 w0.508: v2(172.61,63.34) 172.18,62.91 166.35,62.91 165.59,63.68 152.99,63.68 152.18,62.86 140.56,62.86 139.59,63.83 139.59,67.67 v2(139.6,67.67)
  BOTTOM w0.457: v2(123.74,73.35) 123.16,73.93 R300.1
  BOTTOM w0.508: v2(121.33,80.07) 121.33,80.69 C134.1
  vias: v2(113.55,69.76) v2(113.55,69.14) v2(120.73,85.55) v2(121.14,64.68) v2(121.33,85.54) v2(121.73,64.67) v2(122.84,85.77) v2(123.5,85.77) v2(124.82,85.77) v2(124.82,84.96) v2(126.14,85.77) v2(126.14,84.96) v2(126.14,84.15) v2(126.14,83.33) v2(126.8,85.77) v2(126.8,84.15) v2(126.8,82.52) v2(128.12,82.52) v3(123.39,63.41) v4(110.97,56.75) v4(110.96,56.08) v4(111.66,56.75) v4(111.65,56.07) v4(112.33,56.73) v4(112.32,56.05) v4(113.05,56.7) v4(113.73,56.73) v4(113.72,56.05)
+1.5VS_PWRGD: length 112.5
  TOP w0.254: R406.2 158.68,71.64 158.35,71.31 158.35,70.1 159.57,68.88 159.57,67.14 v3(160.63,66.08) 161.68,65.03 161.68,61.81 165.29,58.2 175.62,58.2 176.46,57.36 182.34,57.36 183.71,58.73 183.71,60.12 184.41,60.82 187.24,60.82 v2(188.42,62)
  IN1 w0.254: v2(188.42,62) 189.21,61.21 195.33,61.21 197.4,59.14 197.4,50.57 190.47,43.63 190.47,15.15 193.99,11.63 198.09,11.63 v2(198.93,12.47)
  BOTTOM w0.254: PU601.2 198.61,12.16 v2(198.93,12.47) 198.93,13.01 PR602.1
+1.05VSP: length 45.3
  TOP w0.254: v2(111.57,47.54) 104.84,47.54 100.97,43.67 100.97,40.27 99.36,38.66 99.36,35.95 97.31,33.91 97.31,27.45 99.7,25.07 v3(105.46,25.07) 107.16,25.07 108.5,26.41 108.5,26.98 PR707.1 PR709.2
+1.5VSP: length 11.7
  BOTTOM w0.254: v4(198.47,23.4) 196.05,20.98 196.05,14.36 196.27,14.14 PR607.1 196.75,13.24 PC607.1
  vias: v1(200.73,17.65) v4(198.44,24.09) v4(199.14,24.12) v4(199.15,23.39) v4(200.92,13.89) v4(201.62,13.92) v4(202.29,13.9) v4(202.97,13.92) v4(203.68,13.93) v4(204.36,13.92) v4(205.04,13.92) v4(205.8,13.91) v4(206.48,13.89) v4(207.16,13.9)
+1.8V_EN: length 7.8
  TOP w0.102: v1(116.76,172.62) 116.21,172.62 115.68,172.08 PR626.1
  TOP w0.254: v2(114.97,169.48) 115.18,169.69 PC619.1 115.18,170.88 PR623.2 115.68,171.39 PR626.1
  BOTTOM w0.254: PU603.1 112.8,170.74 113.06,171 113.38,171 113.64,170.73 PD601.2 114.35,170.1 v2(114.97,169.48)
+1.8V_FB: length 2.6
  BOTTOM w0.102: v4(113.65,173.8) 113.65,174.42 113.57,174.5 v1(113.25,174.5)
  BOTTOM w0.508: PU603.6 112.8,173.35 113.25,173.8 v4(113.65,173.8)
+1.8V_LX: length 2
  TOP w0.102: PR614.1 110.18,168.5 v1(109.48,167.8)
  vias: v4(110.2,169.47) v4(110.84,169.47)
+1.8V_SNUB: length 1.8
  TOP w0.102: v1(110.5,164.26) 111.14,164.91 PR614.2
+1.8V_VIN:
  vias: v1(111.01,174.04) v4(110.37,174.17) v4(110.37,173.49)
+1.8VGS: length 143
  TOP w0.508: LV3.1 145.76,127.75 RV43.1 v2(144.89,126.34) 144.79,126.24 143.76,126.24 143.09,126.9 LV1.2 ; v2(145.07,123.74) LV2.2 145.94,124.45 RV23.1 ; LV7.1 v2(140.69,123.26) ; v2(137.37,123.37) 136.93,123.8 RV22.1 RV20.1 ; RV21.1 152.68,131.93 153.16,132.41 v2(153.16,132.74) ; v2(143.92,133.63) 143.31,134.25 LV8.1
  IN1 w0.508: v2(143.92,133.63) 144.17,133.39 152.51,133.39 v2(153.16,132.74)
  IN1 w1.016: 115.99,164.94 115.99,170.12 114.97,171.14 114.97,172.93 115.69,173.66 117.75,173.66 120.75,176.65 157.5,176.65 160.38,173.77 160.38,161.54 157.64,158.8 157.64,152.82
  IN2 w0.508: v2(143.92,133.63) 143.54,134.02 142.69,134.02 142.25,133.58 142.25,129.74 144.89,127.1 v2(144.89,126.34) ; v2(157.06,151.53) 157.84,150.75 157.84,149.02 156.11,147.28 v2(156.11,145.56) 155.68,145.14 155.68,138.57 153.67,136.55 153.67,136.29 153.66,136.28 153.66,133.25 v2(153.16,132.74) ; v2(137.37,123.37) 137.53,123.2 140.63,123.2 v2(140.69,123.26) 140.79,123.16 144.49,123.16 v2(145.07,123.74)
  BOTTOM w0.508: v2(144.89,126.34) 145.07,126.16 v2(145.07,123.74) ; RV13.2 v2(156.11,145.56)
  vias: v2(137.34,148.35) v2(150.16,150.39) v2(150.55,149.39) v2(157.02,152.19) v3(154.63,150.42) v4(114.46,164.17) v4(115.16,164.17)
+1.8VGSP: length 9.4
  TOP w0.254: v2(113.57,170.01) 113.57,171.77 PC625.2 114.74,172 PR625.1
  IN1 w0.254: v4(111.63,164.7) 111.32,165.01 111.32,167.24 113.39,169.31 113.39,169.83 v2(113.57,170.01)
  vias: v1(113.46,168.06) v4(114.66,167.48) v4(114.66,166.79)
+1.35V: length 109.6
  TOP w0.508: 48.21,58.37 38.03,58.37 34.58,61.82 32.15,61.82 ; 48.05,45.06 48.04,45.06
  BOTTOM w0.356: JDIMM1.106 68.42,47.99 v2(68.46,47.95) ; v2(67.83,56.17) 68.11,56.46 JDIMM1.105 ; v2(61.26,32.94) 61.41,32.94 62.8,34.34 62.8,35.02 63.02,35.23 JDIMM2.88 ; v2(66.28,40.91) 67.25,40.91 68,41.66 68,43.54 68.01,43.54 68.11,43.64 JDIMM2.105 ; v2(69.92,34.46) 70.22,34.76 JDIMM2.112 ; v2(57.8,54.27) 57.81,54.26 58.17,54.26 59.11,55.2 JDIMM1.75 ; v2(72.59,47.9) 72.59,47.89 72.5,47.89 72.02,48.38 JDIMM1.118 ; JDIMM2.123 73.52,43.61 v2(73.93,43.19) ; JDIMM1.99 66.32,56.16 v2(65.94,55.79) ; JDIMM1.93 64.51,55.8 64.53,55.79 v2(64.39,55.79) ; JDIMM2.111 69.92,46.03 v2(70.31,46.43) ; JDIMM2.81 60.92,45.74 v2(60.71,45.94) 59.53,45.94 59.11,45.53 JDIMM2.75 ; v2(60.91,39) 61.22,38.7 JDIMM2.82 ; v2(72.33,50.97) 72.33,50.97 73.38,50.97 73.81,50.53 JDIMM1.124 ; JDIMM1.76 59.41,47.95 59,47.54 v2(58.28,47.54) ; v2(59,52.19) 59,52.82 60.92,54.74 JDIMM1.81 ; v2(67.92,34.84) 68.42,35.34 JDIMM2.106 ; v2(64.48,42.81) 64.52,42.84 JDIMM2.93 ; v2(67.07,47.82) 66.62,48.28 JDIMM1.100 ; JDIMM1.82 61.22,50.69 61.74,51.22 v2(62.61,51.22) ; JDIMM2.124 73.81,35.24 v2(72.66,34.08) ; JDIMM2.76 59.41,38.01 v2(59.12,38.3) ; v2(66.28,43.19) 66.32,43.23 JDIMM2.99 ; v2(62.61,55.79) 62.72,55.9 JDIMM1.87 ; JDIMM2.87 62.72,43.21 61.55,42.05 60.91,42.05 v2(60.91,42.05) ; JDIMM1.112 70.21,47.79 v2(70.31,47.7) ; JDIMM2.94 64.81,35.16 64.69,35.04 64.69,33.7 63.92,32.94 v2(63.73,32.94) ; JDIMM1.117 71.71,57.58 71.71,54.63 72.32,54.02 v2(72.33,54.02) ; JDIMM1.94 64.81,47.99 v2(64.65,47.82) ; v2(71.98,43.19) 71.93,43.19 71.71,43.41 71.71,44.58 JDIMM2.117 ; JDIMM2.118 72.02,38.59 v2(71.98,38.62) ; JDIMM2.100 66.62,35.27 66.78,35.1 66.78,33.51 67.74,32.56 v2(67.92,32.56) ; v2(69.84,55.79) 69.92,55.86 JDIMM1.111 ; JDIMM1.88 63.02,48.21 v2(62.74,47.94) ; v2(75.14,55.57) 74.38,55.57 73.51,56.44 JDIMM1.123
  vias: v1(55.48,27.73)
+1.35V_CPU_VDDQ: length 11
  TOP w0.508: R30.1 87.56,92.49 87.04,91.97 86.55,91.97
  BOTTOM w0.356: JCPU1.AE2 61.51,80.95 v2(61.04,81.42) ; JCPU1.T8 70.51,86.91 v2(71.04,86.38) ; JCPU1.T5 70.51,83.93 v2(71.04,83.39) ; v2(68.05,84.46) 67.53,83.94 JCPU1.W5 ; v2(64.04,87.4) 64.5,86.94 JCPU1.AB8 ; v2(61.04,84.39) 61.49,83.94 JCPU1.AE5 ; JCPU1.AB2 64.51,80.88 v2(64.04,80.4) ; v2(74.04,86.4) 73.51,86.93 JCPU1.N8 ; JCPU1.W8 67.57,86.94 v2(68.04,87.41) ; JCPU1.AE8 61.51,86.96 v2(61.04,87.43) ; JCPU1.T2 70.53,80.94 v2(71.04,81.45) ; v2(65.04,84.44) 64.54,83.94 JCPU1.AB5 ; v2(68.04,81.41) 67.57,80.94 JCPU1.W2
  vias: v1(71.1,64.56) v2(57.9,91.55) v2(57.93,90.86) v2(58.92,91.55) v2(58.95,90.86) v2(60.1,91.57) v2(60.13,90.89) v2(61.11,91.57) v2(61.14,90.89) v2(62.13,91.57) v2(62.14,90.86) v2(63.15,91.57) v2(63.17,90.89) v2(64.16,91.57) v2(64.19,90.89) v2(65.18,91.57) v2(65.21,90.89) v2(66.19,91.57) v2(66.22,90.89) v2(67.21,91.57) v2(67.24,90.89) v2(68.23,91.57) v2(68.25,90.89) v2(69.24,91.57) v2(69.27,90.89) v2(70.26,91.57) v2(70.29,90.89) v2(71.04,89.53) v2(71.27,91.57) v2(71.3,90.89) v2(72.29,91.57) v2(72.32,90.89) v2(73.31,91.57) v2(73.33,90.89) v2(73.98,89.46) v2(74.32,91.57) v2(74.35,90.89) v2(75.34,91.57) v2(75.37,90.89) v2(76.35,91.57) v2(76.38,90.89) v2(77.37,91.57) v2(77.4,90.89) v2(78.39,91.57) v2(78.39,90.91)
+1.35VP: length 60
  TOP w0.254: PR507.1 31.39,10.86 v2(31.02,10.49)
  TOP w0.508: 47.38,13.09 39.4,13.09 38.3,11.99 38.3,10.02
  IN2 w0.254: v2(31.02,10.49) 31.11,10.49 32.01,11.39 35.02,11.39 35.57,10.84 37.37,10.84 39.33,12.8 42.29,12.8 44.83,15.34 52.59,15.34 v2(52.75,15.5)
  IN2 w0.508: v4(31.76,10.35) 32.25,10.84 34.77,10.84 35.38,10.23 37.57,10.23 39.57,12.23 42.6,12.23 45.19,14.81 v2(52.73,14.81)
  vias: v1(62.87,16.86)
+3V_HDD:
  vias: v3(159.74,124.9)
+3V_LAN: length 11.4
  TOP w0.203: UL1.16 31.69,30.8 31.36,31.12
  IN1 w1.016: 37.92,26.89 37.92,28.66 36.36,30.22 30.61,30.22
  vias: v2(30.28,31.05) v2(30.89,31.05) v2(38.93,26.31) v2(38.93,25.73) v3(36.11,24.9)
+3V_LDO: length 128.4
  TOP w0.254: PU201.5 v2(189.48,69.2)
  IN1 w0.254: v2(189.48,69.2) 189.48,69.13 185.14,64.79 185.14,59.41 183.59,57.86 179.37,57.86 177.05,55.53 177.05,38.91 180.61,35.34 180.61,21.65 v2(179.09,20.13)
  BOTTOM w0.254: v2(179.09,20.13) 178.44,19.48 122.82,19.48 119.86,16.52 v3(119.3,16.52) PC213.1 114.57,16.11 114.07,16.11 113.76,16.42 PU202.5
+3V_PCH: length 140.5
  TOP w0.254: U4.K8 131.53,91 v2(131.68,90.85) ; v2(135.77,83.69) 135.77,83.71 135.65,83.6 U4.A26 ; U4.AJ30 123.84,82.03 v2(124.16,81.71) 123.84,81.39 U4.AJ32
  TOP w0.508: 156.37,63.29 154.15,61.07 148.31,61.07 147.57,60.33 147.57,57.06 146.88,56.37 RA2.1 ; 156.37,63.29 156.37,64.03 v2(154.11,66.29) ; 156.37,63.29 159.22,63.29 160.27,62.24 160.27,56.44 160.13,56.29 RA4.1 ; v2(136.96,99.13) 137.18,98.92 R222.1 137.17,98.27 R216.1 ; R100.2 138.16,83.2 v2(138.11,83.26) ; 143.85,87.26 143.46,86.88 R173.1 ; v2(130.47,101.99) 130.47,101.98 130.92,101.53 130.92,101.11
  IN1 w0.508: v2(143.82,73.38) 144.05,73.61 v2(144.05,75.99) 141.9,75.99 141.56,75.65 139.09,75.65 138.23,76.5 138.23,77.73 138.73,78.23 138.73,81.65 138.11,82.27 v2(138.11,83.26)
  IN2 w0.508: v2(143.82,73.38) 144.22,73.38 151.4,66.19 154.01,66.19 v2(154.11,66.29)
  BOTTOM w0.508: C160.1 135.72,83.64 v2(135.77,83.69) ; v2(130.47,101.99) 130.17,102.3 130.17,104.3 128.58,105.89 124.42,105.89 124.14,106.17 115.19,106.17 113.07,108.29 100.47,108.29 95.85,103.67 95.85,100.82 93.97,98.95 93.97,93.77 95.21,92.54 95.21,90.94 v2(93.09,88.82) ; v2(142.86,86.16) 142.86,85.32 R261.1 142.86,85.31 142.86,83.63 142.38,83.15 R105.2 138.22,83.15 v2(138.11,83.26) 138.11,83.74 137.88,83.97 R106.1 ; R177.1 126.39,94.12 R272.1 127.31,94.13 R226.2 R227.2 130.03,94.13 R221.1 130.26,94.37 130.26,96.85 130.54,97.13
  vias: v2(126.93,99.59) v2(127.52,99.58) v2(128.77,85.76) v2(128.79,84.95) v2(129.68,97.15) v2(130.25,99.96) v2(144.18,89.82) v2(144.62,90.29) v2(144.81,97.85) v3(144.19,88.8)
+3V_ROM: length 110.2
  TOP w0.254: v2(125.18,89.75) 125.21,89.75 125.69,89.27 U4.AD12
  TOP w0.508: 133.85,61.4 v1(132.07,61.4) 129.09,61.4 v2(128.26,62.23) ; v2(109.2,106.52) 109.42,106.31 109.42,103.26 110.97,101.71 110.97,100.73 109.67,99.44 109.67,96.34 v2(110.01,96)
  IN1 w0.508: v2(125.18,89.75) 125.4,89.75 126.37,88.78 127.08,88.78 127.48,88.39 127.48,84.68 127.99,84.17 129.5,84.17 130.07,83.6 130.07,82.29 129.84,82.06 129.84,81.61 131.24,80.21 131.24,79.78 131.59,79.42 133.32,79.42 134.11,78.64 134.11,77.29 134.49,76.91 134.49,75.38 134.13,75.03 134.13,72.16 133.23,71.26 133.23,66.13 129.33,62.23 v2(128.26,62.23) 114.87,62.23 108.8,68.3 108.8,94.78 v2(110.01,96)
  BOTTOM w0.457: C167.1 125.76,89.75 v2(125.18,89.75)
  BOTTOM w0.508: v2(110.01,96) 109.18,96 108.85,95.67 U8.8 ; R230.1 v2(109.2,106.52) R229.1
+3VALW: length 568.8
  TOP w0.508: R304.2 v2(156.74,74.15) ; R764.1 154.18,10.7 159.48,5.4 191.99,5.4 194.9,8.31 v4(194.9,12.15) 191.26,15.79 191.26,31.46 190.66,32.05 v2(187.37,32.05) JP3.1 ; v2(179.81,51.54) 179.62,51.35 179.62,49.61 179.98,49.25 JLED1.2 ; PR108.2 189.72,122.13 187.85,123.99 v3(187.85,125.83) 187.85,129.05 v2(187.92,129.12) ; RV35.1 161.4,117.22 161.75,117.57 v2(161.75,118.35) ; PR211.2 181.28,68.27 PR214.2 v2(180.47,69.02) ; v2(161.65,94.03) 161.99,94.37 163.76,94.37 163.81,94.32 166.69,94.32 166.95,94.57 171.05,94.57 171.86,95.39 174.53,95.39 174.66,95.26 177.18,95.26 177.92,94.52 177.92,93.98 180.5,91.4 180.5,88.66 179.83,87.99 R606.2 ; PR315.1 v4(191.39,168.09) ; v2(94.67,118.53) 94.67,114.22 96,112.88 R642.2 ; v2(193.66,81.67) 193.08,81.1 PR103.1
  IN1 w0.508: v2(162.28,76.4) 167,76.4 167.55,76.95 v2(169,76.95) ; v2(180.47,69.02) 188.14,69.02 193.66,74.53 v2(193.66,81.67) ; v4(174.23,127.86) 180.16,127.86 180.6,128.29 187.09,128.29 v2(187.92,129.12) 187.98,129.18 188.63,129.18 191.33,131.89 191.33,134.9 192.22,135.79 192.22,138.15 193.7,139.62 193.7,150.2 192.08,151.81 192.08,165.36 191.39,166.05 v4(191.39,168.09) ; v2(198.43,15.07) 197.82,15.07 v4(194.9,12.15) ; v2(133.12,100.52) 135.13,98.51 138.02,98.51 138.43,98.1 138.43,96.61 v2(137.93,96.11) ; v2(162.23,80.96) 163.12,81.85 165.63,81.85 166.62,82.84 166.62,85.44 166,86.07 v2(164.1,86.07)
  IN1 w1.016: 137.43,110.94 136.66,111.72 131.48,111.72 129.52,109.76 118.65,109.76 118.38,110.03 110,110.03 108.97,109 97.63,109 93.81,112.82 93.81,118.08 ; 109.49,170.19 109.07,169.77 109.07,165.97 107.46,164.36 103.54,164.36 102.77,163.6 102.77,158.57 103.63,157.71 103.63,150.34 102.95,149.66 102.95,147.89 101.06,145.99 101.06,132.22 99.93,131.1 99.93,124.55 100.39,124.09 100.37,124.07 ; 154.99,93.56 154.71,93.84 145.71,93.84 143.68,95.87 143.68,97.2
  IN2 w0.508: v2(160.77,68.04) 161.34,67.47 169.07,67.47 169.64,68.04 179.5,68.04 v2(180.47,69.02) ; v2(142.58,97.53) 142.02,96.98 142.02,94.84 141.6,94.41 140.58,94.41 139.71,93.54 139.21,93.54 138.63,94.11 138.63,95.41 v2(137.93,96.11) ; v2(161.75,118.35) 164.98,118.35 167.27,120.63 171.62,120.63 173.21,122.22 173.21,123.94 174.23,124.96 v4(174.23,127.86) ; v2(148.41,89.16) 147.11,87.87 v2(137.52,87.87)
  IN2 w1.016: 45.98,17.04 48.8,17.04 49.23,17.47 74.53,17.47 76.83,15.17 86.09,15.17 86.82,15.91
  BOTTOM w0.203: RP10.2 131.82,98.37 131.96,98.22 132.97,98.22 133.36,98.6 133.36,100.28 v2(133.12,100.52)
  BOTTOM w0.381: R307.2 137.52,87.52 v2(137.52,87.87)
  BOTTOM w0.508: v2(161.65,94.03) 161.65,96.73 162.75,97.83 162.75,111.65 161.75,112.65 v2(161.75,118.35) ; v2(162.23,80.96) 162.83,80.36 163.94,80.36 164.32,80.74 R593.2 ; PR206.2 188.88,171.15 189.81,170.23 189.81,168.59 190.31,168.09 v4(191.39,168.09) ; R694.2 164.33,85.84 v2(164.1,86.07) ; v4(174.23,127.86) 174.48,128.1 PC628.1 ; PR602.2 198.43,14.42 v2(198.43,15.07) ; R266.1 137.67,95.85 v2(137.93,96.11) ; R601.1 168.9,77.06 v2(169,76.95) ; v2(187.37,32.05) 185.74,33.67 185.74,34.75 184.47,36.02 184.47,42.59 184.48,42.59 184.48,43.68 179.81,48.34 v2(179.81,51.54) 179.81,58.4 179.13,59.09 179.13,67.67 v2(180.47,69.02)
  BOTTOM w1.016: 142.29,98.94 141.35,99.88 141.35,108.17 139.58,109.93 139.58,110.75 ; 99.39,122.78 98.49,122.78 95.53,119.81
  vias: v2(44.5,17.36) v2(45.09,17.35) v2(95.37,118.52) v2(100.34,123.19) v2(100.33,122.61) v2(136.91,60.86) v2(138.65,111.25) v2(138.64,110.65) v2(142.56,98.16) v2(156.23,93.82) v2(156.5,93.29) v3(45.88,17.42) v3(151.28,93.13) v4(87.92,16.08) v4(87.91,15.42) v4(88.59,16.07) v4(88.58,15.4) v4(89.29,16.07) v4(89.28,15.41) v4(110.1,171.61) v4(110.08,170.98)
+3VALW_EC: length 101.6
  TOP w0.203: U31.9 178,79.76 178.28,79.48 C654.1 ; U31.96 159.74,76.56 159.27,76.08 C653.1 ; U31.33 174.79,92.16 C662.1 ; C658.1 178.72,84.96 U31.22
  TOP w0.508: v2(178.63,74.8) 178.82,74.99 R301.1 178.82,76.87 C655.1 C654.1 ; v2(178.73,92.18) 178.17,92.75 C662.1 ; R590.1 172.26,94.31 172.53,94.57 v2(173.48,94.57) ; v2(157.79,74.05) 158.14,74.4 R304.1 158.14,75.03 C653.1 ; C658.1 178.72,84.04 C657.1 178.72,83.22 178.74,83.21 v2(178.72,83.19)
  IN1 w0.508: v2(165.09,84.3) 164.26,85.14 159.91,85.14 158.92,84.15 v2(157.07,84.15)
  IN2 w0.508: v2(178.73,92.18) 176.34,94.57 v2(173.48,94.57) ; v2(157.79,74.05) 158.56,74.82 159.78,74.82 160.79,75.83 161.96,75.83 162.19,75.59 162.64,75.59 163.13,75.11 166.82,75.11 167.09,74.84 178.59,74.84 v2(178.63,74.8)
  BOTTOM w0.508: v2(165.09,84.3) 164.93,84.46 R600.1 R604.1 ; v2(178.73,92.18) 177.99,91.43 v1(177.99,90.94) 177.99,90.54 179.22,89.3 179.22,86.95 178.72,86.46 v2(178.72,83.19) 178.72,74.89 v2(178.63,74.8) ; v2(157.79,74.05) 157.82,74.08 157.82,81.09 157.07,81.84 v2(157.07,84.15) 157.07,85.03 157.73,85.69 157.73,92.15 157.46,92.42 v2(156.48,92.42)
+3VALWP: length 36
  TOP w0.254: PU401.4 65.75,5.88 65.82,5.81 65.82,5.82 v2(65.83,5.82)
  BOTTOM w0.254: PR414.2 65.58,6.08 v2(65.83,5.82) 66.15,5.5 66.15,2.55 66.48,2.22 76.07,2.22 78.34,4.49 78.34,9.8 79.1,10.57 v4(90.19,10.57)
  vias: v3(90.72,9.47)
+3VGS: length 157.9
  TOP w0.381: U9.1 148.05,71.52
  TOP w0.508: PR833.1 192.41,136.6 192.41,134.15 192,133.74 PR830.1 191.54,133.73 PR816.1 190.65,132.56 v2(190.29,132.2) ; RV26.1 v2(152.38,129.44) ; 148.05,71.52 147.18,70.65 143.71,70.65 142.67,71.69 142.67,75.78 144.9,78.01 144.9,81.47 144.38,81.99 v2(144.38,86.23)
  IN1 w0.508: v2(152.38,129.44) 152.23,129.44 150.54,127.75 150.54,123.43 v2(150.29,123.17) 149.16,123.17 147.51,124.83 v2(133.14,124.83)
  IN2 w0.508: v2(152.38,129.44) 152.38,129.49 ; 152.38,129.49 152.38,131.1 151.56,131.92 151.56,135.9 v2(150.46,136.99) ; 152.38,129.49 153.33,128.54 153.33,127.31 155.04,125.61 157.4,125.61 161.04,121.97 171.11,121.97 172,122.86 172,124.44 173.02,125.46 173.02,128.32 173.86,129.16 175.78,129.16 179.49,132.88 v2(180.79,132.88) 181.05,132.88 181.41,133.24 183.3,133.24 183.7,132.84 185.3,132.84 185.87,133.41 185.87,134.08 187.29,135.51 189.15,135.51 190.29,134.36 v2(190.29,132.2) ; v2(150.29,123.17) 150.06,122.95 150.06,118.62 149.32,117.88 v2(149.32,117.62)
  BOTTOM w0.508: v2(190.29,132.2) 190.82,132.73 PR831.1 ; v2(149.91,117.42) 149.91,109.85 148.32,108.26 148.32,102.6 145.42,99.7 145.42,96.89 144.38,95.84 144.38,94.27 145.31,93.34 145.31,89.96 144.38,89.04 v2(144.38,86.23)
  vias: v3(150.18,136.46)
+3VLP: length 470.8
  TOP w0.203: U31.111 167.99,72.87
  TOP w0.254: U31.125 173.59,75.84 173.11,76.32 v2(173.11,76.46)
  TOP w0.508: R301.2 180.22,71.01 v2(180.75,70.48) 181.06,70.48 PR220.2 ; R643.2 101.53,112.58 108.64,105.47 108.64,102.91 109.68,101.86 109.68,100.47 109.04,99.82 109.04,92.47 109.29,92.21 109.29,80.42 108.69,79.82 108.69,68.63 111.85,65.47 117.11,65.47 119.86,62.72 127.82,62.72 128.15,63.05 130.12,63.05 132.54,65.48 v2(135.44,65.48) ; v2(158.83,61.14) 158.1,60.4 148.62,60.4 148.27,60.04 148.27,56.8 147.8,56.33 RA1.1 ; v2(195.59,29.96) 195.57,29.94 PR101.2 ; v2(156.59,66.44) 155.3,67.73 155.3,69.49 156.2,70.39 156.2,71.69 R653.1 ; v2(96.57,26.53) 92.18,22.15 v3(92.18,18.16) v2(92.18,5.64)
  IN1 w0.508: v2(187.15,89) 187.54,89.38 187.54,112.09 192.23,116.79 192.23,121.5 191.42,122.31 191.42,128.28 193.73,130.59 193.73,135.8 194.3,136.38 194.3,138.79 194.71,139.2 194.71,150.42 195.38,151.09 195.38,153.4 195.84,153.86 195.84,161.41 193.95,163.31 193.95,165.1 192.69,166.36 192.69,167.76 191.62,168.83 v2(190.47,168.83) ; v2(173.11,76.46) 173.11,75.49 172.57,74.95 168.22,74.95 167.44,74.18 167.44,70.56 168.19,69.81 v2(168.19,68.96)
  IN2 w0.508: v2(135.44,65.48) 135.44,66.01 137.95,68.53 148.14,68.53 151.19,65.48 155.62,65.48 v2(156.59,66.44) 158.9,68.76 161.37,68.76 161.96,68.17 167.41,68.17 v2(168.19,68.96) 175.71,68.96 177.23,70.48 v2(180.75,70.48) ; v2(92.18,5.64) 88.01,5.64 86.74,6.9 81.13,6.9 77.7,3.46 67.25,3.46 v4(65.4,5.32)
  BOTTOM w0.508: v2(96.57,26.53) 96.6,26.57 96.6,33.88 97.4,34.68 98.98,34.68 100.86,36.56 100.86,44.14 101.43,44.71 101.43,55.96 103.89,58.43 128.11,58.43 129.89,60.2 129.89,60.56 134.81,65.48 v2(135.44,65.48) ; v2(190.47,168.83) 190.47,170.47 188.87,172.07 PR209.2 ; v2(158.83,61.14) 156.59,63.38 v2(156.59,66.44) ; PC414.1 v4(65.4,5.32) ; v2(195.59,29.96) 185.11,40.43 185.11,42.33 185.11,43.94 180.45,48.61 180.45,58.9 179.83,59.52 179.83,66.96 181.26,68.4 181.26,69.97 v2(180.75,70.48) 180.75,73.58 183.24,76.07 184.7,76.07 187.42,78.78 187.42,88.73 v2(187.15,89)
+3VS: length 417.3
  TOP w0.203: 154.22,53.01 154.55,53.01 155.45,52.11 UA1.18 ; 160.24,47.1 160.01,47.1 159.45,47.67 UA1.2
  TOP w0.254: U4.AK32 123.18,81.38 v2(122.88,81.68) 123.18,81.98 U4.AK30 ; v2(131.26,84.04) 131.26,84.32 131.06,84.51 U4.L24 ; PR215.2 178.09,60.44 v2(173.4,60.44) ; U4.M31 130.17,81.58 130.05,81.71 129.53,81.71 U4.R32 129.12,81.39 v2(128.78,81.73) 129.12,82.07 U4.R30 ; JLVDS1.24 v2(94.15,142.85) ; v2(94.74,143.54) 94.74,144.26 JLVDS1.21
  TOP w0.356: v2(117.67,100.42) 117.34,100.76 RP15.5 ; v2(114.64,103.38) 114.74,103.28 RP15.10
  TOP w0.508: v2(118.48,99.03) 118.17,98.73 R271.1 ; v2(44.04,94.4) 44.01,94.4 42.97,93.36 39.99,93.36 31.4,84.77 31.4,71.1 27.86,67.56 v2(24.12,67.56) ; R268.1 v2(121.41,98.88) R138.2 ; R11.1 44.72,108.15 44.09,107.52 v2(44.09,103.98) ; PR604.1 198.66,14.4 199.17,14.91 v2(199.99,14.91) ; v2(163.35,51.62) 163.18,51.8 RA15.1 ; 96.2,60.46 96.19,60.46 94.56,60.46 93.58,59.48 93.58,48.31 93.57,48.3 ; v2(145.38,74.93) 147.52,74.93 148.37,75.78 150.77,75.78 151.12,75.42 R335.1 ; Q95.2 20.78,55.6 v2(22.85,57.67) 24.48,59.29 Q93.2 25.9,60.93 R485.2 ; v2(161.79,45.58) CA15.1 161.53,46.4 161.07,46.86 CA10.1 160.48,46.86 160.24,47.1 ; v2(112.07,96.57) 112.07,97.13 112.61,97.66 R278.1 ; R281.2 120.16,102.73 R270.1 v2(119.49,102.73) ; v2(14.56,127.53) 15.98,127.53 16.51,128.05 18.28,128.05 v2(18.59,127.75) ; v4(171.21,132.68) 171.9,132.68 PR618.1 ; R184.2 v2(123.41,100.84) 123.41,100.85 R176.2 123.42,101.68 R182.2 ; 81.07,20.38 79.98,21.46 77.57,21.46 75.45,19.34 R645.1 ; R126.1 132.59,70.8 v2(132.52,70.73) ; v2(10.33,113.59) 10.32,113.6 C537.1 ; 17.32,74.64 20.14,74.64 v2(21.66,73.11) ; v2(177.73,86.54) 178.16,86.54 178.35,86.34 179.24,86.34 179.73,86.83 R605.1 ; v2(131.45,70.73) 131.5,70.78 R125.1 ; R280.2 v2(120.03,98.9) ; 85.27,21.11 89.6,21.11 94.22,25.72 94.22,35.61 95.87,37.26 R93.1 93.58,45.99 93.58,47.48 93.57,47.5 ; RA5.2 v2(160.26,42.34)
  TOP w1.524: 196.95,139.51 196.95,138.98 195.47,137.5 195.47,133.91 192,130.44 189.8,130.44
  IN1 w0.508: v2(10.33,113.59) 10.33,114.29 9.44,115.18 9.44,123 13.96,127.53 v2(14.56,127.53) ; v2(177.73,86.54) 177.61,86.41 v2(170.64,86.41) ; v2(24.12,67.56) 20.1,67.56 v2(18.71,68.95) ; v2(202.9,22.75) 200.41,20.26 200.41,15.32 v2(199.99,14.91)
  IN1 w1.524: 201.51,165.78 201.51,163.66 204.36,160.8 204.36,160.18 204.29,160.11 204.29,148.27 202.51,146.49 202.51,143.4 200.72,141.61 198.51,141.61
  IN2 w0.508: v2(141.43,88.93) 145.13,88.93 v2(146.18,89.99) ; v2(10.33,113.59) 10.33,113.36 9.73,112.76 8.5,112.76 7.78,112.04 7.78,110.95 9.6,109.14 9.6,105.52 12.43,102.69 12.43,97.05 22.57,86.9 24.72,86.9 26.8,84.83 26.8,75.35 25.32,73.87 22.42,73.87 v2(21.66,73.11) 20.67,72.12 20.67,71.03 18.71,69.07 v2(18.71,68.95) 18.71,68.55 22.85,64.41 v2(22.85,57.67) ; v2(122.88,81.68) 123.96,82.76 125.06,82.76 125.4,83.11 125.4,87.5 124.83,88.08 v2(124.83,88.2)
  IN2 w1.016: 202.9,24.34 201.33,25.92 201.33,28.45 189.26,40.51 189.26,54.82 187.81,56.27 181.97,56.27
  BOTTOM w0.356: JDIMM2.199 96.32,44.58 96.32,46.28 v2(96.11,46.48) ; JDIMM1.199 96.32,60.34 96.81,60.83 97.74,60.83 v2(98.04,60.53) ; RP13.5 141.02,88.52 v2(141.43,88.93) ; v2(138.49,85.7) 138.42,85.76 RP13.10
  BOTTOM w0.381: Q63.5 Q63.2 18.71,68.95 v2(18.71,68.95) ; U10.7 10.78,114.04 10.33,113.6 v2(10.33,113.59)
  BOTTOM w0.457: U6.5 120.05,98.83 120.03,98.85 v2(120.03,98.9)
  BOTTOM w0.508: v2(122.88,81.68) 121.45,81.68 C173.1 ; R223.2 119.77,89.39 120.21,88.95 v2(120.21,88.55) ; v2(124.99,94.89) 125.09,94.79 R195.2 ; v2(132.65,75.02) 133.16,75.02 R277.2 ; PR916.2 24.4,127.19 24.08,127.51 20.48,127.51 19.86,128.13 18.97,128.13 v2(18.59,127.75) ; v2(44.04,94.4) 43.85,94.59 43.85,103.74 v2(44.09,103.98)
  vias: v2(88.72,142.31) v2(88.72,141.72) v2(89.33,142.3) v2(89.31,141.72) v2(89.42,133.41) v2(89.45,132.82) v2(90.01,133.39) v2(90.04,132.81) v2(119.65,95.88) v2(119.88,95.31) v2(125.2,89.13) v2(136.99,63.33) v2(140.08,72.83) v2(140.71,72.82) v2(142.32,77.52) v2(142.37,78.1) v2(142.62,77.01) v2(142.94,77.54) v2(146.03,98.12) v2(146.62,98.12) v2(149.27,119.42) v2(149.27,118.84) v2(153.87,55.39) v2(154.53,55.39) v2(155.47,124.48) v2(155.66,123.83) v2(172.8,57.34) v2(173.4,57.33) v2(181.08,56.69) v2(181.09,56.05) v2(188.27,130.49) v2(188.74,130.86) v2(189.08,131.37) v2(197.63,142.02) v2(197.61,141.39) v2(197.61,140.77) v2(201.98,168.07) v2(201.98,167.43) v2(201.96,166.85) v2(202.9,23.37) v3(83.15,21.07) v4(81.02,17.35) v4(81,16.69) v4(81.67,17.35) v4(81.65,16.69) v4(82.35,16.7) v4(82.36,17.36) v4(83.05,17.36) v4(83.03,16.7) v4(83.72,17.38) v4(83.7,16.71) v4(84.35,16.71) v4(84.36,17.37)
+3VS_CMOS: length 8.2
  TOP w0.254: v2(93.95,142.13) 93.52,142.08 JLVDS1.26
  IN2 w0.508: v2(100.14,144.76) 98.18,142.8 v2(97.16,142.8)
  BOTTOM w0.508: v2(100.14,144.76) 100.14,144.76 100.14,143.71 100.14,143.71 Q83.1
  vias: v1(95.28,142.15)
+3VS_PS: length 2.8
  TOP w0.508: v2(83.99,133.96) 83.51,134.44 83.51,135.61 83.93,136.03 RT4.2
  vias: v1(88.7,129.8)
+3VS_TS:
  vias: v3(204.21,142.1)
+3VS_WLAN: length 25.7
  IN1 w1.524: 206.94,162.94 206.94,154.17 ; 207.11,141.51 207.11,151.59
  BOTTOM w1.524: 201.28,160.26 203.25,160.26 205.28,162.29 205.28,164.26
  vias: v2(205.77,153.51) v2(205.78,152.9) v2(205.8,152.31) v2(206.65,140.01) v2(206.66,139.4) v2(206.8,164.7) v2(207.28,139.38) v2(207.41,164.72) v2(208.01,164.7) v3(207.64,165.68)
+5V_DISPLAY: length 62.2
  TOP w1.016: 28.43,84.58 28.43,77.07 26.19,74.84 25.45,74.84
  IN2 w1.016: 15.39,74.44 21.7,74.44 22.08,74.83 23.05,74.83 ; 12.8,120.44 12.8,111.8 12.09,111.08 11.48,111.08 10.7,110.31 10.7,106.09 13.42,103.38 13.42,97.43 22.93,87.92 25.29,87.92 26.59,86.62
  vias: v1(27.6,85.07) v2(12.15,121.46) v2(12.76,121.47) v2(13.62,74.44) v2(14.26,74.44) v2(23.9,74.86) v2(24.51,74.86) v2(26.86,86.04) v2(27.5,86)
+5V_HDD:
  vias: v1(165.84,120.79) v2(164.57,119.62) v2(164.86,119.11) v2(165.21,119.62)
+5V_ODD: length 0.6
  BOTTOM w0.102: v2(185.44,55.32) v1(185.44,55.89)
  vias: v2(184.84,55.32) v2(184.84,54.73) v2(185.44,54.73) v2(194.61,57.41) v2(194.61,56.78) v2(195.2,57.41) v2(195.2,56.78)
+5VALW: length 198
  TOP w0.508: R778.1 152.77,89.09 154.14,87.71 154.14,85.5 156.21,83.43 156.21,82.47 R594.2 156.35,81.36 155.87,80.88 155.87,80.19 156.13,79.93 156.13,77.37 155.43,76.67 155.34,76.67 ; v2(151.65,119.44) 152.68,120.47 RV37.1 ; 155.34,76.67 v3(155.34,75.41) 155.34,70.79 154.62,70.06 v2(154.62,67.41) ; 155.34,76.67 153.66,76.67 R780.1 ; v4(122.93,8.98) 123.65,9.7 v3(127.71,9.7) 147.38,9.7 148.37,10.69 R623.1 150.56,10.69 R765.1
  IN1 w1.016: 31.63,3.42 29.86,5.18 27.65,5.18 25.29,7.55 25.29,16.4 23.34,18.35 20.16,18.35 ; 105.88,34.63 106.67,33.83 106.67,21.74 108.71,19.71 ; 19.81,43.41 20.43,42.78 20.43,27.34 20.28,27.18
  IN1 w1.524: 182.03,17.92 182.03,36.17 180.55,37.65 180.55,41.16
  IN2 w0.508: v2(171.89,69.71) 167.88,69.71 167.04,68.87 163.27,68.87 162.45,69.68 156.89,69.68 v2(154.62,67.41) ; v2(176.21,116.19) 173.87,116.19 170.28,119.78 167.6,119.78 165.53,117.71 152.28,117.71 v2(151.65,117.08)
  BOTTOM w0.508: v2(182.43,50.69) 182.43,52.42 182.99,52.98 186.78,52.98 187.62,52.14 R568.1 ; v2(151.65,119.44) v2(151.65,117.08)
  vias: v2(18.09,43.65) v2(18.59,18.32) v2(18.78,43.63) v2(18.8,27.53) v2(18.79,26.94) v2(19.13,17.87) v2(19.39,27.52) v2(19.38,26.93) v2(31.48,2.54) v2(32.07,2.54) v2(104.55,34.62) v2(109.57,19.34) v2(110.17,19.34) v2(178.35,40.82) v2(178.77,41.27) v2(179.17,40.8) v2(179.73,17.8) v2(180.15,18.25) v2(180.55,17.78) v2(182.38,50.05) v2(192.4,113.64) v2(192.85,114.11) v2(192.88,112.1) v2(193.35,112.54) v3(20.33,27.07) v4(105,35.04) v4(122.27,8.97) v4(122.27,8.3) v4(122.28,7.65) v4(122.28,6.99) v4(122.28,6.32) v4(122.29,5.67) v4(122.93,8.32) v4(122.94,7.66) v4(122.94,7) v4(122.94,6.33) v4(122.95,5.68)
+5VALWP: length 27.4
  TOP w0.254: PR413.2 102.66,10.82 v2(102.78,10.93)
  IN2 w0.254: v4(119.33,11.83) 119.33,14.16 118.55,14.95 105.48,14.95 103.6,13.07 103.6,11.76 v2(102.78,10.93) 101.2,9.36 v4(101.2,7.48)
  BOTTOM w0.254: PU402.4 v4(101.2,7.48)
  vias: v3(120.23,7.08)
+5VS: length 534.3
  TOP w0.203: UA1.28 152.98,48.07 152.66,47.75 ; 156.02,53.1 156.16,52.96 156.16,52.16 156.25,52.08 UA1.16 ; UA1.13 157.45,52.08 157.86,52.49 157.86,52.89 158.26,53.3 158.26,53.34
  TOP w0.254: v2(185.73,145.08) 186.01,145.08 186.62,145.69 188.95,145.69 189.12,145.51 191.9,145.51 192.83,144.59 PR863.2
  TOP w0.508: v2(156.57,80.52) 157.25,80.52 R603.2 R598.2 ; v2(184.7,131.2) 184.68,131.18 183.39,131.18 DA3.5 ; C696.1 v2(182.65,91.78) 182.99,92.12 185.9,92.12 187.5,93.72 JTP1.6 ; PR844.2 185.73,144.23 v2(185.73,145.08) ; R303.1 v2(151.45,11.5)
  TOP w1.016: 16.87,126.98 15.41,125.52 15.41,122.1
  TOP w1.524: 29.26,73.3 29.98,74.03 29.98,85.44 27.1,88.32 26.04,88.32 ; 13.25,113.78 13.25,111.87 12.3,110.92 11.21,110.92 10.21,109.92 10.21,106.72 12.17,104.76
  IN1 w0.508: v2(149.88,45.34) 152.77,45.34 153.89,46.46 153.89,53.53 155.33,54.97 v2(155.33,55.41) 155.33,59.57 160.1,64.34 160.1,77.67 159.46,78.32 158.05,78.32 157.17,79.19 157.17,79.92 v2(156.57,80.52) ; v2(16.11,116.06) 16.49,116.44 19.67,116.44 20.05,116.06 v2(22.68,116.06) 23.35,116.73 23.35,117.41 24.24,118.3 26.04,118.3 26.74,119 26.74,120 27.24,120.49 v4(27.55,120.49) ; v4(182.68,138.9) 182.56,138.9 182.15,138.48 182.15,135.58 184.26,133.46 184.26,131.64 v2(184.7,131.2)
  IN1 w1.016: 97.29,164.22 97.29,161.99 96.3,161 96.3,158.95 95.59,158.24 95.59,154.43 94.77,153.62 94.77,147.9 96.59,146.09 96.59,143.58 96.01,143 96.01,129.23 95.33,128.56 95.33,122.1 96.53,120.9 96.53,113.04 99.42,110.14 108.5,110.14 109.63,111.27 124.87,111.27 126.02,112.42 130.08,112.42 131.25,113.6 137.08,113.6 138.18,112.49 157.75,112.49 158.43,113.17 166.71,113.17 168.63,115.08 168.63,116.18 ; 14.27,68.45 14.28,68.46 14.28,72.98 15.36,74.06 22.37,74.06 22.77,73.67
  IN1 w1.524: 15.22,104.25 15.22,95.02 20.44,89.8 24.61,89.8
  IN1 w2.032: 130.1,5.63 122.03,13.7 122.03,13.95 117.96,18.02 112.17,18.02 111.07,16.91 101.99,16.91 97.57,12.49 81.78,12.49 77.3,16.98 68.16,16.98 63.8,12.62 63.8,12.49 38.95,12.49 ; 27.41,12.18 27.41,17.19 26.02,18.59 26.02,22.5 23.1,25.41 23.1,29.52 25.89,32.3 25.89,68.45
  IN2 w0.508: v2(182.84,126.24) 183.71,127.11 183.71,130.21 v2(184.7,131.2) ; v2(185.73,145.08) 185.94,145.3 186.59,145.3 187.42,144.47 187.42,142.43 187.71,142.14 187.71,141.44 185.19,138.91 v4(183.34,138.91)
  IN2 w1.016: 180.9,48.55 180.9,53.58 179.07,55.4 163.68,55.4 162.08,53.81 159.78,53.81 159.46,54.13 158.08,54.13 ; 183.46,48.65 183.46,52.09 184.51,53.15 186.43,53.15
  IN2 w2.54: 170.77,116.91 173.57,114.12 182.35,114.12
  BOTTOM w0.508: v2(22.68,116.06) 23.19,116.58 PR932.1 ; v2(182.84,126.24) 182.84,123.45 186.27,120.02 PR107.2 186.27,118.74 185.9,118.37 v2(185.33,118.37)
  vias: v2(13.16,68.43) v2(13.19,67.84) v2(14.14,105.46) v2(14.14,104.82) v2(14.14,104.19) v2(16.11,115.42) v2(16.11,114.79) v2(18.21,127.14) v2(18.2,126.54) v2(23.35,73.14) v2(23.96,73.12) v2(24.57,73.1) v2(25.17,73.09) v2(25.62,89.49) v2(26.21,89.49) v2(26.8,89.49) v2(100.44,165.02) v2(101.07,165.02) v2(155.98,55.42) v2(158.11,55.29) v2(158.7,55.29) v2(168.19,118.67) v2(168.19,118.03) v2(168.19,117.4) v2(168.78,118.36) v2(168.8,117.69) v2(182.42,49.12) v2(182.41,48.51) v2(185.1,116.56) v2(185.24,115.99) v2(185.24,115.4) v2(185.24,114.82) v2(185.24,114.23) v2(186.22,54.07) v2(186.6,54.57) v2(186.91,54.02) v2(187.23,54.56) v2(187.57,54) v2(187.88,54.56) v2(192.16,53.79) v2(192.44,53.22) v2(192.44,52.63) v2(192.46,54.33) v3(28.33,72.39) v4(28.21,120.49) v4(131.79,6.07) v4(131.8,5.4) v4(132.45,6.07) v4(132.46,5.4) v4(133.1,6.08) v4(133.09,5.41) v4(133.75,6.07) v4(133.74,5.4) v4(134.39,6.08) v4(134.41,5.41) v4(135.03,6.08) v4(135.05,5.41)
+AVDD: length 1.6
  TOP w0.102: v1(139.89,129.74) 140,129.74 v2(140.38,129.36)
  BOTTOM w0.254: v2(140.38,129.36) 140.17,129.36 UV1.AD34
+V18R: length 3.5
  TOP w0.254: C667.1 174.67,72.2 v1(173.49,73.38) 173.19,73.68 U31.124
+VCCADAC: length 2.1
  TOP w0.254: U4.P45 129.65,74.9 129.55,74.8 v2(129.54,74.8)
  BOTTOM w0.102: C133.1 129.99,72.6 v1(129.14,72.6)
+VCCIO_OUT: length 119
  TOP w0.508: R8.1 v2(44.58,111.69) ; C53.1 88.63,99.42 R78.1 88.68,99.77 88.68,101.24 ; R81.1 54.53,116.81 R87.2 54.52,116.55 53.88,115.91 53.88,115.08 v2(53.51,114.71) ; RC1.2 88.28,101.64 88.68,101.24 ; 88.68,101.24 v2(88.68,101.27) ; v2(21.26,128.25) v2(21.26,126.63) 20.62,125.99 20.12,125.99 19.44,125.31 19.44,124.41 19.8,124.04 PC909.2 ; v2(88.39,105.22) 88.84,105.67 R26.1
  IN1 w0.508: v2(88.68,101.27) 88.39,101.56 v2(88.39,105.22) 88.36,105.25 88.36,113.01 83.87,117.51 76.66,117.51 74.89,119.28 67.76,119.28 64.39,115.91 54.13,115.91 53.51,115.29 v2(53.51,114.71)
  IN2 w0.508: 45.66,116.34 45.89,116.11 51.22,116.11 52.62,114.71 v2(53.51,114.71) ; 45.66,116.34 44.47,115.15 44.47,111.8 v2(44.58,111.69) ; 45.66,116.34 v2(45.66,125.6)
  BOTTOM w0.305: JCPU1.AN35 53.51,114.71 v2(53.51,114.71)
  BOTTOM w0.508: v2(45.66,125.6) 45.66,126.18 44.18,127.67 31.15,127.67 30.5,128.32 v1(27.73,128.32) 21.32,128.32 v2(21.26,128.25) ; v2(21.26,126.63) 21.5,126.87 PR906.2 23.48,126.87 PR910.2
+VCCST: length 0.8
  TOP w0.089: v1(56.08,110.27) 56.04,110.23 v2(56.04,109.48)
+VDD1DI: length 8.9
  TOP w0.102: v1(144.61,122.95) 144.61,124.85 144.09,125.37 CV22.1
  IN2 w0.508: v2(141.87,126.26) 141.87,127.4 140.69,128.58 140.28,128.58 139.63,129.23 139.63,129.96 v2(139.24,130.35)
  BOTTOM w0.254: v2(139.24,130.35) 138.92,130.67 UV1.AC33
+VDD_MEM15_REFDA: length 5.7
  TOP w0.102: v1(127.21,142.58) 127.58,142.95 v2(127.58,143.03)
  TOP w0.508: RV49.2 128.35,143.69 RV55.1 128.45,143.57 CV98.1 128.03,142.66 127.66,143.03 v2(127.58,143.03)
  BOTTOM w0.254: v2(127.58,143.03) 127.69,143.13 128.36,143.13 128.82,142.67 UV1.L18
+VDD_MEM15_REFDB: length 21.8
  TOP w0.102: v1(153.22,148.43) 153.16,148.37 v2(152.58,148.37)
  IN1 w0.508: v2(152.58,148.37) 152.58,148.51 152.18,148.92 151.29,148.92 150.6,148.23 150.09,148.23 149.49,147.63 146.71,147.63 146.35,147.27 143.07,147.27 142.58,147.76 136.86,147.76 v2(136.25,147.15)
  BOTTOM w0.381: v2(136.25,147.15) 135.85,147.55 UV1.Y12
  BOTTOM w0.508: v2(152.58,148.37) 152.67,148.46 153.25,148.46 CV101.1 RV58.1 155.01,148.52 RV51.2
+VDD_MEM15_REFSA: length 5.6
  TOP w0.102: v1(126.75,141.34) 127.87,141.34 128.33,141.79 CV99.1
  TOP w0.254: RV56.1 129.79,141.66 v2(129.39,142.05) 129.14,141.79 CV99.1
  TOP w0.508: RV50.2 130.31,140.78 RV56.1
  BOTTOM w0.254: UV1.L20 129.02,141.67 v2(129.39,142.05)
+VDD_MEM15_REFSB: length 21.2
  TOP w0.102: v1(152.38,147.38) 152.48,147.28 v2(152.48,146.74)
  IN1 w0.508: v2(152.48,146.74) 152.48,145.82 151.87,145.21 149.63,145.21 149.27,145.56 141.73,145.56 141,146.29 140.24,146.29 139.4,147.13 v2(137.47,147.13)
  BOTTOM w0.457: UV1.AA12 136.99,147.67 137.39,147.27 137.39,147.21 v2(137.47,147.13)
  BOTTOM w0.508: RV52.2 155.09,146.73 RV59.1 153.31,146.73 CV102.1 v2(152.48,146.74)
+VDDC_CT: length 2.2
  TOP w0.102: CV90.1 140.71,135.13 140.16,134.58 v1(138.92,134.58)
  vias: v2(141.35,136.18)
+VDDR3: length 0.6
  TOP w0.102: v1(142.67,136.71) 142.67,136.9 v2(142.35,137.22)
  vias: v2(142.32,138.2)
+VDDR4:
  vias: v1(140.85,147.08) v2(140.33,147.1) v2(141.37,147.09)
GND: length 2701.6
  TOP w0.089: 135.85,72.85 v2(135.85,72.89)
  TOP w0.102: v2(129.22,129.46) v3(129.22,128.83) ; v3(124.81,129.74) 125.24,130.17 v2(125.24,130.25) ; U4.BA1 118.4,94.13 118.62,94.13 119.09,93.66 U4.AW2 ; 182.24,170.95 v3(182.94,170.95)
  TOP w0.203: U31.24 177.27,85.76 177.48,85.54 v2(177.68,85.54) ; v2(174.14,92.73) 174.14,91.83 173.99,91.68 U31.35 ; v2(177.73,80.24) 177.41,80.56 U31.11 ; U31.94 159.26,77.36 v2(158.95,77.67) ; v2(32.35,8.36) 32.74,8.76 PU501.3 ; U31.113 168.79,73.92 v2(168.56,73.7) ; UL1.27 28.8,26.46 28.59,26.67 28.59,27.23 v2(28.35,27.46) ; U4.AV6 120.04,92.41 120.47,92.41 121.12,93.06 U4.AR2 ; U4.AG2 124.37,93.09 123.8,92.52 123.8,92.26 U4.AJ6
  TOP w0.254: v2(118.42,88.61) 118.42,88.25 U4.AY15 ; U4.A4 U4.A5 135.51,92.32 v2(135.8,92.61) ; v2(136.34,89.69) 134.84,89.69 U4.B11 ; 129.47,82.52 129.78,82.83 U4.P28 ; 129.47,82.52 v2(129.43,82.52) ; 129.47,82.52 129.47,82.43 U4.P30 ; v2(133.51,77.19) 133.69,77.19 U4.D42 ; U4.P24 U4.P26 129.78,83.66 129.46,83.33 v2(129.43,83.33) ; v2(132.94,171.98) 132.57,171.6 UV9.P9 ; U4.AB38 126.52,78.85 v2(126.75,78.85) 126.9,78.85 U4.Y36 ; v2(92.71,139.34) 92.24,139.8 92.24,140.53 JLVDS1.30 ; U4.AT15 120.17,87.82 v2(120.17,87.55) 120.17,87.31 U4.AT17 ; v2(120.17,86.52) 120.17,86.34 U4.AT20 ; UV9.B9 122.97,171.6 v2(122.58,171.99) 122.17,171.58 UV9.A9 ; v2(131.77,82.05) 131.77,82.37 U4.K29 ; UV9.G8 126.95,170.77 v2(126.54,171.17) ; UV9.J2 128.57,165.9 v2(128.23,165.56) ; UV9.D8 124.57,170.77 v2(124.96,171.17) 125.36,170.77 UV9.E8 ; U4.BD11 117.87,89.69 v2(118.07,89.49) ; U4.BD7 117.78,91.32 U4.AY7 118.29,91.72 v2(118.64,92.07) ; U4.AD32 125.82,81.35 v2(125.46,81.71) 125.82,82.08 U4.AD30 ; UV9.T9 134.26,171.66 134.26,172.21 133.93,172.53 v2(133.81,172.53) ; U4.AJ6 124.23,91.7 v2(124.23,91.36) 124.36,91.36 U4.AF8 ; v2(126.57,164.77) 126.58,164.77 126.97,165.16 UV9.G1 ; U4.Y34 127.73,80.87 v2(128.07,80.87) 128.25,80.69 128.25,80.42 U4.U34 ; v2(136.11,87.97) 136.11,87.97 135.86,87.97 135.76,88.07 U4.B15 ; UV12.P9 144.79,164.85 144.79,164.72 144.79,164.72 144.79,164.72 v2(144.77,164.7) ; v2(126.79,91.96) 126.77,91.99 126.77,92.75 U4.AA4 127.32,92.79 127.62,93.09 U4.W2 ; v2(105.83,134.83) 106.41,134.83 UV5.M9 ; UV5.F9 v2(106.05,130.42) 106.43,130.8 UV5.G9 ; v2(106.83,128.05) 107.22,128.45 UV5.D8 ; U4.D4 133.77,92.81 v2(133.47,93.1) 133.47,93.23 133.1,93.6 U4.G2 ; UV7.E2 107.18,155.15 v2(106.79,155.55) ; v2(119.53,82.11) 121.31,82.11 121.6,81.82 U4.AP31 122.24,81.58 U4.AM32 ; v2(131.3,164.71) 130.97,165.04 UV9.M1 ; U4.K10 131.6,90.4 v2(131.74,90.27) 131.99,90.01 U4.H10 ; U4.U6 128.26,92.2 128.47,92.42 128.71,92.42 v2(128.82,92.53) 129.25,92.95 U4.R2 ; U4.B31 134,81.56 v2(133.87,81.7) ; UV12.A9 155.51,164.16 v2(155.53,164.13) ; v2(146.92,164.39) 146.92,164.7 146.7,164.92 UV12.M9 ; U4.BE5 U4.BE3 115.8,93.01 115.48,93.33 v2(115.48,93.64) ; v2(118.78,89.48) 118.78,89.85 U4.AY10 ; UV12.E1 152.3,171.56 v2(152.7,171.16) ; UV5.E8 107.23,129.25 v2(107.63,128.85) ; U4.BA40 118.17,78.08 v2(117.94,78.31) U4.BD39 ; U4.B35 133.88,79.94 v2(133.69,80.13) 133.69,80.29 U4.F33 ; v2(98.9,148.92) 98.6,149.22 98.13,149.22 JLVDS1.9 ; UV9.J8 128.56,170.77 v2(128.16,171.17) ; U4.BD19 118.18,86.44 v2(118.29,86.55) 118.29,86.43 U4.AY20 ; v2(124.25,76.87) 124.37,76.75 U4.AG44 ; v2(130.69,79.58) 130.45,79.58 U4.N35 ; v2(130.59,91.91) 130.3,92.19 U4.N6 ; U4.R8 128.96,90.72 v2(128.75,90.72) 128.58,90.72 U4.U10 ; U4.BD44 117.29,75.58 U4.BD45 ; U4.V43 127.62,76 U4.W44 ; v2(113.33,149.72) 113.13,149.52 UV7.M9 ; UV9.F9 126.17,171.62 v2(126.53,171.98) 126.94,171.57 UV9.G9 ; U4.L44 130.87,76.85 v2(130.75,76.97) ; UT2.4 v2(82.22,130.48) ; U4.G44 132.9,76.38 U4.F43 132.84,76.54 132.71,76.54 v2(132.42,76.83) ; UV7.B3 108.36,157.52 v2(108.54,157.71) ; v2(113.22,130.42) 112.83,130.81 UV5.G1 ; U4.AD8 125.68,91 125.31,91.36 v2(125.21,91.36) ; UV5.P9 106.43,136.45 v2(106.83,136.05) ; U4.B39 134.84,77.65 v2(134.71,77.52) ; v2(124.24,78.9) 124.44,78.9 U4.AF38 ; UV12.B1 154.71,171.57 v2(155.11,171.96) ; v2(152.7,171.16) 152.31,170.77 UV12.E2 ; v2(152.7,171.16) 153.1,171.56 UV12.D1 ; U4.F29 133.37,82.56 v2(132.9,83.03) ; UV9.D1 124.57,165.14 v2(124.94,164.76) 125.35,165.17 UV9.E1 ; U4.BE2 116.76,93.53 U4.BD2 ; U4.BC22 117.77,85.22 v2(118.07,84.92) ; U4.BD31 v2(117.84,81.56) 118.62,82.34 U4.AY29 ; U4.B1 U4.D1 U4.E1 ; U4.H40 132.29,77.44 v2(132.58,77.73) 132.78,77.92 U4.G38 ; v2(106.79,155.55) 106.38,155.14 UV7.E1 ; v2(106.79,155.55) 106.41,155.92 UV7.D1 ; UV7.P1 105.97,147.51 v2(105.96,147.51) ; U4.AD18 125.82,86.91 v2(126.14,86.59) 126.48,86.25 U4.AA20 ; v2(144.69,171.99) 144.69,171.98 UV12.P1 ; U4.AN36 121.49,79.23 121.31,79.05 v2(121.31,78.31) ; UV5.D1 112.85,128.45 v2(113.23,128.83) 112.83,129.24 UV5.E1 ; v2(130.66,90.72) 130.52,90.72 U4.N10 ; U4.BD35 118.07,79.94 v2(118.13,80) 118.24,80 U4.AY36 ; U4.H7 132.47,91.6 v2(132.63,91.44) 132.74,91.33 132.74,91.03 U4.G8 ; U4.AJ38 123.48,78.89 v2(123.24,78.89) 123.02,78.89 U4.AL38 ; U4.H22 132.18,85.26 131.99,85.46 v2(131.99,85.58) 131.58,85.98 U4.K20 ; v2(106.76,149.12) 106.76,149.15 UV7.M1 ; U4.Y8 127.02,90.74 v2(126.79,90.74) 126.53,91 U4.AB8 ; UV7.G1 106.38,153.55 v2(105.99,153.95) ; U4.F15 133.58,88.26 v2(133.58,88.54) ; v2(126.78,80.8) 126.4,80.42 U4.AB34 ; U4.L2 130.87,93.02 v2(131.11,92.79) ; UV9.B3 122.97,167.09 v2(122.77,167.29) ; v2(149.48,171.17) 149.1,170.79 UV12.J2 ; U4.AC2 126,93.09 v2(125.66,92.76) 125.69,92.73 U4.AD6 ; UV5.J2 v2(112.43,132.04) ; UV5.B1 112.86,126.85 v2(113.25,126.46) ; UV12.G1 150.74,171.57 v2(151.13,171.96) ; v2(123.12,92.61) 122.74,92.99 U4.AL2 ; U4.AT29 120.13,82.84 v2(120.13,83.06) 120.13,83.25 U4.AT26 ; 91.8,141.44 92.66,140.84 92.66,140.29 v2(93.18,139.77) ; v4(103.71,32.09) 103.65,32.03 PU701.3 ; U4.A41 U4.A43 135.61,76.62 v2(135.95,76.28) ; U4.AV31 119.59,81.35 v2(119.59,81.14) 119.59,80.83 U4.AV33 ; U4.H24 U4.H26 132.28,83.43 v2(132.28,83.05) ; UV7.T9 112.93,146.17 v2(113.32,146.17) ; U4.AD40 125.98,77.14 v2(125.98,76.87) 126,76.85 U4.AC44 ; U4.BA1 U4.BC1 117.8,95.04 117.4,95.45 v2(117.24,95.45) ; v2(120.12,85.53) 120.12,85.43 U4.AV22 U4.AV24 ; UV7.G9 112.78,153.57 v2(113.16,153.95) UV7.F9 ; UV7.J2 107.16,151.92 v2(106.78,152.3) ; U4.K39 130.86,77.71 v2(130.64,77.71) 130.54,77.71 U4.N39 ; v2(112.43,128.85) 112.03,129.25 UV5.E2 ; v2(105.98,146.71) 106.36,146.32 UV7.T1 ; U4.Y28 127.14,82.99 v2(126.8,83.33) 126.48,83.01 U4.AA28 ; UV7.E8 111.98,155.14 v2(112.39,155.55) 112.02,155.92 UV7.D8 ; U4.H17 132.16,87.08 131.87,87.36 131.87,87.77 U4.K15 131.83,88.3 v2(131.83,88.54) 131.83,88.6 132.18,88.95 U4.H13 ; UV7.B1 106.38,157.53 v2(105.98,157.93) ; UV5.M1 112.85,134.85 v2(113.24,135.24) ; U4.M24 130.39,84.16 v2(130.51,84.04) ; U4.B45 134.71,75.58 U4.B44 135.23,76.11 U4.A44 ; UV12.F9 v2(151.13,164.79) 150.76,165.17 UV12.G9 ; UV5.A9 106.42,126.05 v2(106,126.46) 106.39,126.85 UV5.B9 ; UV9.E2 125.36,165.97 v2(124.97,165.57) ; PU701.17 103.65,32.71 PU701.7 ; UV5.B3 110.94,126.85 v2(110.71,126.62) ; UV5.T9 v2(106.01,138.46) ; UV9.B1 122.97,165.12 122.57,164.72 v2(122.57,164.72) ; UV7.P9 112.71,147.92 112.38,147.58 112.38,147.53 v2(112.41,147.53) ; v2(38.34,59.54) 35.41,62.47 31.58,62.47 31.27,62.16 RP18.4 ; U4.AL8 122.64,91 122.32,91.32 v2(122.2,91.32) 122.04,91.32 121.78,91.06 U4.AN8 ; v2(151.13,165.56) 150.72,165.97 UV12.G8 ; U4.B19 134.24,86.44 133.9,86.1 133.38,86.1 U4.F20 133.37,85.91 133.16,85.7 v2(133.16,85.54) ; U4.BD15 117.42,88.07 117.59,87.9 U4.BC16 118.29,87.66 v2(118.29,87.66) ; U4.AP13 121.65,89.19 v2(121.33,89.52) 120.9,89.52 U4.AT10 119.81,89.41 U4.AV13 ; v2(111.57,152.36) 111.98,151.95 UV7.J8 ; U4.AV6 119.7,92.19 v2(119.4,91.9) 119.7,91.6 U4.AV7 ; UV7.G8 111.98,153.54 v2(112.39,153.95) ; v2(124.23,90.73) 124.01,90.73 U4.AJ8 ; PU301.14 187.61,169.11 v4(187.04,169.68) ; v2(149.54,166.38) 149.13,165.97 UV12.J8 ; UV12.E8 152.32,165.97 v2(152.7,165.59) 153.09,165.97 UV12.D8 ; v2(119.25,77.58) 119.68,77.58 U4.AV40 ; UV12.T9 143.41,165.17 143.08,164.84 143.08,164.82 v2(143.07,164.82) ; U4.BB42 118.07,77.01 v2(118.36,77.29) ; v2(132.43,81.11) 132.18,81.36 U4.H31 ; v2(129.75,79.62) 129.75,79.91 U4.R34 129.78,80.97 U4.P32 ; v2(113.24,136.85) 112.84,136.45 UV5.P1 ; U4.U28 128.46,82.99 v2(128.12,83.33) 127.8,83.66 U4.V26 ; v2(120.35,78.31) 120.68,78.63 U4.AT38 U4.AT36 ; U4.B7 134.12,91.39 134.05,91.32 v2(134.05,91.32) ; UV9.M9 130.97,171.87 v2(130.65,172.18) ; U4.AJ18 123.84,86.89 v2(123.53,86.58) 123.84,86.27 U4.AJ20 ; U4.B2 134.73,93.51 U4.A2 ; v2(113.32,157.67) 112.93,157.67 UV7.B9 ; v2(154.83,169.42) 154.71,169.54 UV12.B3 ; v2(123.07,77) 123.15,76.91 U4.AK43 U4.AK45 ; UV5.J8 107.23,132.44 v2(106.82,132.03) ; UV12.M1 146.33,171.2 146.33,171.19 v2(146.3,171.16) ; v2(113.32,158.44) 112.9,158.44 UV7.A9 ; v2(133.19,164.64) 132.65,165.17 UV9.P1 ; v2(129.44,84.97) 129.78,85.32 U4.P22 130.02,85.12 U4.M22 ; U4.BE41 v2(116.19,77.21) ; U4.H36 132.18,79.69 v2(131.83,80.04) 131.83,80.37 131.6,80.6 U4.K33 ; U4.E45 U4.C45 134.19,75.26 134.74,74.72 v2(135.05,74.72) ; v2(133.12,84.05) 133.17,84 U4.D25 133.97,84.5 134.29,84.82 U4.B23 ; v2(136.41,83.65) 136.41,83.66 135.98,83.23 134.87,83.23 U4.B27 ; U4.BC28 118.14,82.78 v2(118.28,82.93) 118.28,83.2 U4.AY26 118.15,84 U4.BB25 ; UV12.T1 143.51,171.57 v2(143.92,171.98) ; U4.AA22 126.48,85.28 v2(126.8,84.96) 127.14,84.62 U4.Y24 ; UV5.G8 107.23,130.83 v2(106.82,130.42) ; U4.AL34 123.15,80.81 v2(123.26,80.81) 123.66,80.42 U4.AJ34 ; JLVDS1.12 v2(95.78,149.03) ; v2(154.71,164.6) UV12.B9
  TOP w0.305: UV9.T1 134.33,165.01 v2(134.33,164.63) ; v2(113.23,138.45) 113.23,138.45 UV5.T1 ; v2(207.17,25.14) 207.17,25.42 206.84,25.75 JCR1.4
  TOP w0.381: v2(135.83,93.22) 135.54,93.51 U4.A2 ; U4.B1 134.66,94.16 134.66,94.39 v2(134.94,94.67) ; v4(180.13,150.65) 180.99,150.65 181.33,150.32 182.87,150.32 183.08,150.11 PQ307.1 ; v2(93.91,92) 93.76,92.15 U1.3 ; U4.BE2 v2(116.1,93.6) ; U4.BD1 v2(117.21,94.86) ; v2(135.66,74.73) 135.66,75.68 135.31,76.03 U4.A44 ; v2(117.2,74.58) 117.21,74.59 U4.BD45 ; PQ307.4 184.38,151.16 v4(184.84,150.7) ; v2(147.24,72.84) 146.61,73.47 U9.5 ; PQ101.4 v2(184.36,118.26)
  TOP w0.406: PQ202.4 v2(180.54,65.96) 181.26,65.96 181.84,66.53 PQ202.1
  TOP w0.432: v2(194.88,80.86) 194.77,80.96 PQ102.4 ; v2(183.97,116.41) 183.5,116.41 183.06,115.96 PQ101.1
  TOP w0.457: PC989.1 28.14,114.01 v2(27.99,114.16) ; v2(131.19,143.17) 130.59,142.57 RV56.2 ; v2(31.99,114.21) 29.55,114.21 29.05,113.71 PC989.2 ; v2(167.94,7.33) 166.55,7.33 SW7.5 ; v2(129.69,131.87) 129.86,132.05 CV88.2 ; SW4.3 130.55,11.75 131.22,11.07 SW4.6 132.74,11.07 133.41,11.75 SW4.4 ; v2(174.19,16.13) 172.96,16.13 SW5.5 ; SW4.5 v2(133.04,16.12) ; 168.74,2.95 168.2,2.95 167.52,2.28 SW7.6 165.78,2.28 165.1,2.95 SW7.3 ; v2(133.14,125.52) 133.22,125.61 UV2.3 ; v2(155.2,53.01) 154.87,53.34 CA9.2 ; SW5.6 172.96,11.08 v2(174.09,11.08) ; v2(113.67,7.33) 116.34,7.33 SW6.5
  TOP w0.508: C78.2 63.66,46.33 64.62,46.33 v2(64.65,46.3) ; JP3.4 v2(186.94,35.8) ; PR946.1 v2(13.72,128.51) ; v2(162.41,171.12) 161.81,171.73 PQ311.3 ; v2(104.68,129.76) 103.63,129.76 CV122.2 ; v2(58.28,46.01) 59.3,46.01 C73.2 ; PC108.2 195.03,77.7 PC109.2 194.99,77.69 v2(194.42,77.11) ; v2(188.02,59.05) 188.02,59.05 JODD2.12 ; CL1.1 CL2.2 37.87,15.82 38.23,15.46 v2(38.23,13.84) ; v2(178,129.77) 178.39,129.37 CA38.2 ; RV31.1 152.73,131.02 153.54,131.82 v2(153.54,131.86) ; v2(61.26,34.46) 61.31,34.41 C185.2 ; v2(184.92,86.17) 184.19,86.17 183.48,85.46 R619.2 ; CV130.2 v2(105.16,162.62) ; CV56.2 150.08,129.86 v2(150.6,129.33) ; CV121.2 125.99,175.82 RV88.2 125.58,175.8 v2(125.33,175.55) ; v2(86.91,100.42) 87.74,100.42 C53.2 ; CL24.2 v2(39.04,31.49) ; v2(69.62,41.29) 69.05,41.29 C101.2 ; C660.2 181.49,80.72 181,80.22 v2(180.21,80.22) ; v2(98.04,61.29) 98.03,61.3 C87.2 ; C727.2 78.31,16.69 ; 78.31,16.69 79.19,16.69 v2(79.6,17.09) ; 78.31,16.69 R650.1 ; PR923.1 23.54,123.28 23.53,123.28 ; CT3.2 78.73,130.98 v2(78.24,130.5) 78.65,130.09 CT2.2 ; C82.2 C83.2 96.67,47.95 v2(96.33,47.61) ; PR624.1 v4(113.88,174.8) ; R522.2 166.28,71.05 v2(166.73,70.6) 167.17,71.04 C664.2 ; v2(194.51,82.52) 195,82.03 PR111.2 ; C84.2 99.72,55.14 C85.2 v2(99.72,57.07) ; v2(137.12,173.86) 137.38,173.86 137.73,174.2 137.73,175.56 137.49,175.8 CV124.2 136.12,175.8 CV188.2 ; C723.2 v2(76.79,14.26) ; PR208.1 v2(175.89,65.33) ; v2(85.1,138.23) 85.1,140.26 JLVDS1.32 ; C118.2 121.4,72.06 v2(121.25,72.21) ; JUSB3.8 v2(205.41,148.84) ; v2(16.17,129.59) 15.73,129.59 15.46,129.32 PR946.2 ; SW5.4 175.15,11.75 v2(174.19,11.75) ; v2(156.17,174.19) 155.91,174.45 CV176.2 ; PU101.4 v2(189.72,110.57) ; CV174.2 v2(140.69,173.16) ; v2(39.91,18.33) CL7.1 39.91,17.37 39.61,17.07 CL3.2 ; JKB2.25 v2(177.86,104.14) ; CA17.2 161.02,51.33 v2(161.22,51.53) ; PC705.1 v2(108.66,29.68) ; PC303.1 v2(193.95,167.23) 194.02,167.16 PR308.1 ; R15.1 45.49,100.34 v2(45.96,99.87) 46.35,100.27 C536.2 ; PR205.1 v2(180.47,62.86) 179.66,62.86 178.98,63.55 PQ209.3 ; PR403.2 111.45,5.65 PC407.2 v4(112.07,6.9) ; v2(181.72,127.43) 181.72,127.9 CA39.2 ; v2(127.11,111.33) 126.2,110.41 QV1.3 ; v2(73.93,40.15) 73.7,39.92 C98.2 ; v2(102.08,134.23) RV64.2 102.72,134.24 CV103.2 ; v2(156.71,96) 156.2,96.5 JKB1.29 156.2,97.91 155.97,98.14 155.4,98.14 155.2,97.93 JKB1.30 ; JHDMI1.2 13.56,65.06 R488.1 ; PC202.2 186.6,73.12 v2(187.07,73.6) ; v2(34.8,31.21) 34.8,31.81 CL18.2 ; CV160.2 v2(118.73,170.78) ; JKB1.27 158.2,96.68 v2(157.65,96.13) 157.2,96.58 JKB1.28 ; v2(160.23,46.19) 160.47,45.95 CA10.2 ; C91.2 76.1,40.51 75.75,40.86 v2(75.07,40.86) ; 21.72,120.17 20.06,120.17 19.46,119.58 17.26,119.58 v2(17.03,119.81) ; v2(158.3,123.55) 158.58,123.82 QV9.3 ; v2(13.32,67.1) 13.91,66.51 C544.2 ; RV19.1 130.28,126.12 RV4.2 130.17,126.69 v2(129.92,126.94) ; JUSB3.1 v2(202.43,158.3) ; PQ205.3 v2(182.76,70.56) ; C35.2 95.24,88.52 94.86,88.15 92.5,88.15 91.98,88.67 91.98,88.79 v2(92.01,88.82) 92.01,88.99 91.74,89.26 Q1.3 ; v2(148.69,122.63) 148.98,122.33 CV52.2 ; v2(101.2,29.9) 99.67,29.9 PR712.2 ; v2(31.35,55.36) 31.35,55.61 R54.2 ; v2(152.06,174.25) 152.35,174.54 CV191.2 ; PU201.4 v2(189.48,67.53) ; v2(135.66,133.48) 135.73,133.54 RV47.1 135.71,134.49 CV54.2 134.85,134.5 CV83.2 ; JKB2.26 149.21,106.33 150.29,107.4 v2(150.29,108.43) ; v2(57.8,55.79) 57.82,55.77 58.73,55.77 C75.2 ; v2(114.02,169.47) 114.26,169.71 PC619.2 114.26,170.88 PR623.1 ; R279.1 139.55,79.11 R288.1 140.07,79.12 v2(140.18,79.02) ; v2(102.36,153.59) 102.67,153.27 RV71.2 CV127.2 ; C69.2 65.95,54.26 v2(65.94,54.27) ; v2(198.19,15.73) 197.74,15.28 PR605.2 ; C529.2 15.67,114.03 v2(16.11,113.59) 15.65,113.13 C531.2 ; CV198.2 144.99,173.62 v2(145.49,173.12) ; JTS1.5 v2(205.09,143.11) ; R89.1 87.95,111.76 87.51,112.19 v2(86.41,112.19) ; PC613.2 v4(107.15,165.83) ; PR609.2 173.63,132.41 v4(173.78,132.56) ; C68.2 75.73,50.27 75.96,50.5 75.96,51.15 75.57,51.54 v2(75.12,51.54) ; v2(200,10.9) 200.24,11.14 PC637.2 ; v2(148.97,162.2) 148.22,162.95 144.75,162.95 143.64,161.85 RV91.2 ; R44.2 76.78,37.67 77.04,37.93 v2(77.49,37.93) ; CV59.2 145.7,132.59 v2(145.63,132.66) ; v2(96.91,39.88) 96.82,39.78 C107.2 96.82,37.19 C106.2 ; v2(106.13,144.74) 106.13,143.81 CV146.2 ; PC506.2 31.84,12.65 v2(31.84,13) ; R84.2 v2(57.26,119.44) ; CV99.2 128.57,140.7 128.57,139.85 v2(128.18,139.46) ; C543.2 15.25,70.74 15.84,70.14 U73.2 15.92,70.31 16.24,70.64 v2(16.74,70.64) ; C1322.1 v2(202.29,138.72) ; v2(186.18,131.77) 186.18,131.86 185.57,132.47 PR809.2 184.71,132.75 184.18,133.28 PR810.2 ; v2(128.49,136.15) 128.33,135.99 CV84.2 128.33,135.55 CV81.2 130.17,135.55 CV82.2 ; JTS1.2 205.33,145.51 v2(205.15,145.69) ; C104.2 99.62,42.34 v2(100.08,42.8) 99.6,43.27 C105.2 ; JLED1.5 v2(179.31,46.25) ; Q6.3 92.74,103.22 v2(93.01,103.49) ; 97.41,159.64 101.08,157.17 v2(101.08,154.21) ; CL17.2 v2(28.57,32.59) ; v2(150.6,134.67) 150.06,134.13 CV85.2 ; PC107.2 190.59,119.05 PR109.1 v2(190.59,120.76) ; PC701.2 v2(97.91,33.63) ; DA3.2 179.59,131.11 v2(179.36,130.88) ; C96.2 60.89,40.55 v2(60.91,40.53) ; CV178.2 154.12,174.54 v2(153.83,174.25) ; PD104.2 184.09,120.93 v2(184.51,120.51) ; v2(141.73,97.88) 141.73,96.91 C111.2 ; v2(180.77,133.78) 181.27,133.28 PR812.2 183,133.28 PR811.2 ; CV162.2 119.8,172.81 v2(120.04,173.05) ; v2(147.76,123.55) RV30.2 147.77,124.41 CV28.2 ; PC511.2 v2(29.64,1.84) ; CL29.2 v2(39.03,29.39) ; v2(35.92,33.12) 35.92,33.12 RL8.2 ; Q95.3 18.77,57.53 v2(18.4,57.9) ; v2(104.82,159.1) 104.79,159.08 CV152.2 ; CL19.2 29.54,21.75 29,22.29 v2(28.92,22.29) ; v2(184.1,113.13) PD105.2 183.4,112.42 182.65,113.17 PR104.1 ; C186.2 v2(45.73,109.08) ; C663.2 v2(163.47,93.73) ; CA23.2 158.99,56.4 v2(158.7,56.69) ; v2(204.11,145.7) 203.48,146.33 C1331.2 ; v2(111.68,84.18) 111.81,84.31 R194.1 112.48,83.42 R193.1 ; CV181.2 141.67,175.77 CV189.2 141.26,175.77 140.9,175.41 v2(140.9,174.69) ; CA22.2 155.81,56.67 v2(155.96,56.82) ; JPWRB1.5 102.34,126.89 v2(102.83,127.38) 102.32,127.89 JPWRB1.6 ; C119.2 118.66,71.75 v2(118.26,72.16) ; JODD2.4 183.93,50.15 v2(185.06,50.15) ; v2(152.88,92.25) 152.38,91.75 C782.2 152.38,90.85 150.86,89.33 C781.2 ; CV171.2 121.62,174.2 v2(121.62,174.19) ; v2(99.9,132.69) JPWRB1.8 99.91,130.8 101.83,130.8 v2(101.97,130.66) ; PR105.1 v2(187.88,120.16) ; C171.2 v2(123.32,68.46) ; Q116.3 v2(112.6,52.64) ; R27.1 88.84,107.45 89.16,107.77 90.42,107.77 v2(90.72,108.07) ; v2(58.99,50.78) 58.99,50.78 58.82,50.61 C74.2 ; C174.2 115.87,71.3 115.54,70.97 C172.2 115.25,70.97 v2(114.71,71.51) ; JLED1.10 181.71,41.25 182.01,41.55 v2(182.01,41.93) ; R124.2 124.35,98.94 v2(124.35,98.94) R123.2 ; v2(108.3,33.25) 107.84,32.79 PR711.2 ; C77.2 63.85,54.37 64.29,54.37 v2(64.39,54.27) ; PR945.2 27.36,127.77 ; C99.2 57.1,34.44 v2(57.08,34.46) ; v2(94.9,51.72) 95.43,51.19 C108.2 ; C100.2 63.81,34.38 v2(63.73,34.46) ; PQ201.3 180.9,59.5 181.11,59.71 v2(181.11,60.25) ; JTS1.8 v2(205.78,147.61) ; R716.2 v2(101.38,149.92) ; v2(159.45,42.69) 159.21,42.45 CA66.1 ; C95.2 76.36,32.67 v2(76.47,32.56) ; v2(150.3,174.24) 150.53,174.47 CV190.2 150.53,175.18 149.93,175.78 CV172.2 149.59,175.78 RV82.2 ; CL8.2 30.28,32.8 v2(30.71,33.22) 31.18,32.75 CL10.2 ; C70.2 69.91,54.34 v2(69.84,54.27) ; JKB1.32 v2(154.4,100.28) ; v2(198.61,55.1) 198.23,54.72 R710.1 ; v2(179.66,83.18) 179.64,83.21 C657.2 179.63,84.04 C658.2 ; v2(129.69,131.87) 129.14,132.42 CV87.2 ; C76.2 74.61,54.42 74.97,54.05 v2(75.14,54.05) ; CV46.2 152.91,117.01 152.9,116.99 152.9,116.57 v2(152.55,116.21) ; v2(36.05,29.31) 36.47,29.73 CL23.2 ; CL25.2 CL26.2 v2(34.41,21.9) ; RV28.2 CV27.2 v2(152.38,134.43) ; R110.2 127.39,96.79 v2(127.55,96.63) ; RV56.2 130.21,142.66 CV98.2 ; v2(130.34,144.18) 130.1,144.18 129.5,143.58 RV55.2 ; v4(103.29,7.01) 103.54,7.01 104.49,7.96 PC431.2 104.49,9.04 PR409.2 ; v2(162.21,165.06) 162.21,165.05 PC324.2 ; v2(114.31,94.31) 114.04,94.31 113.41,94.94 R203.1 113.19,94.93 R202.1 ; v2(101.94,151.69) 101.94,151.56 R39.1 ; v2(168.56,73.7) 168.97,73.28 C535.2 ; v2(76.47,34.08) 75.92,34.08 75.55,34.45 R45.2 ; C654.2 C655.2 v2(179.74,77.79) ; QV7.3 v2(157.12,118.73) ; PC702.2 v2(102.53,29.52) ; CA40.2 182.61,127.66 v2(182.61,127.37) ; SW4.4 134.98,11.75 v2(135,11.77) v3(136.45,11.77) ; v2(139.24,131.88) 139.14,131.98 RV11.2 ; C67.2 74.62,50.36 v2(75.14,50.88) ; v2(134.77,101.81) 134.5,101.53 134.48,101.53 133.99,101.05 133.99,100.42 133.51,99.93 R312.2 ; JCR1.5 v2(209.16,21) ; v2(146.87,129.25) 146.32,129.79 CV30.2 ; PC309.2 v4(186.16,170.42) ; RT12.1 85.13,136.82 v2(85.11,136.84) ; v2(140.14,80.12) 140.11,80.16 R289.1 ; JTP1.7 193.78,94.05 v2(193.33,93.6) ; v2(62.74,46.67) 62.72,46.65 62.36,46.65 61.7,47.3 C72.2 ; JLVDS1.33 95.8,151.51 v2(95.8,149.75) ; v2(186.71,130.32) 186.09,129.71 CA43.2 ; v4(188.69,170.43) 188.92,170.66 PC305.2 ; CV49.2 CV105.2 v2(131.11,109.01) ; C103.2 63.53,41.29 v2(64.48,41.29) ; PC708.2 v2(104.83,37.89) ; v2(67.07,46.3) 66.98,46.39 C79.2 ; R143.2 139.46,94.3 v2(139.59,94.43) ; JODD2.1 183.93,47.15 v2(184.83,47.15) ; CV34.2 122.13,150.04 v2(122.09,150.01) 122.09,149.79 122.88,149.01 CV35.2 ; PR948.1 v2(18,111.25) ; C696.2 v2(182.65,90.86) ; PR948.2 v2(18.02,112.16) ; PC318.1 182.24,157.5 v4(182.25,157.51) ; C92.2 66.27,34.47 65.64,34.47 v2(65.63,34.46) ; CV196.2 103.56,148.22 CV129.2 104.07,148.21 v2(104.26,148.41) ; R36.2 88.82,92.7 v2(88.29,93.23) ; J11.1 169.06,65.46 v2(168.76,65.76) ; PD201.2 v2(183.5,67) ; CV158.2 137.24,172.99 v2(137.13,173.1) ; SW7.3 v2(163.3,2.95) ; v2(20.33,128.67) 20.33,129.44 20.63,129.74 25.2,129.74 PR945.1 ; PC508.2 v2(29.26,6.4) ; PR316.2 v4(193.78,169.91) ; CT11.2 v2(87.54,136.04) ; v2(105.04,27.83) PR705.1 104.3,27.84 PC703.1 ; PC503.2 v2(29.29,10.54) ; R740.2 172.59,71.16 v2(173.02,70.74) 173.5,71.22 C93.2 ; D25.1 199.1,155.9 198.67,156.32 v2(197.2,156.32) ; QV6.3 154.51,123.66 v2(154.66,123.51) ; SW5.3 v2(171.74,11.75) ; PR807.2 187.77,132.63 v2(187.13,131.99) 186.46,132.65 PR808.2 ; CV138.2 v2(104.33,144.07) ; R66.1 v2(77.96,102.48) ; JCR1.6 v2(209.16,27.5) ; CV100.2 144.94,147.99 v2(144.83,147.88) ; v2(59.38,34.46) 59.39,34.45 C102.2 ; v3(116.34,8.57) 116.34,7.33 ; v2(136.21,100.39) 135.82,100 C149.2 ; v2(72.59,46.63) 72.58,46.64 C71.2 ; PH902.1 v2(33.52,115.19) ; v2(130.16,105.26) 131.44,105.26 QV2.3 ; R608.2 179.84,89.08 179.84,90.79 179.36,91.27 v2(179.34,91.27) ; PR506.2 v2(29.7,12.97) ; C175.2 135.85,72.85 ; CA65.1 144.76,55.17 v2(143.87,56.06) ; v2(195.08,168.75) PQ308.3 v3(197.53,168.75) ; CV80.2 148.44,129.21 v2(148.83,128.83) 148.44,128.45 CV32.2 ; CV89.2 143.59,135.33 144.12,134.8 v2(144.12,134.73) ; v2(143.18,93.1) C113.1 142.44,92.21 CLRP2.1 ; C6.2 C537.2 11.23,113.73 v2(11.03,113.52) ; PC919.2 25.38,91.24 v2(25.31,91.31) ; CV19.2 142.02,127.1 142.76,126.35 v2(142.77,126.35) ; v2(95.55,116.6) 95.55,115.45 96.01,114.99 D24.1 ; R283.2 112.18,95.92 v2(111.61,95.92) ; CL63.1 v3(22.05,84.37) ; C493.2 v2(162.68,71.65) ; v2(34.08,23.35) 34.43,23 RL12.1 ; v2(148.19,134.42) 148.45,134.16 CV86.2 147.71,133.26 CV57.2 ; PR947.2 v2(24.26,86.26) ; JTP1.8 v2(184.6,96.05) ; CA7.1 v2(156.75,57.5) ; JLVDS1.34 87.75,146.42 v2(87.75,141.72) ; CV139.2 106.7,139.67 v2(106.3,139.28) ; R68.2 v2(45.66,102.08) ; SW4.3 128.67,11.75 v2(128.65,11.77) ; CV48.2 v2(142.19,117.78) ; v2(104,163.08) 104.22,162.86 CV141.2 ; Q118.3 149.6,82.86 149.33,82.59 v2(148.3,82.59) ; C662.2 v2(176.01,93.66) ; PC704.1 v2(105.73,27.24) ; L45.1 156.55,87.96 v2(156.24,88.26) ; PR213.1 187.7,62.9 v2(188.18,63.37) 187.73,63.82 PC207.2 ; RV84.2 102.03,131.56 v2(102.01,131.55) ; CV170.2 130.65,175.77 CV149.2 129.73,175.77 RV76.2 129.17,175.77 v2(128.95,175.55) ; v2(150.55,138.25) 150.15,137.84 RV12.1 ; JPWRB1.7 v2(99.9,121.9) ; v2(133.8,174.24) 134.25,174.69 CV197.2 ; v2(114.43,131.2) 114.92,131.7 CV117.2 115.65,130.65 CV106.2 ; v2(156.44,76.08) C653.2 C492.2 ; JLED1.11 v2(181.96,53.25) ; v2(98.04,59.01) 98.04,58.67 97.39,58.03 C86.2 ; JLED1.12 v2(175.41,38.25) ; PC626.2 v2(113.38,175.52) ; v2(94.74,46) 94.93,45.81 C109.2 ; C783.2 146.05,92.52 v2(146.48,92.95) ; v2(140.46,149.87) 140.81,149.87 141.22,149.45 CV96.2 CV97.2 142.21,149.1 RV57.1 ; JODD2.11 187.94,44.25 v2(187.95,44.25) ; CV58.2 144.01,126.93 v2(143.98,126.91) ; PR706.1 v2(97.91,32.68) ; CT1.2 v2(77.96,129.02) ; v4(167.9,131.14) PR615.2 PR616.1 PC638.1 ; RA6.2 v2(163,42.3) ; CV55.2 128.23,132.13 v2(128.54,131.82) ; R309.1 v2(45.73,109.99) ; C661.1 173.73,93.64 v2(173.84,93.75) ; CL28.2 38.48,30.71 v2(39.03,30.71) ; v2(180.64,154.3) 180.41,154.07 PC310.1 ; PC209.2 191.82,70.9 PR217.1 191.8,70.3 191.42,69.92 v2(190.98,69.92) ; JUSB3.7 v2(205.41,159.65) ; CV159.2 v2(125.1,174.22) ; v2(58.01,118.5) 58.01,117.83 PC953.2 ; JKB1.31 v2(189.99,100.27) ; v2(116.52,146.74) 116.2,146.74 115.8,146.35 RV86.2 ; CA64.1 v2(148.95,59.61) ; CA25.2 160.7,48.77 v2(160.28,49.18) ; CV148.2 113.48,155.8 v2(113.22,155.55) ; CV147.2 v2(106.1,162.61) ; CA11.2 162.06,52.17 CA16.2 v2(162.06,50.61) ; Q117.3 v2(158.27,67.15) ; R64.1 v2(75.66,117.37) ; PC422.2 v2(100.51,10.47) ; 87.99,122.74 v3(87.99,122.13) ; CA8.2 v2(154.16,56.82) ; RT8.1 v2(80.48,126.47) ; v2(39.05,28.51) CL21.2 38.37,27.63 CL20.2 ; C94.2 66.29,40.14 v2(66.28,40.15) ; v2(133.43,110.45) CV53.2 133.43,108.79 RV42.1 ; C780.2 v2(144.32,93.19) ; CV132.2 v2(102.84,146.41) ; R59.2 33.67,43.34 v2(33.01,42.68) ; JUSB3.4 v2(202.45,155.3) ; PR312.2 v2(196.78,164.56) ; C667.2 v2(174.83,71.49) ; PC914.2 27.28,121.38 v4(27.5,121.16) ; v2(169.61,2.95) SW7.4 168.74,2.95 ; PC510.2 v2(32.65,1.85) ; RA22.2 v2(161.07,54.92) ; C80.2 62.2,54.27 v2(62.61,54.27) ; Q37.3 v2(164.56,69.53) ; v2(158.81,171.37) 158.77,171.37 157.98,171.37 CV185.2 ; v2(71.98,40.15) 71.27,40.15 C97.2 ; v4(184.07,147.11) 184.68,147.11 PC104.2 184.73,146.16 PC103.2 ; CL22.2 v2(26.47,30.06) ; JTS1.7 v2(207.94,139.91) ; R507.1 v2(197.66,161.72) ; PQ303.3 v2(184.39,154.19) ; R122.2 v2(125.34,98.97) ; PR947.1 v2(24.26,92.34) ; R205.1 v2(133.98,70.74) ; R627.2 v2(182.65,89.03) ; C112.2 139.04,99.04 v2(139.28,99.27) ; CV155.2 v2(123.36,174.19) ; C90.2 v2(75.02,40.17)
  VCC w0.203: H8.1 2.8,105.63 ; H8.1 4.14,105.14 ; H8.1 2.8,101.97 ; H8.1 4.14,102.46 ; H8.1 4.63,103.8 ; H8.1 1.46,105.14 ; H8.1 1.46,102.46 ; JUSB2.4 14.8,45.3 ; JUSB2.4 14.06,44.56 ; JUSB2.4 15.37,43.99 ; JUSB2.4 14.23,45.13 ; JUSB2.4 14.8,43.82 ; JUSB2.4 15.54,44.56 ; JUSB2.4 15.37,45.13 ; JUSB2.4 14.23,43.99 ; 159.52,157.71 H5.1 ; H5.1 163.12,156.19 ; H5.1 163.12,159.24 ; H5.1 161.6,155.63 ; H5.1 160.08,159.24 ; H5.1 163.68,157.71 ; H5.1 161.6,159.8 ; H5.1 160.08,156.19 ; JUSB1.7 13.3,27.8 ; JUSB1.7 13.87,27.63 ; JUSB1.7 14.04,27.06 ; JUSB1.7 13.87,26.49 ; JUSB1.7 13.3,26.32 ; 14.8,22.82 JUSB1.4 ; JUSB1.4 15.37,24.13 ; JUSB1.4 14.8,24.3 ; JUSB1.4 15.37,22.99 ; JUSB1.4 15.54,23.56 ; JUSB1.4 14.23,24.13 ; JUSB1.4 14.06,23.56 ; JUSB1.4 14.23,22.99 ; H3.1 93.54,82.84 ; H3.1 91.84,82.21 ; H3.1 93.54,78.17 ; H3.1 91.84,78.8 ; H3.1 91.2,80.51 ; H3.1 95.24,78.8 ; H3.1 95.88,80.51 ; H3.1 95.24,82.21 ; 3.84,58.91 JHDMI1.23 ; JHDMI1.23 5.2,58.91 ; JHDMI1.23 2.48,58.91 ; JHDMI1.23 5.2,59.91 ; JHDMI1.23 2.48,59.91 ; 41.84,78.17 H2.1 ; H2.1 43.54,82.21 ; H2.1 39.5,80.51 ; H2.1 43.54,78.8 ; H2.1 40.14,78.8 ; H2.1 44.18,80.51 ; H2.1 41.84,82.84 ; H2.1 40.14,82.21 ; 3.9,35.79 JUSB1.11 ; JUSB1.11 6.74,35.79 ; JUSB1.11 5.32,35.79 ; JUSB1.11 6.74,34.91 ; JUSB1.11 3.9,34.91 ; 10.64,19.21 JUSB1.13 ; JUSB1.13 14.2,18.33 ; JUSB1.13 14.2,19.21 ; JUSB1.13 12.42,18.33 ; JUSB1.13 10.64,18.33 ; JUSB1.13 14.2,20.09 ; 10.64,34.91 JUSB1.10 ; JUSB1.10 14.2,35.79 ; JUSB1.10 14.2,34.03 ; JUSB1.10 10.64,35.79 ; JUSB1.10 14.2,34.91 ; JUSB1.10 12.42,35.79 ; H10.1 21.33,3.75 ; H10.1 19.5,5.58 ; H10.1 18.16,2.41 ; H10.1 18.16,5.09 ; H10.1 20.84,5.09 ; H10.1 19.5,1.92 ; H10.1 20.84,2.41 ; H10.1 17.67,3.75 ; 12.42,39.33 JUSB2.13 ; JUSB2.13 10.64,40.21 ; JUSB2.13 14.2,40.21 ; JUSB2.13 14.2,39.33 ; JUSB2.13 14.2,41.09 ; JUSB2.13 10.64,39.33 ; JUSB1.12 6.74,19.21 ; JUSB1.12 3.9,18.33 ; JUSB1.12 5.32,18.33 ; JUSB1.12 6.74,18.33 ; JUSB1.12 3.9,19.21 ; 3.9,56.79 JUSB2.11 ; JUSB2.11 5.32,56.79 ; JUSB2.11 3.9,55.91 ; JUSB2.11 6.74,55.91 ; JUSB2.11 6.74,56.79 ; 3.9,39.33 JUSB2.12 ; JUSB2.12 5.32,39.33 ; JUSB2.12 6.74,40.21 ; JUSB2.12 6.74,39.33 ; JUSB2.12 3.9,40.21 ; 10.64,55.91 JUSB2.10 ; JUSB2.10 14.2,56.79 ; JUSB2.10 14.2,55.91 ; JUSB2.10 12.42,56.79 ; JUSB2.10 10.64,56.79 ; JUSB2.10 14.2,55.03 ; JCRT1.17 7.75,129.56 ; JCRT1.17 7.75,127.84 ; JCRT1.17 5.95,129.56 ; JCRT1.17 7.75,128.7 ; 11.89,64.48 JHDMI1.2 ; JHDMI1.2 12.35,65.52 ; JHDMI1.2 12.47,65.06 ; JHDMI1.2 12.35,64.6 ; JHDMI1.2 11.43,64.6 ; 10.68,76.31 JHDMI1.21 ; JHDMI1.21 12.04,75.31 ; JHDMI1.21 13.4,76.31 ; JHDMI1.21 10.68,75.31 ; JHDMI1.21 13.4,75.31 ; JHDMI1.20 13.4,60.81 ; JHDMI1.20 10.68,62.81 ; JHDMI1.20 12.04,62.81 ; JHDMI1.20 13.4,61.81 ; JHDMI1.20 10.68,60.81 ; JHDMI1.20 12.04,60.81 ; JHDMI1.20 10.68,61.81 ; JHDMI1.20 13.4,62.81 ; JCRT1.16 7.75,109.46 ; JCRT1.16 7.75,108.6 ; JCRT1.16 5.95,107.74 ; JCRT1.16 7.75,107.74 ; JUSB2.7 13.87,47.49 ; JUSB2.7 13.3,47.32 ; JUSB2.7 14.04,48.06 ; JUSB2.7 13.3,48.8 ; JUSB2.7 13.87,48.63 ; JHDMI1.8 12.47,68.06 ; JHDMI1.8 12.35,68.52 ; JHDMI1.8 12.35,67.6
  IN1 w0.508: v2(151.57,53.53) 151.57,55.14 v2(152.53,56.1)
  GND w0.203: JHDMI1.20 13.4,60.81 ; JHDMI1.20 10.68,62.81 ; JHDMI1.20 10.68,60.81 ; JHDMI1.20 13.4,62.81 ; JHDMI1.20 10.68,61.81 ; JHDMI1.20 13.4,61.81 ; JHDMI1.20 12.04,62.81 ; JHDMI1.20 12.04,60.81 ; JODD1.12 199.22,61.43 ; JODD1.12 200.45,60.9 ; JODD1.12 199.76,60.21 ; JODD1.12 199.76,61.59 ; JODD1.12 199.07,60.9 ; JODD1.12 199.22,60.36 ; 200.22,62.43 JODD1.13 ; JODD1.13 200.07,61.9 ; JODD1.13 200.76,61.21 ; JODD1.13 201.3,62.43 ; JODD1.13 201.3,61.36 ; JODD1.13 200.76,62.59 ; JBATT1.8 185.61,180.31 ; JBATT1.8 185.19,179.12 ; JBATT1.8 184,181.92 ; JBATT1.8 184,178.7 ; JBATT1.8 182.81,179.12 ; JBATT1.8 182.39,180.31 ; JBATT1.8 185.19,181.5 ; JBATT1.8 182.81,181.5 ; H5.1 163.12,159.24 ; H5.1 161.6,155.63 ; H5.1 161.6,159.8 ; H5.1 163.68,157.71 ; H5.1 163.12,156.19 ; H5.1 160.08,156.19 ; H5.1 159.52,157.71 ; H5.1 160.08,159.24 ; H11.1 203.33,173.8 ; H11.1 199.67,173.8 ; H11.1 201.5,171.97 ; H11.1 202.84,172.46 ; H11.1 200.16,175.14 ; H11.1 202.84,175.14 ; H11.1 200.16,172.46 ; H11.1 201.5,175.63 ; JODD1.4 201.31,47.43 ; JODD1.4 200.21,46.32 ; JODD1.4 201.31,46.32 ; JODD1.4 200.05,46.88 ; JODD1.4 201.47,46.88 ; JODD1.4 200.21,47.43 ; 10.68,76.31 JHDMI1.21 ; JHDMI1.21 13.4,76.31 ; JHDMI1.21 13.4,75.31 ; JHDMI1.21 10.68,75.31 ; JHDMI1.21 12.04,75.31 ; 14.8,43.82 JUSB2.4 ; JUSB2.4 14.8,45.3 ; JUSB2.4 15.37,45.13 ; JUSB2.4 15.37,43.99 ; JUSB2.4 14.23,43.99 ; JUSB2.4 14.06,44.56 ; JUSB2.4 14.23,45.13 ; JUSB2.4 15.54,44.56 ; 137.61,120.65 JHDD1.23 ; JHDD1.23 137.15,119.39 ; JHDD1.23 140.13,120.65 ; JHDD1.23 138.87,121.11 ; JHDD1.23 137.61,118.13 ; JHDD1.23 138.87,117.68 ; JHDD1.23 140.58,119.39 ; JHDD1.23 140.13,118.13 ; 9.88,67.02 JHDMI1.5 ; JHDMI1.5 10.8,66.1 ; JHDMI1.5 9.88,66.1 ; JHDMI1.5 10.92,66.56 ; JHDMI1.5 10.8,67.02 ; JHDMI1.5 9.76,66.56 ; JODD1.7 201.31,50.13 ; JODD1.7 201.47,50.69 ; JODD1.7 200.76,51.4 ; JODD1.7 200.21,50.13 ; JODD1.7 200.05,50.69 ; JODD1.7 200.21,51.24 ; JODD1.7 201.31,51.24 ; H18.1 201.33,72.25 ; H18.1 198.16,73.59 ; H18.1 197.67,72.25 ; H18.1 200.84,73.59 ; H18.1 199.5,70.42 ; H18.1 198.16,70.91 ; H18.1 200.84,70.91 ; H18.1 199.5,74.08 ; 169.89,175.31 JBATT2.8 ; JBATT2.8 171.5,173.7 ; JBATT2.8 170.31,174.12 ; JBATT2.8 172.69,176.5 ; JBATT2.8 172.69,174.12 ; JBATT2.8 170.31,176.5 ; JBATT2.8 171.5,176.92 ; JBATT2.8 173.11,175.31 ; JHDMI1.8 12.35,68.52 ; JHDMI1.8 11.31,68.06 ; JHDMI1.8 12.47,68.06 ; JHDMI1.8 11.43,68.52 ; JHDMI1.8 12.35,67.6 ; JHDMI1.8 11.43,67.6 ; 203.81,179.12 JBATT1.9 ; JBATT1.9 205,178.7 ; JBATT1.9 205,181.92 ; JBATT1.9 206.19,179.12 ; JBATT1.9 206.19,181.5 ; JBATT1.9 203.81,181.5 ; JBATT1.9 206.61,180.31 ; JBATT1.9 203.39,180.31 ; 4.15,129.56 JCRT1.17 ; JCRT1.17 4.15,127.84 ; JCRT1.17 5.95,127.84 ; JCRT1.17 7.75,128.7 ; JCRT1.17 5.95,129.56 ; JCRT1.17 4.15,128.7 ; JCRT1.17 7.75,127.84 ; JCRT1.17 7.75,129.56 ; 2.48,60.91 JHDMI1.23 ; JHDMI1.23 5.2,59.91 ; JHDMI1.23 5.2,58.91 ; JHDMI1.23 2.48,59.91 ; JHDMI1.23 3.84,58.91 ; JHDMI1.23 5.2,60.91 ; JHDMI1.23 3.84,60.91 ; JHDMI1.23 2.48,58.91 ; 93.54,78.17 H3.1 ; H3.1 91.2,80.51 ; H3.1 95.24,82.21 ; H3.1 95.24,78.8 ; H3.1 95.88,80.51 ; H3.1 91.84,82.21 ; H3.1 91.84,78.8 ; H3.1 93.54,82.84 ; 18.16,2.41 H10.1 ; H10.1 20.84,5.09 ; H10.1 17.67,3.75 ; H10.1 19.5,1.92 ; H10.1 20.84,2.41 ; H10.1 21.33,3.75 ; H10.1 19.5,5.58 ; H10.1 18.16,5.09 ; H7.1 84.74,2.21 ; H7.1 85.23,3.55 ; H7.1 84.74,4.89 ; H7.1 81.57,3.55 ; H7.1 82.06,4.89 ; H7.1 82.06,2.21 ; H7.1 83.4,5.38 ; H7.1 83.4,1.72 ; 14.2,41.09 JUSB2.13 ; JUSB2.13 10.64,40.21 ; JUSB2.13 14.2,40.21 ; JUSB2.13 14.2,39.33 ; JUSB2.13 12.42,39.33 ; JUSB2.13 10.64,39.33 ; JUSB1.11 6.74,34.91 ; JUSB1.11 6.74,35.79 ; JUSB1.11 3.9,35.79 ; JUSB1.11 3.9,34.91 ; JUSB1.11 5.32,35.79 ; H12.1 196.35,125.18 ; H12.1 193.18,123.84 ; H12.1 195.87,126.53 ; H12.1 193.18,126.53 ; H12.1 192.69,125.18 ; H12.1 194.52,123.35 ; H12.1 194.52,127.01 ; H12.1 195.87,123.84 ; 10.64,18.33 JUSB1.13 ; JUSB1.13 14.2,19.21 ; JUSB1.13 10.64,19.21 ; JUSB1.13 14.2,20.09 ; JUSB1.13 12.42,18.33 ; JUSB1.13 14.2,18.33 ; 6.89,118.17 JCRT1.8 ; JCRT1.8 6.89,117.5 ; JCRT1.8 6.89,116.84 ; 3.9,55.91 JUSB2.11 ; JUSB2.11 6.74,56.79 ; JUSB2.11 5.32,56.79 ; JUSB2.11 3.9,56.79 ; JUSB2.11 6.74,55.91 ; JUSB1.4 15.54,23.56 ; JUSB1.4 15.37,22.99 ; JUSB1.4 14.06,23.56 ; JUSB1.4 14.23,24.13 ; JUSB1.4 14.23,22.99 ; JUSB1.4 14.8,22.82 ; JUSB1.4 14.8,24.3 ; JUSB1.4 15.37,24.13 ; 10.64,34.91 JUSB1.10 ; JUSB1.10 14.2,34.03 ; JUSB1.10 10.64,35.79 ; JUSB1.10 12.42,35.79 ; JUSB1.10 14.2,35.79 ; JUSB1.10 14.2,34.91 ; H2.1 43.54,82.21 ; H2.1 41.84,82.84 ; H2.1 44.18,80.51 ; H2.1 40.14,78.8 ; H2.1 40.14,82.21 ; H2.1 39.5,80.51 ; H2.1 43.54,78.8 ; H2.1 41.84,78.17 ; JCRT1.6 6.89,112.26 ; JCRT1.6 6.89,112.92 ; JCRT1.6 6.89,113.59 ; JCRT1.6 6.05,112.26 ; JCRT1.10 6.89,121.42 ; JCRT1.10 6.89,122.08 ; JCRT1.10 6.89,122.75 ; JBATT2.9 192.5,176.92 ; JBATT2.9 194.11,175.31 ; JBATT2.9 191.31,174.12 ; JBATT2.9 190.89,175.31 ; JBATT2.9 193.69,176.5 ; JBATT2.9 192.5,173.7 ; JBATT2.9 193.69,174.12 ; JBATT2.9 191.31,176.5 ; JUSB2.10 14.2,55.91 ; JUSB2.10 10.64,55.91 ; JUSB2.10 12.42,56.79 ; JUSB2.10 14.2,56.79 ; JUSB2.10 10.64,56.79 ; JUSB2.10 14.2,55.03 ; JBATT1.6 199.5,182.04 ; JBATT1.6 200.24,180.32 ; JBATT1.6 198.76,181.8 ; JBATT1.6 200.24,181.8 ; JBATT1.6 198.76,180.32 ; JBATT1.6 199.5,180.08 ; JDCIN1.3 193.33,158.43 ; JDCIN1.3 194,158.22 ; JDCIN1.3 192.66,158.22 ; JDCIN1.3 193.33,156.67 ; JDCIN1.3 194.21,157.55 ; JDCIN1.3 194,156.88 ; JDCIN1.3 192.66,156.88 ; JDCIN1.3 192.45,157.55 ; 9.88,69.1 JHDMI1.11 ; JHDMI1.11 10.8,69.1 ; JHDMI1.11 10.8,70.02 ; JHDMI1.11 9.88,70.02 ; JHDMI1.11 10.92,69.56 ; JHDMI1.11 9.76,69.56 ; 200.05,43.07 JODD1.1 ; JODD1.1 200.21,43.62 ; JODD1.1 201.31,43.62 ; JODD1.1 201.31,42.51 ; JODD1.1 200.76,42.36 ; JODD1.1 200.21,42.51 ; 65.99,127.81 H1.1 ; H1.1 69.39,124.4 ; H1.1 65.99,124.4 ; H1.1 65.35,126.1 ; H1.1 67.69,123.77 ; H1.1 67.69,128.44 ; H1.1 70.03,126.1 ; H1.1 69.39,127.81 ; 12.56,27.06 JUSB1.7 ; JUSB1.7 12.73,26.49 ; JUSB1.7 13.3,26.32 ; JUSB1.7 13.3,27.8 ; JUSB1.7 12.73,27.63 ; JUSB1.7 13.87,27.63 ; JUSB1.7 13.87,26.49 ; JUSB1.7 14.04,27.06 ; JDCIN1.4 194,160.22 ; JDCIN1.4 192.66,158.88 ; JDCIN1.4 193.33,160.43 ; JDCIN1.4 192.66,160.22 ; JDCIN1.4 192.45,159.55 ; JDCIN1.4 194.21,159.55 ; JDCIN1.4 194,158.88 ; JDCIN1.4 193.33,158.67 ; 187,175.08 JBATT2.6 ; JBATT2.6 187,177.04 ; JBATT2.6 187.74,175.32 ; JBATT2.6 186.26,175.32 ; JBATT2.6 187.74,176.8 ; JBATT2.6 186.26,176.8 ; 4.15,108.6 JCRT1.16 ; JCRT1.16 7.75,109.46 ; JCRT1.16 5.95,107.74 ; JCRT1.16 7.75,107.74 ; JCRT1.16 4.15,109.46 ; JCRT1.16 7.75,108.6 ; JCRT1.16 4.15,107.74 ; JCRT1.16 5.95,109.46 ; 200.76,181.8 JBATT1.7 ; JBATT1.7 201.5,182.04 ; JBATT1.7 201.5,180.08 ; JBATT1.7 202.48,181.06 ; JBATT1.7 202.24,181.8 ; JBATT1.7 200.76,180.32 ; JBATT1.7 202.24,180.32 ; 201.05,62.99 JODD1.14 ; JODD1.14 202.85,65.1 ; JODD1.14 201.05,65.1 ; JODD1.14 199.25,62.99 ; JODD1.14 199.25,65.1 ; JODD1.14 202.85,64.05 ; JODD1.14 199.25,64.05 ; JHDD1.24 178.87,121.11 ; JHDD1.24 180.13,118.13 ; JHDD1.24 180.58,119.39 ; JHDD1.24 177.15,119.39 ; JHDD1.24 177.61,120.65 ; JHDD1.24 180.13,120.65 ; JHDD1.24 178.87,117.68 ; JHDD1.24 177.61,118.13 ; JUSB1.12 6.74,19.21 ; JUSB1.12 6.74,18.33 ; JUSB1.12 3.9,19.21 ; JUSB1.12 3.9,18.33 ; JUSB1.12 5.32,18.33 ; JHDMI1.2 12.35,64.6 ; JHDMI1.2 11.43,65.52 ; JHDMI1.2 11.43,64.6 ; JHDMI1.2 11.89,64.48 ; JHDMI1.2 12.47,65.06 ; JHDMI1.2 12.35,65.52 ; JHDMI1.2 11.31,65.06 ; 1.42,17.15 JHP1.6 ; JHP1.6 1.42,17.93 ; JHP1.6 3.58,17.15 ; JHP1.6 2.5,17.93 ; JHP1.6 3.58,17.93 ; H8.1 2.8,105.63 ; H8.1 4.14,105.14 ; H8.1 4.63,103.8 ; H8.1 1.46,105.14 ; H8.1 0.97,103.8 ; JCRT1.7 6.89,115.21 ; JCRT1.7 6.89,114.55 ; JCRT1.7 6.89,115.88 ; H4.1 104.5,122.57 ; H4.1 102.98,122.01 ; H4.1 106.02,122.01 ; H4.1 102.98,118.96 ; H4.1 106.02,118.96 ; H4.1 102.42,120.48 ; H4.1 106.58,120.48 ; H4.1 104.5,118.4 ; 199.25,41.9 JODD1.15 ; JODD1.15 199.25,39.79 ; JODD1.15 202.85,40.85 ; JODD1.15 202.85,39.79 ; JODD1.15 201.05,39.79 ; JODD1.15 199.25,40.85 ; JODD1.15 201.05,41.9 ; JCRT1.5 6.89,122.57 ; JCRT1.5 6.05,123.89 ; JCRT1.5 6.89,123.89 ; JHDMI1.17 10.8,73.02 ; JHDMI1.17 10.8,72.1 ; JHDMI1.17 9.88,72.1 ; JHDMI1.17 10.92,72.56 ; JHDMI1.17 9.76,72.56 ; JHDMI1.17 9.88,73.02 ; 12.73,47.49 JUSB2.7 ; JUSB2.7 12.56,48.06 ; JUSB2.7 13.87,47.49 ; JUSB2.7 12.73,48.63 ; JUSB2.7 13.3,48.8 ; JUSB2.7 13.3,47.32 ; JUSB2.7 13.87,48.63 ; JUSB2.7 14.04,48.06 ; JBATT2.7 189.74,175.32 ; JBATT2.7 189.74,176.8 ; JBATT2.7 188.26,176.8 ; JBATT2.7 188.26,175.32 ; JBATT2.7 189,177.04 ; JBATT2.7 189,175.08 ; JBATT2.7 189.98,176.06 ; 5.32,39.33 JUSB2.12 ; JUSB2.12 3.9,39.33 ; JUSB2.12 6.74,39.33 ; JUSB2.12 3.9,40.21 ; JUSB2.12 6.74,40.21
  BOTTOM w0.102: C412.2 v3(14.59,126.72) ; v2(104,163.08) v3(104,163.83) ; v2(187.95,44.25) v3(189.14,44.25) ; v2(102.32,154.68) 102.18,154.68 v3(101.61,155.25) ; v2(91.68,128.99) v3(93.12,128.99) ; v2(133.7,9.05) v3(133.7,10.01) ; v3(10.02,107.1) C524.2 ; v2(29.26,6.4) v3(29.26,6.99) ; v2(184.1,113.13) v3(183.12,113.13) ; v2(12.17,128.64) v3(12.17,127.72) ; v4(32.26,99.52) v3(31.02,99.52)
  BOTTOM w0.178: UV1.AR5 148.05,153.07 147.25,153.07 UV1.AN6
  BOTTOM w0.203: UV1.B33 122.85,130.88 122.67,131.06 v2(122.28,131.06) ; UV1.AG2 v2(141.85,155.68) ; UV1.B11 122.83,148.5 121.79,148.5 v2(121.77,148.52) ; UV9.G1 126.99,165.19 126.99,165.94 UV10.G8 ; JCPU1.W3 JCPU1.W4 ; UV5.G1 112.78,130.79 112.61,130.79 112.6,130.79 112.25,130.79 112.24,130.79 112.24,130.79 112.08,130.79 UV6.G8
  BOTTOM w0.229: UV1.F25 124.85,136.86 125.23,136.48 125.23,136.3 125.25,136.28 125.25,135.82 125.24,135.8 125.24,135.79 v2(125.23,135.79) 124.91,135.47 UV1.F27
  BOTTOM w0.254: v2(135.35,155.15) 135.35,154.77 UV1.W2 ; UV12.P9 145.1,165.17 144.79,164.86 144.79,164.73 v2(144.77,164.7) ; UV5.P1 112.84,136.45 v2(113.24,136.85) ; UV1.AK7 144.34,151.87 144.08,152.13 v2(143.95,152.13) ; UV1.AK7 144.45,151.87 UV1.AL6 ; UV1.AK7 UV1.AL8 145.25,151.07 v2(145.65,150.68) UV1.AM9 ; UV5.M9 106.41,134.83 v2(105.83,134.83) ; UV1.F31 125.18,132.59 v2(125.18,132.63) ; UV1.K7 128.03,151.87 v2(127.63,152.28) 127.25,152.65 UV1.J6 ; v2(122.1,139.35) 122.57,138.87 UV1.B23 ; v2(144.92,146.65) 144.92,146.41 145.25,146.08 UV1.AL14 ; UV1.AG6 141.83,152.89 v2(141.83,153.12) ; v2(112.39,155.55) 111.98,155.14 UV7.E8 ; v2(121.66,135.35) 121.82,135.35 122.13,135.66 122.84,135.66 UV1.B27 ; UV1.Y39 136.25,127.05 v2(136.34,126.96) ; UV1.AD37 139.85,128.27 UV1.AE38 140.25,126.84 140.78,126.31 v2(140.89,126.31) ; v2(148.83,128.83) 149.25,128.4 UV1.AU37 ; v2(139.18,135.18) 138.85,134.86 UV1.AC28 138.67,134.67 138.08,134.08 138.08,133.57 v2(138.17,133.48) ; UV8.D8 107.16,155.92 v2(106.79,155.55) 107.18,155.15 UV7.E2 ; v2(122.34,142.2) 122.73,142.2 UV1.B19 ; UV1.AP7 UV1.AN6 ; UV1.AP7 147.65,151.85 147.29,151.49 147.27,151.49 UV1.AN8 UV1.AM9 ; UV1.AP7 147.93,151.87 v2(148.16,151.64) ; UV9.G9 126.94,171.57 v2(126.53,171.98) ; UV1.AE6 140.45,152.23 v2(140.39,152.16) ; 135.11,152.67 UV1.W6 ; 135.11,152.67 134.73,153.05 134.19,153.05 133.81,152.67 UV1.U6 ; 135.11,152.67 134.6,152.16 v2(134.42,152.16) ; UV10.E1 125.36,171.57 v2(124.94,171.98) 124.57,171.61 UV10.D1 ; UV5.E2 112.03,129.25 v2(112.43,128.85) 112.03,128.45 UV6.D8 ; UV1.AL34 144.95,129.57 v2(144.95,129.39) 145.26,129.07 UV1.AM35 ; UV1.B31 122.73,132.59 121.8,132.59 v2(121.68,132.47) ; UV1.AP16 147.99,144.34 v2(147.99,144.28) ; UV1.AL20 145.25,141 v2(144.86,140.6) ; v2(149.66,139.37) 149.95,139.67 UV1.AW22 ; UV6.F9 112.85,130.05 v2(113.22,130.42) 112.83,130.81 UV5.G1 ; v2(122.09,150.01) 122.79,150.01 UV1.B9 ; v2(136.89,153.02) 137.24,152.67 UV1.AA6 ; UV1.R6 132.05,152.23 v2(131.96,152.14) ; v2(147.15,143.02) 147.2,143.07 UV1.AP18 UV1.AP19 ; v2(122.4,154.93) 122.4,154.32 UV1.A3 ; UV9.M1 130.97,165.04 v2(131.3,164.71) ; UV1.F19 124.97,142.27 v2(125.26,141.98) ; v2(113.33,149.72) 113.13,149.52 UV7.M9 ; UV1.AM9 UV1.AN10 UV1.AP9 148.03,149.89 148.03,149.11 v2(147.98,149.05) 147.98,148.9 147.75,148.67 UV1.AP11 147.45,148.47 UV1.AN11 UV1.AM11 146.05,148.2 v2(145.71,147.86) 145.25,148.32 UV1.AL11 ; UV1.F21 124.85,140.16 125.38,139.63 v2(125.38,139.48) 125.38,139.29 124.85,138.76 UV1.F23 ; UV1.B21 122.8,140.42 122.71,140.42 v2(122.46,140.17) ; UV8.G8 107.18,153.53 106.39,153.53 UV7.G1 106.38,153.55 v2(105.99,153.95) 106.36,154.32 UV8.F9 ; UV1.AF10 140.85,149.47 v2(140.46,149.87) 140.05,150.27 UV1.AD9 ; v2(128.54,155.91) 128.54,155.71 128.96,155.29 128.96,154.77 UV1.L2 ; UV11.A9 155.5,171.57 v2(155.11,171.96) 154.71,171.57 UV12.B1 ; UV1.AK39 144.25,127.18 v2(143.98,126.91) ; UV11.F9 151.5,171.59 v2(151.13,171.96) 150.74,171.57 UV12.G1 150.71,171.56 150.71,170.77 UV11.G8 ; v2(130.57,155.19) 130.65,155.1 UV1.N2 ; v2(137.46,126.98) 137.85,127.38 UV1.AB39 ; v2(133.81,172.53) 133.93,172.53 134.25,172.22 134.25,171.65 UV9.T9 ; 113.16,155.55 112.78,155.17 UV8.E1 ; 113.16,155.55 UV8.D1 ; 113.16,155.55 v2(113.22,155.55) ; UV5.T9 v2(106.01,138.46) ; UV1.B29 122.64,133.86 121.92,133.86 v2(121.76,133.7) ; UV12.J2 149.1,170.79 v2(149.48,171.17) ; UV5.B1 112.86,126.85 v2(113.25,126.46) 112.83,126.05 UV6.A9 ; UV1.AL2 145.05,154.67 145.51,154.67 v2(145.54,154.65) 145.56,154.67 UV1.AN2 ; UV1.AJ6 143.5,152.82 v2(143.5,153.24) ; v2(139.11,155.45) 138.69,155.03 138.69,154.71 UV1.AC2 ; v2(127.57,146.63) 128.05,146.14 UV1.K14 ; UV10.D8 124.57,165.97 v2(124.97,165.57) 125.36,165.97 UV9.E2 ; UV1.AN19 146.71,142.62 146.7,142.62 146.47,142.85 v2(146.47,143.06) 146.47,143.33 146.81,143.67 UV1.AN17 ; UV12.P1 145.1,171.57 v2(144.69,171.99) ; v2(146.92,164.39) 146.92,164.7 146.7,164.92 UV12.M9 ; v2(144.06,140.58) 143.97,140.67 UV1.AH21 ; v2(121.85,127.84) 122.28,128.27 UV1.A37 ; UV1.H9 v2(126.05,149.87) ; UV9.B9 122.9,171.57 122.58,171.89 v2(122.58,171.99) ; UV11.B3 154.71,167.07 v2(154.91,167.28) ; UV1.B7 122.84,151.69 121.93,151.69 v2(121.76,151.85) ; v2(131.96,155.58) 132.1,155.45 132.1,154.82 UV1.R2 ; UV1.J27 v2(127.25,134.72) ; v2(125.24,149.05) 124.87,148.67 UV1.F11 ; v2(142.77,126.35) 142.65,126.47 UV1.AH39 ; UV12.M1 146.33,171.2 146.33,171.19 v2(146.3,171.16) ; UV1.L11 128.85,148.8 v2(128.51,149.15) ; UV10.A9 122.21,165.17 122.57,164.81 v2(122.57,164.72) 122.67,164.82 122.67,164.87 UV9.B1 ; UV1.F29 124.85,133.83 v2(124.53,133.51) ; v2(135.37,148.15) 135.4,148.18 135.4,148.41 135.14,148.67 UV1.V11 ; v2(121.98,137.47) 122.16,137.29 122.84,137.29 UV1.B25 ; UV1.AL32 145.24,131.47 v2(144.86,131.86) 144.45,132.26 UV1.AK31 ; v2(130.91,152.07) 130.45,152.53 UV1.N6 ; UV1.AW14 150.19,146.07 v2(150.48,145.79) ; v2(128.52,152.25) 128.85,152.58 UV1.L6 ; v2(123.77,153.84) 124.12,153.49 124.12,153.4 UV1.E5 ; UV1.T11 132.39,148.21 v2(132.39,148.16) ; v2(128.16,171.17) 128.56,170.77 UV9.J8 ; v2(130.65,172.18) 130.97,171.87 UV9.M9 ; v2(126.09,152.3) 126.02,152.3 UV1.G6 UV1.F7 ; UV7.J2 107.16,151.92 v2(106.78,152.3) ; UV1.AW20 150.43,141.27 v2(150.58,141.42) ; v2(122.85,144.17) 122.85,144.17 UV1.B17 ; UV1.AV17 150.37,143.67 v2(150.43,143.73) 150.48,143.78 150.48,144.05 UV1.AW16 ; v2(143.56,155.81) 143.47,155.71 143.47,154.68 UV1.AJ2 ; UV5.E8 107.23,129.25 v2(107.63,128.85) ; v2(144.83,147.88) 144.45,148.26 UV1.AK11 UV1.AJ11 143.45,148.67 UV1.AJ10 ; v2(125.52,145.44) 124.88,145.44 UV1.F15 ; v2(124.46,149.88) 124.85,150.27 UV1.F9 ; UV12.E2 152.31,170.77 v2(152.7,171.16) 153.1,170.77 UV11.D8 ; v2(150.55,138.25) 150.38,138.07 UV1.AW24 ; v2(125.74,155.67) 125.85,155.56 UV1.G2 ; UV9.P9 132.57,171.6 v2(132.94,171.98) ; UV7.T1 106.37,146.32 105.98,146.71 v2(105.98,146.71) ; v2(112.41,147.53) 112.38,147.53 112.38,147.58 112.71,147.92 UV7.P9 ; UV1.U2 133.84,154.67 133.56,154.96 v2(133.56,155.05) ; v2(124.48,144.23) 124.79,143.92 124.8,143.92 UV1.F17 ; v2(125.13,146.67) 125.13,146.8 UV1.F13 124.81,147.03 124.07,147.03 123.83,147.26 123.24,147.26 UV1.B13 ; UV11.D1 153.1,165.13 v2(152.73,164.76) 152.32,165.17 UV11.E1 ; v2(148.06,126.92) 148.35,127.21 UV1.AR39 ; v2(151.13,164.79) 150.76,165.17 UV12.G9 ; v2(154.71,164.6) UV12.B9 ; UV12.T1 143.52,171.57 143.92,171.97 v2(143.92,171.98) ; UV1.AL26 145.27,136.49 v2(145.27,137.08) ; UV9.G1 126.96,165.17 v2(126.57,164.77) 126.17,165.17 UV10.F9 ; v2(106.05,130.42) 106.43,130.8 UV5.G9 ; v2(140.54,130.37) 140.45,130.28 UV1.AE34 ; UV1.AC13 UV1.AB12 137.85,147.84 138.69,148.67 UV1.AC11 138.85,148.71 v2(139.28,149.13) ; v2(145.63,132.66) 146.01,132.27 UV1.AM31 UV1.AN32 ; UV1.B15 122.29,145.27 v2(122.12,145.44) ; v2(140.92,126.92) 140.92,127.33 UV1.AF39 ; v2(141.76,149.87) 142.16,150.27 UV1.AG9 ; UV1.C39 UV1.E39 124.24,127.47 v2(124.64,127.87) 124.62,127.89 124.62,128.71 UV1.E35 UV1.F34 ; UV7.B1 106.38,157.53 v2(105.98,157.93) 106.36,158.32 UV8.A9 ; v2(134.33,164.63) 134.33,165.01 UV9.T1 ; v2(140.53,155.08) 140.25,154.81 UV1.AE2 ; UV5.T1 113.23,138.45 v2(113.23,138.45) ; UV1.AV27 150.16,135.67 v2(150.2,135.71) 150.2,136.33 UV1.AW26 ; 133.19,163.79 v2(133.19,164.64) 132.65,165.17 UV9.P1 ; v2(128.23,165.56) 128.23,165.59 128.57,165.93 UV9.J2 ; UV12.J8 149.5,166.37 149.53,166.37 v2(149.54,166.38) ; v2(111.57,152.36) 111.59,152.35 111.59,152.32 UV7.J8 ; v2(108.54,126.61) 108.31,126.85 UV6.B3 ; v2(106,126.46) 106.1,126.46 106.43,126.78 UV5.B9 ; UV1.AW32 UV1.AW30 150.05,134.12 v2(150.6,134.67) ; v2(110.67,157.71) 110.85,157.52 UV8.B3 ; UV12.E8 152.32,165.97 v2(152.7,165.59) ; UV5.J2 112.03,132.42 112.41,132.04 v2(112.43,132.04) ; UV7.B9 113.18,157.52 v2(113.32,157.67) ; v2(143.07,164.82) 143.08,164.82 143.08,164.84 143.41,165.17 UV12.T9 ; v2(106.76,149.12) 106.76,149.15 UV7.M1 ; UV1.J2 127.1,155.03 127.1,155.48 v2(127.07,155.51) ; v2(147.31,144.29) 147.31,144.21 UV1.AP17 148.45,143.07 UV1.AR18 ; UV7.T9 112.93,146.17 v2(113.32,146.17) ; UV1.AJ33 143.43,130.67 v2(142.98,131.12) ; v2(122.71,169.43) 122.97,169.69 UV10.B3 ; v2(106.83,136.05) 106.43,136.45 UV5.P9 ; UV6.E1 106.43,129.23 v2(106.01,128.82) 106.39,128.45 UV6.D1 ; v2(106.82,132.03) 107.23,132.44 UV5.J8 ; v2(138.32,153.09) 138.32,153.09 138.32,153.1 138.74,152.67 UV1.AC6 ; UV9.E8 125.36,170.77 v2(124.96,171.17) ; v2(137.11,155.68) 137.07,155.64 137.07,154.68 UV1.AA2 ; v2(144.12,134.73) 144.12,134.72 143.87,134.47 UV1.AJ28 ; v2(146.87,129.25) 146.87,129.86 UV1.AN34 ; UV7.P1 106.38,147.92 v2(105.96,147.51) ; UV1.AD35 139.3,129.07 v2(139.01,129.36) 138.85,129.52 UV1.AC34 ; v2(147.45,126.93) UV1.AP39 147.05,127.87 UV1.AN38 ; v2(113.16,153.95) 112.78,153.57 UV7.G9
  BOTTOM w0.305: v2(55.04,109.41) 55.51,109.88 JCPU1.AL31 55.51,109.96 v2(55.06,110.4) ; v2(58.04,88.41) 58.51,87.94 JCPU1.AH9 ; JCPU1.N3 73.51,81.94 v2(74.04,81.41) ; v2(129.92,126.94) 129.85,127.01 UV1.M39 ; JCPU1.AK30 JCPU1.AK29 56.51,107.89 v2(56.98,107.42) ; JCPU1.AL18 55.51,97.02 v2(55.91,97.42) 55.51,97.82 JCPU1.AL19 ; 70.03,82.42 v2(70.04,82.42) ; 70.03,82.42 70.51,81.94 JCPU1.T3 ; 70.03,82.42 70.03,82.42 70.51,82.91 JCPU1.T4 ; v2(59.04,89.41) 59.51,89.88 JCPU1.AG11 ; v2(77.01,108.44) 76.51,107.95 JCPU1.K29 76.56,107.94 77.51,106.99 JCPU1.J28 ; 82.51,97.94 v2(82.96,98.4) 83.42,97.94 JCPU1.C19 83.59,97.94 v2(84.06,98.41) 84.51,97.95 JCPU1.B19 84.54,97.94 v2(85.01,98.41) 85.48,97.94 JCPU1.A19 ; 82.51,97.94 JCPU1.D19 ; 82.51,97.94 82.51,97.99 v2(82.02,98.47) 81.51,97.96 ; v2(63.04,108.41) 63.51,107.94 JCPU1.AC29 ; JCPU1.AN4 53.51,82.88 v2(53.04,82.41) ; v2(53.02,105.45) 52.53,105.94 JCPU1.AP27 52.51,105.94 JCPU1.AR28 ; JCPU1.A27 v2(86.2,105.94) ; JCPU1.T1 70.51,79.91 v2(71.04,79.38) ; JCPU1.AR7 51.51,85.92 51.03,85.44 50.52,85.94 JCPU1.AT7 ; JCPU1.R32 71.51,110.94 v2(70.9,111.55) 70.51,111.94 JCPU1.T33 ; JCPU1.AR26 51.51,104.88 v2(51.04,104.41) 51.51,103.94 JCPU1.AR25 ; JCPU1.AN24 53.52,102.94 v2(54.03,103.46) 54.51,103.93 JCPU1.AM25 ; JCPU1.AA25 65.51,103.94 v2(65.04,104.41) ; JCPU1.AE25 61.51,103.94 v2(61.04,104.41) ; v2(61.04,110.41) 61.51,109.94 JCPU1.AE31 ; v2(50.04,109.41) 50.51,108.94 JCPU1.AT30 ; JCPU1.K4 76.51,82.94 v2(77.04,82.41) ; JCPU1.H6 78.51,84.94 v2(78.04,85.41) 78.51,85.88 JCPU1.H7 ; v2(80.04,81.41) 79.97,81.41 79.5,80.94 79.5,80.94 79.52,80.94 79.71,80.75 79.71,80.31 79.51,80.11 JCPU1.G1 ; v2(55.04,94.41) 55.51,93.94 JCPU1.AL15 55.59,93.86 55.59,93.02 JCPU1.AL14 ; v2(61.04,108.41) 61.51,107.94 JCPU1.AE29 ; UV1.F39 125.07,127.46 125.07,127.01 v2(124.98,126.92) ; v2(86.33,110.14) 86.13,109.94 JCPU1.A31 ; JCPU1.AM23 54.56,101.94 v2(55.06,101.44) ; UV1.J8 127.25,151.08 v2(126.87,151.47) ; JCPU1.AM32 54.52,110.94 v2(55.06,110.4) ; 79.99,109.48 79.53,109.94 JCPU1.G31 ; 79.99,109.48 80.51,108.96 JCPU1.F30 ; 79.99,109.48 v2(80,109.48) ; v2(58.04,83.41) 58.51,82.94 JCPU1.AH4 ; JCPU1.AG6 59.51,84.88 v2(59.04,84.41) ; JCPU1.B34 84.43,112.94 v2(83.98,113.4) ; JCPU1.AT32 v2(49.88,110.94) ; v2(57.04,83.41) 57.51,83.88 JCPU1.AJ5 ; JCPU1.AC11 JCPU1.AD11 62.51,89.88 v2(62.04,89.41) ; JCPU1.AE27 61.51,105.94 v2(61.04,106.41) ; v2(86.04,89.41) 85.57,88.94 JCPU1.A10 85.51,88.94 v2(85.04,89.41) 84.57,88.94 JCPU1.B10 84.51,88.94 v2(84.04,89.41) 83.57,88.94 JCPU1.C10 83.51,88.94 v2(83.04,89.41) 82.57,88.94 JCPU1.D10 82.5,88.94 v2(82.02,89.42) 82.04,89.42 81.56,88.94 JCPU1.E10 81.51,88.94 v2(81.06,89.39) 80.62,88.94 JCPU1.F10 80.69,88.76 80.69,88.12 80.51,87.94 JCPU1.F9 80.63,87.83 80.63,87.06 JCPU1.F8 ; v2(76.04,114.41) 76.51,113.94 JCPU1.K35 ; JCPU1.AL1 55.51,79.96 v2(55.05,80.42) 55.51,80.88 JCPU1.AL2 ; JCPU1.AL17 55.51,95.88 v2(55.04,95.41) ; v2(50.08,88.41) 50.51,88.84 JCPU1.AT10 ; JCPU1.N10 73.51,88.94 v2(74.04,88.41) 73.57,87.94 JCPU1.N9 ; v2(50.04,100.41) 50.51,99.94 JCPU1.AT21 ; 53.51,88.94 53.51,88.94 53.5,88.92 52.52,88.92 52.51,88.94 JCPU1.AP10 ; 53.51,88.94 v2(54.04,88.41) 54.51,88.88 JCPU1.AM10 ; 53.51,88.94 JCPU1.AN10 ; JCPU1.R28 71.51,106.94 v2(71.04,107.41) 70.51,107.94 JCPU1.T29 ; v2(54.04,82.41) 54.51,82.88 JCPU1.AM4 ; v2(53.04,91.41) 53.51,91.88 JCPU1.AN13 ; JCPU1.P26 72.5,104.94 v2(72.04,105.4) ; JCPU1.D31 82.52,109.94 83.01,109.45 ; v2(58.04,82.41) 58.51,81.94 JCPU1.AH3 ; v2(83.01,109.44) 83.01,109.45 ; 83.01,109.45 83.51,108.95 JCPU1.C30 ; JCPU1.AP7 52.51,85.91 v2(52.01,85.41) ; JCPU1.T7 70.51,85.94 v2(71.04,85.41) 70.57,84.94 JCPU1.T6 ; v2(55.06,101.44) 55.51,100.99 JCPU1.AL22 ; v2(55.06,101.44) 55.51,101.89 JCPU1.AL23 ; JCPU1.AN7 53.51,85.91 v2(53.01,85.41) ; JCPU1.AL3 55.51,81.88 v2(55.04,81.41) ; JCPU1.AR22 51.51,100.89 v2(51.03,100.42) ; JCPU1.F19 80.51,97.98 v2(81.01,98.47) 81.51,97.97 81.51,97.96 ; v2(64.04,79.41) 64.51,79.88 JCPU1.AB1 ; 81.51,97.96 JCPU1.E19 ; v2(126.65,126.96) UV1.H39 ; v2(71.04,88.41) 70.51,88.94 JCPU1.T10 ; v2(67.18,112.45) 67.51,112.12 JCPU1.W33 ; v2(56.04,83.46) 56.51,83.93 JCPU1.AK5 ; v2(134.78,126.94) 134.78,127.35 UV1.V39 ; v2(79,104.39) 78.51,104.88 JCPU1.H26 JCPU1.J26 ; JCPU1.H11 78.61,89.94 v2(79.04,90.38) ; v2(49.84,112.94) JCPU1.AT34 JCPU1.AR34 ; JCPU1.AP4 52.51,82.88 v2(52.04,82.41) ; JCPU1.AR4 51.51,82.88 v2(51.04,82.41) ; JCPU1.AK11 JCPU1.AL11 55.51,89.88 v2(55.04,89.41) 55.51,88.94 JCPU1.AL10 ; JCPU1.AN16 53.51,94.94 v2(54.01,94.44) 54.51,94.94 JCPU1.AM16 ; v2(56.04,107.41) 56.51,106.94 JCPU1.AK28 ; v2(69.04,89.41) 68.51,89.94 JCPU1.V11 ; JCPU1.A7 85.41,85.94 v2(84.93,86.42) 84.51,86.01 JCPU1.B7 84.51,85.94 v2(84.04,86.41) 83.57,85.94 JCPU1.C7 83.51,85.94 v2(83.04,86.41) 82.57,85.94 JCPU1.D7 82.51,85.94 v2(82.04,86.41) 81.57,85.94 JCPU1.E7 81.47,85.94 v2(81.01,86.41) 80.54,85.94 JCPU1.F7 JCPU1.F6 ; v2(61.04,114.41) 61.51,113.94 JCPU1.AE35 ; v2(65.04,108.41) 65.51,107.94 JCPU1.AA29 ; JCPU1.T26 70.51,104.97 v2(70.04,105.44) 69.54,105.94 JCPU1.U27 69.51,105.97 v2(68.94,106.54) 68.54,106.94 JCPU1.V28 ; JCPU1.AT16 50.62,94.84 51.4,94.84 JCPU1.AR16 51.57,94.94 v2(52.04,94.47) 52.51,94.94 JCPU1.AP16 52.51,94.95 v2(53.02,95.47) ; v2(79.97,112.42) 79.51,111.96 JCPU1.G33 79.6,111.94 80.51,111.03 JCPU1.F32 ; JCPU1.AJ11 57.51,89.94 v2(58.04,89.41) 58.51,88.94 JCPU1.AH10 ; v2(61.04,89.41) 61.51,88.94 JCPU1.AE10 ; JCPU1.M11 74.51,89.94 v2(75.04,89.41) ; JCPU1.AL8 55.51,86.94 v2(55.04,87.41) ; v2(68.04,109.41) 68.51,108.94 JCPU1.V30 ; JCPU1.AG25 59.51,103.94 v2(59.04,104.41) ; v2(77.04,81.41) 76.51,81.94 JCPU1.K3 ; JCPU1.AR10 51.51,88.94 v2(52.04,88.41) ; v2(54.04,85.41) 54.51,85.88 JCPU1.AM7 ; JCPU1.A29 86.24,107.94 v2(86.36,108.07) ; JCPU1.AL21 55.51,99.94 v2(55.04,100.41) 54.51,100.94 JCPU1.AM22 ; JCPU1.D29 82.52,107.94 83.04,107.42 ; v2(64.04,85.41) 64.51,84.94 JCPU1.AB6 ; JCPU1.T35 70.51,113.8 v2(70.91,113.4) 71.36,112.94 JCPU1.R34 ; v2(51.04,91.41) 51.51,91.88 JCPU1.AR13 ; v2(52.02,114.4) 52.48,113.94 JCPU1.AP35 JCPU1.AP34 JCPU1.AN34 ; v2(55.06,110.4) 55.6,110.94 ; 55.6,110.94 JCPU1.AL32 ; 55.6,110.94 JCPU1.AK32 ; v2(55.04,86.41) 55.51,85.94 JCPU1.AL7 ; JCPU1.G29 79.53,107.94 v2(79.98,107.49) 80.51,106.96 JCPU1.F28 ; v2(74.04,85.41) 73.51,85.94 JCPU1.N7 ; JCPU1.G27 79.51,105.93 v2(80.06,105.38) 80.5,104.94 JCPU1.F26 80.55,104.94 v2(81.08,104.4) 81.51,103.98 JCPU1.E25 ; JCPU1.AR31 51.03,110.42 v2(50.99,110.42) ; v2(58.97,108.4) 59.44,107.94 JCPU1.AG29 ; v2(82.04,83.41) 81.57,82.94 JCPU1.E4 ; JCPU1.T9 70.51,87.94 v2(71.04,87.41) ; v2(77.11,85.48) 77.11,85.38 77.51,84.98 JCPU1.J6 ; JCPU1.AB10 64.51,88.88 v2(64.04,88.41) 64.51,87.94 JCPU1.AB9 ; JCPU1.AC33 63.51,111.94 v2(63.04,112.41) ; v2(70.04,89.41) 69.51,89.94 JCPU1.U11 ; JCPU1.AE1 61.51,79.94 v2(61.04,80.41) ; JCPU1.C34 83.43,112.94 v2(82.98,113.4) 82.51,113.86 JCPU1.D35 ; v2(80,83.62) 79.68,83.94 JCPU1.G5 ; JCPU1.R11 71.51,89.94 v2(72.04,89.41) ; JCPU1.AT33 v2(49.82,111.94) ; JCPU1.AE4 61.51,82.88 v2(61.04,82.41) 61.51,81.94 JCPU1.AE3 ; JCPU1.L26 74.99,105.46 v2(74.91,105.46) 74.51,105.06 JCPU1.M26 ; v2(50.03,82.39) 50.51,82.87 JCPU1.AT4 ; JCPU1.AN21 53.51,99.94 v2(54.04,99.41) 54.51,98.94 JCPU1.AM20 ; v2(50.04,97.41) 50.51,97.88 JCPU1.AT19 ; JCPU1.A33 86.15,111.94 v2(86.41,112.19) ; JCPU1.AM24 54.53,102.94 v2(55.02,103.43) 55.5,102.94 JCPU1.AL24 ; v2(65.01,114.41) 65.48,113.94 JCPU1.AA35 ; v2(72.97,107.39) 73.51,107.93 JCPU1.N29 JCPU1.M30 ; JCPU1.F4 80.6,82.94 v2(81.02,83.36) ; JCPU1.AA27 65.51,105.94 v2(65.04,106.41) ; JCPU1.AK25 56.51,103.94 v2(56.04,104.41) 56.51,104.88 JCPU1.AK26 ; JCPU1.AH6 58.51,84.94 v2(58.04,85.41) 58.51,85.88 JCPU1.AH7 ; v2(68.04,89.43) 67.55,88.94 JCPU1.W10 ; JCPU1.AC35 63.51,113.94 v2(63.04,114.41) ; JCPU1.K7 76.57,85.94 v2(77.04,86.41) 77.04,86.41 JCPU1.K8 ; JCPU1.N2 73.51,80.94 v2(74.04,80.41) 73.57,79.94 JCPU1.N1 ; v2(82.04,80.41) 81.57,79.94 JCPU1.E1 ; JCPU1.AR19 51.51,97.88 v2(51.04,97.41) ; JCPU1.AB4 64.51,82.88 v2(64.04,82.41) 64.51,81.94 JCPU1.AB3 ; 83.04,107.42 83.51,106.95 JCPU1.C28 ; 83.04,107.42 v2(83.04,107.4) ; v2(63.04,104.41) 63.51,103.94 JCPU1.AC25 ; JCPU1.A22 85.51,100.94 v2(85.04,101.41) 84.58,100.94 JCPU1.B22 84.48,100.94 v2(84.02,101.41) 83.55,100.94 JCPU1.C22 83.39,100.94 v2(83,101.33) 82.61,100.94 JCPU1.D22 82.39,100.82 81.64,100.82 81.52,100.94 JCPU1.E22 JCPU1.F21 80.55,99.94 v2(81.07,99.43) 80.59,98.94 JCPU1.F20 ; JCPU1.K2 76.51,80.94 v2(77.04,80.41) ; JCPU1.R5 71.57,83.94 v2(72.04,84.41) 72.51,83.94 JCPU1.P5 ; v2(50,106.4) 50.45,105.94 JCPU1.AT27 ; JCPU1.AH5 58.51,83.94 v2(58.04,84.41) ; JCPU1.E16 81.6,94.94 v2(82.02,95.36) 82.44,94.94 JCPU1.D16 82.57,94.94 v2(82.99,95.36) 83.41,94.94 JCPU1.C16 83.58,94.94 v2(84,95.37) 84.43,94.94 JCPU1.B16 84.59,94.94 v2(85.04,95.4) 85.49,94.94 JCPU1.A16 ; JCPU1.AA11 65.51,89.94 v2(66.04,89.41) 66.51,89.88 JCPU1.Y11 ; JCPU1.AL6 55.51,84.94 v2(55.04,85.41) ; v2(59.04,112.41) 59.51,111.94 JCPU1.AG33 ; JCPU1.L6 75.51,84.88 v2(75.04,84.41) 74.51,84.94 JCPU1.M6 ; JCPU1.AP19 52.51,97.94 v2(53.04,97.41) 53.51,97.88 JCPU1.AN19 ; JCPU1.D33 82.52,111.94 v2(83.04,111.43) 83.51,110.96 JCPU1.C32 ; v2(65.04,110.41) 65.51,109.94 JCPU1.AA31 ; v2(70,110.5) 70,110.46 JCPU1.T31 ; v2(68.04,83.41) 67.57,82.94 JCPU1.W4 ; v2(68.04,88.47) 67.51,87.94 JCPU1.W9 ; v2(77.98,113.41) 77.51,112.94 JCPU1.J34 ; JCPU1.AN2 JCPU1.AP1 52.51,79.89 v2(52.98,79.42) ; JCPU1.D25 v2(83.05,103.4) 83.51,102.94 JCPU1.C24 ; JCPU1.F12 80.58,90.94 v2(81.06,91.42) 81.51,91.88 JCPU1.E13 81.59,91.94 v2(82.05,92.41) 82.51,91.95 JCPU1.D13 82.61,91.94 v2(83.04,92.37) 83.47,91.94 JCPU1.C13 83.57,91.94 v2(84.04,92.41) 84.51,91.94 JCPU1.B13 84.57,91.94 v2(85.04,92.41) 85.51,91.94 JCPU1.A13 85.57,91.94 v2(86.04,92.41) ; JCPU1.AC27 63.51,105.94 v2(63.04,106.41) ; v2(53.04,109.41) 53.51,108.94 JCPU1.AN30 ; JCPU1.AL5 55.51,83.94 v2(55.04,84.41) ; JCPU1.C26 83.48,104.94 v2(83.04,105.38) 82.51,105.91 JCPU1.D27 ; JCPU1.AC31 63.51,109.94 v2(63.04,110.41) ; JCPU1.F14 80.51,93.02 v2(80.91,93.42) 80.51,93.82 JCPU1.F15 ; JCPU1.N5 73.51,83.94 v2(74.04,83.41) ; v2(74.04,84.41) 73.51,84.94 JCPU1.N6 ; v2(84.04,81.41) 84.51,80.94 JCPU1.B2 ; v2(86.09,82.42) 85.61,81.94 JCPU1.A3 ; JCPU1.W1 67.57,79.94 v2(68.04,80.41) ; JCPU1.V32 68.51,110.87 v2(68.05,110.41) ; v2(72.04,88.41) 71.51,88.94 JCPU1.R10 ; JCPU1.A25 v2(86.18,103.94) ; v2(83.04,83.41) 82.57,82.94 JCPU1.D4 ; v2(61.04,112.41) 61.51,111.94 JCPU1.AE33 ; JCPU1.K31 76.52,109.94 v2(77.01,109.46) 77.51,108.95 JCPU1.J30 ; UV1.P39 v2(131.45,126.97) ; JCPU1.J11 77.51,89.88 v2(77.04,89.41) 76.57,88.94 JCPU1.K10 ; v2(144.89,139.43) 144.89,139.24 UV1.AL23 ; v2(73.96,112.49) 73.51,112.05 JCPU1.N33 ; JCPU1.AH8 58.51,86.94 v2(58.04,87.41) ; JCPU1.AE9 61.51,87.94 v2(61.04,88.41) ; JCPU1.AK34 56.51,112.94 v2(56.04,113.41) ; JCPU1.V10 68.51,88.94 v2(69.04,88.41) ; UV1.T39 133.05,127.08 v2(133.15,126.98) ; JCPU1.AL20 55.51,98.94 v2(55.04,99.41) 54.51,99.94 JCPU1.AM21 ; v2(77.04,83.41) 76.51,83.94 JCPU1.K5 ; v2(54.04,91.41) 54.51,91.88 JCPU1.AM13 ; JCPU1.AL4 55.51,82.88 v2(55.04,82.41) ; JCPU1.R26 71.04,105.41 v2(71.04,105.41) ; v2(54.03,105.44) 53.53,105.94 JCPU1.AN27 ; JCPU1.AG35 59.51,113.94 v2(59.04,114.41) ; JCPU1.F34 80.43,112.94 v2(79.97,113.41) 79.51,113.86 JCPU1.G35 ; v2(58.04,80.41) 58.51,79.94 JCPU1.AH1 ; JCPU1.M28 74.51,106.93 v2(75.01,106.42) ; JCPU1.W6 67.51,84.96 v2(68.04,85.49) 67.59,85.94 JCPU1.W7 ; v2(72,108.57) 71.64,108.94 JCPU1.R30 ; JCPU1.AR2 51.51,80.88 v2(51.04,80.41) ; v2(52.04,91.41) 52.51,91.88 JCPU1.AP13 ; v2(69.01,112.45) 68.52,112.94 JCPU1.V34 ; JCPU1.M32 74.5,110.94 73.97,110.41 73.97,110.4 JCPU1.N31 73.51,109.94 v2(72.93,109.36) ; JCPU1.P11 72.51,89.94 v2(73.04,89.41) ; v2(58.04,81.41) 58.51,80.94 JCPU1.AH2 ; v2(49.87,102.94) JCPU1.AT24 ; JCPU1.F11 80.44,89.94 v2(80.03,90.35) 79.62,89.94 JCPU1.G11 ; JCPU1.K9 76.57,87.94 v2(77.04,88.41) ; v2(76.04,89.41) 75.51,89.94 JCPU1.L11 ; JCPU1.AG31 59.48,109.94 v2(59.01,110.41) ; JCPU1.F18 80.51,96.86 v2(80.97,96.41) 80.51,95.95 JCPU1.F17 ; v2(54.04,97.41) 54.51,97.88 JCPU1.AM19 ; v2(50.04,91.41) 50.51,91.88 JCPU1.AT13 ; v2(60.04,84.41) 60.51,84.88 JCPU1.AF6 ; JCPU1.C4 83.57,82.94 v2(84.04,83.41) 84.51,82.94 JCPU1.B4 ; v2(58.99,106.45) 59.49,105.94 JCPU1.AG27 ; JCPU1.M34 74.39,112.94 v2(73.95,113.38) 73.51,113.82 JCPU1.N35 ; v2(60.04,89.41) 60.51,89.88 JCPU1.AF11 ; JCPU1.AT3 50.46,81.94 49.96,81.44 v2(49.96,81.44) ; JCPU1.F24 80.51,102.89 v2(80.99,102.41) 80.98,102.41 JCPU1.F23 ; UV1.K39 128.25,127.24 v2(128,126.98) ; v2(77.04,79.41) 76.51,79.94 JCPU1.K1 ; JCPU1.AL9 55.51,87.94 v2(55.04,88.41) ; JCPU1.AL12 55.51,90.9 v2(55.04,90.42) ; v2(64.96,86.4) 64.51,85.95 JCPU1.AB7 ; v2(86.09,83.42) 85.61,82.94 JCPU1.A4 ; v2(63.04,86.41) 62.57,85.94 JCPU1.AD7 ; JCPU1.C2 83.51,80.94 v2(84.04,80.41) 83.57,79.94 JCPU1.C1 ; v2(79.04,89.41) 78.57,88.94 JCPU1.H10 ; JCPU1.AE7 61.51,85.88 v2(61.04,85.41) 61.51,84.94 JCPU1.AE6 ; v2(74.04,82.41) 73.51,82.94 JCPU1.N4 ; v2(65.04,112.41) 65.51,111.94 JCPU1.AA33 ; JCPU1.J32 77.51,110.94 v2(76.97,111.49) 76.51,111.94 JCPU1.K33 ; JCPU1.W35 v2(67.51,114.6) ; JCPU1.W25 67.51,103.97 v2(66.99,104.49)
  BOTTOM w0.33: UV1.M22 129.74,139.79 128.97,139.79 UV1.L22
  BOTTOM w0.356: JDIMM2.32 43.81,39.35 v2(44.56,40.1) ; JDIMM2.167 86.72,45.62 87.04,45.95 v2(87.74,45.95) ; v2(48.06,59.28) 48.52,59.28 48.92,58.89 JDIMM1.49 ; v2(51.49,55.15) 50.72,55.92 JDIMM1.55 ; JDIMM2.128 75.02,34.02 v2(76.47,32.56) ; JCPU1.AF8 60.51,86.88 v2(60.04,86.41) ; JDIMM2.20 40.22,34.89 v2(41.03,34.08) ; v2(86.94,59.71) 85.87,59.71 84.94,58.78 84.91,58.78 ; JDIMM2.31 43.52,44.58 43.52,45.67 43.15,46.04 v2(41.95,46.04) 40.46,46.04 39.92,45.5 JDIMM2.19 ; JDIMM2.55 50.72,45.65 51.1,46.04 v2(52.08,46.04) 52.7,46.04 53.12,45.62 53.12,44.58 JDIMM2.63 ; JDIMM1.190 93.62,50.44 v2(94.9,51.72) ; v2(78.04,46.2) 76.77,46.2 76.51,45.95 JDIMM2.133 ; JDIMM1.26 42.02,51.15 41.07,52.1 v2(40.91,52.1) ; 87.76,47.91 87.62,48.05 JDIMM1.170 ; 87.76,47.91 87.17,47.91 87.02,48.06 JDIMM1.168 ; 87.76,47.91 v2(87.78,47.91) ; JDIMM1.172 88.21,50.67 88.36,50.81 88.36,51.25 v2(87.78,51.82) ; JDIMM1.20 40.22,50.51 39.97,50.75 39.97,51.89 v2(38.24,53.62) ; JDIMM1.134 76.8,49.37 76.8,48.25 76.56,48.01 75.28,48.01 75.02,48.27 JDIMM1.128 75.02,50.76 v2(75.14,50.88) ; JDIMM1.71 55.52,56.3 56.03,55.78 56.03,54.43 55.5,53.9 54.82,53.9 v2(54.54,53.62) 55.81,52.35 JDIMM1.72 ; v2(37.57,34.44) 37.68,34.44 38.41,35.17 JDIMM2.14 ; JDIMM1.195 95.12,58.82 v2(95.32,59.03) 95.56,59.03 95.72,58.87 JDIMM1.197 ; JDIMM1.63 53.11,55.88 v2(52.76,55.53) 52.52,55.77 JDIMM1.61 ; JDIMM2.54 50.41,37.44 50.72,37.75 v2(52.17,37.75) ; v2(79.03,42.05) 79.03,42.46 78.32,43.18 JDIMM2.139 ; JDIMM1.65 53.72,55.97 v2(54.54,55.15) ; JDIMM1.13 38.11,59.32 v2(38.34,59.54) ; v2(94.74,46.82) 95,46.82 95.72,46.11 JDIMM2.197 ; JDIMM1.139 78.32,56.59 79.48,55.42 v2(79.48,55.23) ; JDIMM2.155 83.12,43.53 83.67,42.97 83.67,41.18 v2(82.64,40.15) ; v2(86.98,34.08) 87.62,34.71 JDIMM2.170 ; v2(89.66,42.05) 89.66,42.42 88.51,43.57 JDIMM2.173 ; JDIMM1.66 54.02,50.72 53.8,50.93 53.8,51.36 v2(54.54,52.1) ; JDIMM1.162 v2(85.21,47.93) ; v2(96.17,52.1) 96.74,51.53 96.74,51.16 96.37,50.79 95.77,50.79 95.42,50.44 JDIMM1.196 ; JDIMM1.178 90.02,48.23 90.26,47.99 v2(90.44,47.99) 91.53,47.99 91.82,48.27 JDIMM1.184 ; JDIMM1.156 83.42,50.4 83.56,50.55 83.56,51.36 83.14,51.78 v2(83.02,51.78) ; JDIMM2.150 81.62,35.45 81.96,35.1 81.96,34.62 v2(81.43,34.08) ; v2(51.69,34.46) 51.69,34.67 52.22,35.19 JDIMM2.60 ; JDIMM2.153 82.51,43.35 83.18,42.69 83.18,42.21 v2(82.64,41.67) ; v2(77.49,37.93) 77.28,37.93 76.81,37.47 JDIMM2.134 ; v2(51.49,52.1) 52.22,51.37 JDIMM1.60 ; JDIMM2.44 47.41,35.39 47.07,35.05 47.07,34.63 v2(47.63,34.08) ; v2(52.45,41.77) 51.91,42.31 51.91,42.75 52.52,43.35 JDIMM2.61 ; JDIMM1.145 80.12,58.59 79.62,59.08 77.67,59.08 v2(77.66,59.09) 76.83,59.09 76.51,58.78 JDIMM1.133 ; JDIMM1.14 38.41,48.07 v2(38.34,47.99) 36.92,46.57 JDIMM2.9 ; v2(92.36,53.63) 93.32,54.58 JDIMM1.189 ; 79.51,80.94 JCPU1.G2 ; JDIMM2.3 35.11,46.17 34.45,46.83 v2(33.75,46.83) ; 47.11,45.69 JDIMM2.43 47.11,43.67 45.85,42.41 v2(45.85,42.08) ; 47.11,45.69 47.46,46.04 48.68,46.04 48.92,45.8 JDIMM2.49 ; 47.11,45.69 46.81,46 45.65,46 45.32,45.66 JDIMM2.37 ; JDIMM1.187 92.72,58.76 v2(92.4,59.08) 92.12,58.8 JDIMM1.185 ; JDIMM2.28 42.62,35.22 42.41,35.02 42.41,34.42 42.75,34.08 v2(43.05,34.08) ; JDIMM1.11 37.52,56.44 37.51,56.44 37.51,55.88 v2(38.24,55.15) ; v2(93.46,34.84) 93.62,35 JDIMM2.190 ; v2(91.68,32.94) 92.23,33.49 92.23,34.46 91.82,34.88 JDIMM2.184 ; v2(85.26,46.29) 84.91,45.94 JDIMM2.161 ; v2(40.91,53.62) 39.92,54.62 JDIMM1.19 ; v2(43.05,32.56) 41.9,33.71 41.9,35.17 42.02,35.29 JDIMM2.26 ; JDIMM1.8 36.62,51.36 v2(36.97,51.72) ; JDIMM2.156 83.42,34.71 v2(83.17,34.46) ; JDIMM2.72 55.82,34.28 54.09,32.56 v2(53.82,32.56) ; JDIMM2.136 77.42,35.02 v2(76.47,34.08) ; v2(34.19,59.23) 34.8,59.23 35.11,58.91 JDIMM1.3 ; JDIMM2.145 80.12,43.67 80.89,42.89 80.89,42.21 v2(80.35,41.67) ; v2(40.91,55.15) 41.42,55.15 41.71,55.44 JDIMM1.25 ; 84.91,58.78 JDIMM1.161 ; 84.91,58.78 84.43,59.27 83.37,59.27 83.12,59.02 JDIMM1.155 ; U36.1 198.46,105.69 ; JDIMM2.65 53.72,45.73 54.06,46.08 55.3,46.08 v2(55.31,46.06) 55.52,45.86 JDIMM2.71 ; JDIMM1.43 47.11,56.57 47.55,56.14 47.55,55.91 v2(47.93,55.53) ; v2(79.01,32.56) 78.02,33.56 JDIMM2.138 ; JDIMM2.48 48.62,37.53 v2(48.84,37.76) 48.75,37.84 48.2,37.84 48.02,37.65 JDIMM2.46 ; JDIMM2.196 95.42,34.73 95.56,34.58 95.56,33.63 95.25,33.32 v2(94.95,33.32) ; JDIMM2.185 92.12,45.82 91.86,46.07 90.61,46.07 90.32,45.78 JDIMM2.179 90.32,43.59 90.93,42.98 91.22,42.98 91.49,42.71 91.49,42.23 v2(90.93,41.67) ; JDIMM1.32 43.81,50.58 43.45,50.95 43.45,52.83 v2(44.25,53.62) ; v2(89.4,32.56) 88.21,33.74 JDIMM2.172 ; v2(44.25,52.1) 45.62,50.73 JDIMM1.38 ; v2(46.53,53.62) 47.33,52.83 47.33,50.62 47.41,50.53 JDIMM1.44 ; JDIMM1.37 45.32,56.21 v2(44.25,55.15) ; JDIMM2.66 54.02,37.64 v2(53.74,37.91) ; v2(77.62,59.75) 75.86,59.75 74.72,58.61 JDIMM1.127 ; JDIMM1.201 96.91,59.48 97.2,59.77 v2(98.04,59.77) ; v2(89.4,34.08) 90.02,34.7 JDIMM2.178 ; v2(42.94,53.24) 42.62,52.92 JDIMM1.28 ; JDIMM2.151 81.92,45.76 v2(81.62,46.06) ; JDIMM1.173 88.51,58.73 89.15,59.36 90.49,59.36 v2(90.72,59.14) 90.72,59.01 90.32,58.61 JDIMM1.179 ; JDIMM2.189 93.32,45.66 93.01,45.96 v2(92.73,45.96) 92.72,45.95 JDIMM2.187 ; v2(35.27,32.53) 34.51,33.29 34.51,35.22 34.82,35.53 JDIMM2.2 ; JDIMM2.8 36.62,35.21 36.38,34.97 36.38,34.37 36.07,34.06 v2(35.27,34.06) ; JCPU1.G3 79.51,81.98 v2(80.03,82.5) 79.58,82.94 JCPU1.G4 ; v2(36.97,54) 36.91,54.06 36.91,56.52 36.92,56.52 JDIMM1.9 ; 51.03,85.44 v2(51.03,85.41) ; v2(84.7,34.08) 85.35,34.74 85.35,35.26 85.21,35.39 JDIMM2.162 ; v2(86.53,59.16) 86.71,58.98 86.71,57.59 JDIMM1.167 ; v2(49.2,53.62) 48.39,52.82 48.39,50.98 48.62,50.76 JDIMM1.48 ; JDIMM2.13 38.11,45.99 v2(38.14,46.02) 37.83,46.02 37.52,45.71 JDIMM2.11 ; v2(77.62,51.79) 77.85,51.79 78.24,51.39 78.24,50.85 78.02,50.63 JDIMM1.138 ; v2(94.74,46) 95.12,45.62 JDIMM2.195 ; JDIMM2.25 41.72,44.58 41.72,43.37 40.74,42.39 v2(40.74,42.05) ; JDIMM1.54 50.41,50.89 v2(49.2,52.1) ; JDIMM2.127 74.72,42.28 76.85,40.15 v2(77.3,40.15) ; v2(47.93,53.24) 47.85,53.16 47.85,50.76 48.02,50.6 JDIMM1.46 ; JDIMM1.150 v2(81.62,47.97) ; JDIMM2.168 87.02,36.38 87.02,37.56 87.4,37.94 v2(87.86,37.94) ; JDIMM1.144 79.81,48.24 79.41,47.83 v2(78.04,47.83) 77.42,48.46 JDIMM1.136 ; v2(42.94,55.53) 42.94,55.95 43.52,56.53 JDIMM1.31 ; v2(79.01,34.08) 79.81,34.88 JDIMM2.144 ; JDIMM2.38 45.62,39.55 v2(45.85,39.79) ; v2(83,54.83) 83.56,55.38 83.56,55.92 83.21,56.27 82.75,56.27 82.51,56.51 JDIMM1.153 82.51,58.6 82.39,58.73 82.04,58.73 81.92,58.6 JDIMM1.151 ; v2(34.9,52.1) 34.35,51.54 34.35,50.97 34.82,50.5 JDIMM1.2
  BOTTOM w0.381: UV1.R27 v2(132.35,135.17) ; UV1.L24 UV1.M24 129.88,137.67 130.85,136.7 UV1.N26 131.35,137.17 v2(131.35,137.2) 131.82,137.67 UV1.R24 v2(132.35,137.17) UV1.T26 133.23,137.05 v2(133.23,137.17) 133.35,137.17 UV1.U24 UV1.V26 135.2,137.02 v2(135.2,137.17) 135.35,137.17 UV1.Y24 136.35,137.17 v2(136.42,137.17) 136.42,137.11 UV1.AA26 137.28,137.1 v2(137.28,137.15) 137.29,137.15 137.32,137.17 137.35,137.17 UV1.AB24 138.35,137.17 v2(138.51,137.17) 138.51,137.01 UV1.AC26 139.01,136.67 v2(139.49,137.16) 139.85,137.52 UV1.AD24 ; UV1.U15 133.39,146.13 v2(133.35,146.13) 132.85,146.63 UV1.T13 ; UV1.U15 133.92,145.67 v2(134.42,145.17) 134.42,145.11 UV1.V16 134.85,144.85 135.16,145.16 v2(135.16,145.17) 135.66,145.67 UV1.Y15 v2(136.35,145.17) UV1.AA16 136.85,144.85 v2(137.19,145.18) 137.68,145.67 UV1.AB15 137.91,145.67 v2(138.43,145.15) 138.43,145.09 UV1.AC16 138.85,144.76 v2(139.24,145.15) 139.76,145.67 UV1.AD15 139.98,145.67 v2(140.48,145.17) 140.48,145.05 UV1.AF16 141.2,145.02 v2(141.2,145.16) ; UV1.U15 133.78,145.67 v2(133.26,145.16) 132.85,144.75 UV1.T16 132.8,144.67 v2(132.34,145.14) 131.85,145.62 UV1.R15 131.67,145.67 v2(131.17,145.17) 130.85,144.85 UV1.N16 130.36,144.18 v2(130.34,144.18) 129.85,143.69 UV1.M17 UV1.L17 ; U10.6 11.41,113.9 v2(11.03,113.52) ; v2(139.18,135.18) 139.67,135.67 UV1.AD27 ; UV1.Y27 135.88,135.67 136.34,135.21 v2(136.42,135.21) 136.42,135.13 136.56,134.99 136.56,134.96 UV1.AA28 137.14,134.96 137.14,135 v2(137.34,135.21) 137.35,135.21 137.82,135.67 UV1.AB27 ; v2(16.74,70.64) 16.57,70.64 16.35,70.85 15.42,70.85 D32.3 ; UV1.N18 130.88,142.67 131.19,142.99 v2(131.19,143.17) 131.69,143.67 UV1.R17 v2(132.35,143.17) UV1.T18 133.29,143.11 v2(133.29,143.17) 133.35,143.17 UV1.U17 134.35,143.17 v2(134.42,143.17) 134.42,143.11 UV1.V18 135.21,143.03 135.21,143.21 v2(135.22,143.21) 135.22,143.22 135.4,143.22 UV1.Y17 v2(136.35,143.17) UV1.AA18 v2(137.35,143.17) UV1.AB17 v2(138.35,143.17) UV1.AC18 139.33,143.15 v2(139.33,143.17) 139.35,143.17 UV1.AD17 140.37,143.16 v2(140.44,143.16) 140.44,143.08 UV1.AF18 140.86,142.67 v2(141.36,143.17) 141.85,143.67 UV1.AG17 ; UV1.L22 128.64,139.46 v2(128.18,139.46) ; v2(113.23,138.45) 113.86,139.08 CV68.2 ; D30.3 v2(16.87,24.6) ; UV1.AD22 139.35,139.17 v2(139.28,139.17) 139.28,139.09 UV1.AC23 138.5,139.02 v2(138.5,139.17) 138.35,139.17 UV1.AB22 137.35,139.17 v2(137.28,139.17) 137.28,139.1 UV1.AA23 136.39,139.13 v2(136.39,139.17) 136.35,139.17 UV1.Y22 135.36,139.18 135.22,139.18 135.21,139.17 v2(135.17,139.17) 135.17,138.99 UV1.V23 134.45,139.08 v2(134.45,139.16) 134.37,139.16 UV1.U22 133.35,139.17 v2(133.23,139.17) 133.23,139.05 UV1.T23 132.4,139.12 v2(132.4,139.12) UV1.R22 131.69,139.67 v2(131.19,139.16) 131.19,139 UV1.N23 130.85,138.7 130.32,139.23 130.32,139.3 129.95,139.67 UV1.M22 UV1.N21 130.85,140.78 v2(131.22,141.15) 131.75,141.67 UV1.R20 v2(132.35,141.17) UV1.T21 v2(133.35,141.17) UV1.U20 v2(134.35,141.17) UV1.V21 135.21,141.03 v2(135.21,141.17) 135.35,141.17 UV1.Y20 v2(136.35,141.17) UV1.AA21 137.28,141.1 v2(137.28,141.17) 137.35,141.17 UV1.AB20 138.35,141.17 v2(138.43,141.17) 138.43,141.09 UV1.AC21 139.33,141.15 v2(139.33,141.17) 139.35,141.17 UV1.AD20 140.37,141.16 v2(140.44,141.16) 140.44,141.08 UV1.AF21 140.85,140.68 v2(141.36,141.18) 141.85,141.67 UV1.AG20 ; v2(144.75,143.08) 145.25,143.58 UV1.AL17 ; UV1.C1 123.25,155.59 v2(123.12,155.72) ; UV1.U27 133.34,136.18 v2(133.34,136.19) ; D27.3 v2(16.33,45.75)
  BOTTOM w0.406: D29.3 20.02,60.23 20.16,60.09 v2(20.33,60.09) ; v2(19.83,63.99) 19.51,63.99 19.46,63.94 D28.3
  BOTTOM w0.432: U6.3 121.35,101.06 v2(121.44,101.15)
  BOTTOM w0.457: v2(125.21,91.36) 125.63,91.36 125.87,91.12 C167.2 ; v2(122.21,94.8) 121.85,94.45 R158.2 ; DL1.2 26.02,71.14 v2(26,71.16) ; v2(124.23,90.73) 124.54,90.42 C158.2
  BOTTOM w0.508: RV2.2 v2(156.68,154.7) ; 93.73,147.64 92.67,148.69 v3(92.68,148.69) ; v2(202.06,137.91) 201.71,137.55 JWLN1.53 ; v2(136.41,83.65) 136.41,83.28 C160.2 ; PC634.2 v4(174.18,123.71) ; R199.1 134.7,78.36 R197.1 v2(134.71,77.52) ; C526.2 v2(11.79,112.07) ; v2(118.29,87.66) 117.88,87.24 C147.2 ; R695.1 161.64,86.58 v2(162.04,86.98) ; PR613.1 199.6,14.39 199.31,14.68 199.31,15.25 198.83,15.73 v2(198.19,15.73) ; JFAN1.6 97.34,154.52 v2(97.34,156.4) ; R265.1 120.52,96.57 R157.2 120.49,96.59 119.07,96.59 v2(119.01,96.53) ; JWLN1.15 v2(197.72,146) ; PC968.2 v2(70.63,121.29) ; DA2.1 v2(19.16,10.83) ; v2(99.9,121.9) 99.67,121.66 C605.2 ; CA32.2 22.97,14.39 v2(23.4,14.82) 22.94,15.28 CA31.2 ; v2(127.78,76.99) 127.73,77.04 C153.2 ; CV179.2 146.76,175.3 147.05,175.59 148.19,175.59 148.53,175.25 RV90.2 148.53,173.5 v2(148.17,173.14) ; v2(135.62,96.52) 135.35,96.52 135.1,96.27 R267.1 ; JHDD1.19 v2(170.93,122.97) ; JWLN1.43 v2(197.74,160.4) ; v2(105.16,162.62) 105.16,162.62 CV134.2 ; v2(154.96,145.82) RV59.2 154.23,145.82 CV102.2 ; v4(180.13,150.65) 179.94,150.46 PQ306.3 ; v2(120.12,85.53) 120.12,85.1 C146.2 ; R132.1 127.1,74.68 v2(127.64,74.14) ; RV89.2 132.86,163.47 133.19,163.79 ; D22.2 v2(18.43,39.04) ; JDIMM2.205 31.09,28.48 v2(30.87,28.26) ; R247.1 128.17,101.56 v2(127.72,102) ; RV87.2 CV136.2 104.33,152 v2(104.81,152.49) ; v2(154.98,153.97) CV45.2 CV44.2 ; v2(133.69,80.13) 133.69,80.14 C184.2 ; JWLN1.29 198.01,154.8 v2(197.61,154.4) 198.01,154 JWLN1.27 ; JRTC1.2 208.56,21.6 v2(209.16,21) ; v2(9.95,111.47) 10.02,111.39 C524.2 ; v2(117.81,99.53) 117.81,98.36 R275.2 ; CV104.2 102.5,131.55 v2(102.01,131.55) ; v2(124.83,84.16) 124.93,84.25 C138.2 ; JFAN1.5 v2(101.01,164.2) ; v2(155.62,153.27) 155.76,153.13 CV43.2 ; v2(92.71,139.34) 92.4,139.34 92.09,139.65 R408.2 ; D31.2 18.87,22.47 18.54,22.8 v2(17.29,22.8) ; v4(173.84,130.73) 174.48,130.1 PC628.2 ; R156.2 134.97,101.11 C494.2 134.97,101.61 v2(134.77,101.81) ; JFAN1.4 v2(96.57,157.46) ; PC314.2 184.11,167.32 v2(183.56,166.77) ; CV107.2 v2(104.72,127.94) ; v2(104.92,138.29) 103.79,138.29 CV108.2 ; JSPK1.6 177.63,129.39 v2(178,129.77) ; PC213.2 v2(114.15,15.61) ; v2(119.53,82.11) 119.73,81.92 C173.2 ; v2(125.61,103.86) 125.44,103.69 R260.1 ; C4.2 86.57,141.68 v2(87.12,141.12) ; CV184.2 119.78,172.8 v2(120.04,173.05) ; v2(156.17,174.19) 156.48,174.51 CV177.2 CV175.2 ; v2(101.95,148.13) 102.07,148.25 RV70.2 CV126.2 ; PC630.2 174.48,132.57 v4(174.47,132.58) ; v2(156.08,150.97) RV34.2 RV33.2 ; CV194.2 v2(150.3,174.24) ; CA33.2 v2(22.92,12.2) ; C163.2 129.91,89.26 130.14,89.49 v2(130.63,89.49) ; C525.2 v2(14.86,111.91) ; C520.2 v2(100.13,136.31) ; CV183.2 144.99,173.62 v2(145.49,173.12) ; CV193.2 v2(152.06,174.25) ; v2(154.91,147.61) RV58.2 CV101.2 ; JDIMM1.206 v2(103.61,44.14) ; JWLN1.35 v2(197.14,157.2) ; 198.46,105.69 198.46,105.15 v2(198.21,104.9) ; C115.2 139.97,89.97 v2(140.52,89.97) ; v2(136.11,87.97) 136.11,88.64 C155.2 ; C412.2 v2(13.62,125.41) 13.57,125.36 C411.2 ; v2(140.69,173.16) 140.44,172.91 CV75.2 ; C133.2 131.74,72.41 131.27,71.94 v2(129.57,71.94) ; R192.1 116.45,82.64 R183.1 v2(115.76,83.52) ; CV145.2 102.33,154.7 v2(102.32,154.68) ; RV83.2 148.53,162.2 v2(148.97,162.2) 149.44,162.2 149.75,161.88 CV173.2 ; C179.2 v2(127.06,73.51) ; v2(91.68,128.99) CT8.2 90.91,128 R438.1 ; v2(198.37,59.93) 196.71,59.93 C604.2 195.79,59.91 C608.2 ; v2(104.33,144.07) 104.33,144.05 CV116.2 ; R274.2 120.16,102.37 119.6,101.81 v2(119.46,101.81) ; JWLN1.9 v2(197.48,143.6) ; v2(132.9,83.03) 132.9,82.86 133.27,82.49 R242.2 ; v2(112.05,102.93) 111.5,102.38 C120.1 ; PC606.2 v4(192.6,11.26) ; v2(153.83,174.25) CV186.2 ; DA1.1 v2(19.67,14.89) ; PR608.2 v2(196.75,15.84) ; CV67.2 116.07,145.65 116.52,146.1 v2(116.52,146.74) ; v3(187.89,152.24) 188.27,152.62 v4(188.67,152.62) 188.88,152.83 PC102.2 190.27,152.83 PC101.2 ; v2(186.79,125.66) 186.48,125.97 JSPK1.5 ; CV109.2 103.88,125.21 v2(104.73,126.06) ; Q107.3 140.57,2.83 140.34,2.6 v2(139.34,2.6) 139.34,3.09 139.06,3.37 Q110.3 ; JRTC1.4 v2(208.24,17.8) ; R168.1 136.07,89.69 v2(136.34,89.69) 136.45,89.79 CLRP3.2 ; v2(27.44,83.3) 28.37,83.3 28.8,82.86 CL31.2 ; R282.1 135.04,74.72 v2(135.05,74.72) ; RV14.2 153.32,143.99 CV23.2 v2(152.62,144) ; v2(28.14,44.4) 28.71,43.82 JDIMM1.205 ; JWLN1.54 v2(197.72,166.85) ; v2(27.25,115.98) 26.84,116.38 PR922.2 ; v2(177.3,153.95) 176.92,153.95 176.56,153.59 PQ314.3 ; JHDD1.4 v2(146.8,119.69) ; C527.2 v2(10.02,112.12) ; JHDD1.7 150.61,119.68 v2(150.69,119.61) ; PC212.2 v2(109.51,15.5) ; v2(101.61,27.19) 100.25,27.19 JDIMM2.206 ; C591.1 v2(103.1,165.84) ; R104.1 140.72,84.02 v2(140.98,84.27) ; C134.2 123.14,80.94 v2(123.26,80.81) ; v2(207.17,25.14) 206.83,25.14 205.84,24.15 JRTC1.3 ; JHDD1.1 142.99,120.03 v2(142.63,119.67) ; C722.2 v2(133.7,9.05) ; v2(124.82,83.33) 124.82,83.14 124.43,82.76 C162.2 ; JWLN1.21 v2(197.47,151.6) ; v2(108.02,83.75) 107.54,83.75 105.04,86.26 U8.4 ; CV167.2 v2(121.62,174.19) ; v2(104,163.08) 104.01,163.07 CV128.2 ; PC517.2 44.44,2.6 43.16,1.32 v3(40.36,1.32) 38.71,1.32 v4(38.05,1.98) ; PR912.1 17.65,117.6 PC908.2 17.65,119.4 PC905.2 17.44,119.4 v2(17.03,119.81) ; JWLN1.40 v2(208.73,159.2) ; v2(126.8,83.33) 126.96,83.49 C132.2 ; PC605.2 v2(195.23,15.37) ; PC432.2 67.2,3.26 v2(66.82,2.88) ; Q113.3 191.38,12.41 v2(191.23,12.26) ; JWLN1.18 v2(209.61,150.4) ; C522.2 v2(14.86,109.74) ; D15.1 192.38,92.96 v2(192.68,92.66) ; PQ313.3 v2(162.21,165.06) ; CV144.2 103.98,157.33 104,157.32 v2(104.75,157.32) ; v2(104.72,155.55) 104.71,155.56 CV135.2 ; v2(114.16,151.06) 114.31,151.21 CV164.2 115.6,152.06 CV112.2 ; v2(44.75,98.66) 45.22,98.19 R63.2 ; C523.2 v2(11.79,109.77) ; CV165.2 118.74,170.78 v2(118.73,170.78) ; JWLN1.37 v2(197.11,158) ; R67.2 45.21,95.5 v2(44.75,95.04) 45.23,94.56 R62.2 ; C136.2 126.37,80.65 126.52,80.8 v2(126.78,80.8) ; v2(199.99,52.13) C607.2 ; U72.2 v2(89.5,144.17) ; R228.2 120.44,76.53 v2(120.84,76.93) ; CV192.2 141.12,174.9 v2(140.9,174.69) ; CV36.1 v2(154.26,132.75) ; v2(208.93,163.19) 208.92,163.2 JWLN1.50 ; Q100.3 193.68,59.47 193.97,59.18 v2(194.51,59.18) ; v2(101.97,130.66) RV65.2 ; v2(125.33,175.55) 125.58,175.8 RV77.2 CV150.2 ; J12.1 v2(200.13,96.52) ; CV37.1 154.02,129.6 v2(153.61,129.6) ; C721.2 v2(132.3,9.05) ; C726.2 v2(131.53,3) ; v2(106.1,162.61) 106.12,162.6 CV125.2 ; JWLN1.34 v2(208.74,156.8) ; CV113.2 v2(106.3,139.28) ; CA34.2 v2(22.98,9.47) ; JHDD1.17 v2(168.39,122.9) ; JWLN1.26 v2(208.67,153.6) ; CV155.2 v2(123.36,174.19) ; JWLN1.4 209.55,141.6 v2(209.56,141.61) ; RV44.2 v2(154.29,127.31) ; CV115.2 v2(158.81,171.37) ; PQ305.3 v2(180.64,154.3)
  vias: v2(7.97,0.51) v2(9.38,103.72) v2(10.03,103.73) v2(10.08,128.57) v2(10.08,126.6) v2(10.59,122.98) v2(11.15,130.48) v2(13.51,59.8) v2(13.51,57.96) v2(14.96,0.51) v2(16.17,21.57) v2(16.17,19.23) v2(16.59,41.23) v2(18.01,29.03) v2(18.77,130.46) v2(18.97,20.52) v2(19.65,62.38) v2(19.83,65.45) v2(20.44,61.88) v2(20.71,58.37) v2(22.71,122.21) v2(22.7,120.34) v2(22.73,78.97) v2(22.74,78.39) v2(22.65,51.36) v2(22.65,49.51) v2(22.97,86.1) v2(22.99,85.48) v2(23.35,36.34) v2(23.38,36.93) v2(23.37,35.72) v2(23.37,35.12) v2(23.49,121.32) v2(24.45,122.25) v2(24.47,120.32) v2(24.55,21.16) v2(24.57,19.72) v2(25.27,27.66) v2(26.4,130.46) v2(27.96,115.93) v2(27.98,115.34) v2(27.97,114.74) v2(28.23,0.51) v2(30.27,19.44) v2(30.87,25.79) v2(30.86,19.43) v2(31.7,25.79) v2(32.26,33.11) v2(32.38,7.63) v2(32.52,25.79) v2(33.09,8.34) v2(33.09,7.59) v2(34.04,130.46) v2(34.04,41.69) v2(34.04,40.16) v2(34.9,55.15) v2(34.9,53.62) v2(35.85,0.51) v2(36.19,23.74) v2(36.25,12.07) v2(36.27,13.76) v2(36.28,13.11) v2(36.26,11.46) v2(36.54,41.79) v2(36.54,40.27) v2(36.77,23.72) v2(37.57,32.15) v2(37.75,132.49) v2(38.19,73.03) v2(38.24,52.1) v2(38.61,73.46) v2(38.57,41.67) v2(38.57,40.15) v2(38.83,34.06) v2(38.83,32.53) v2(39.12,73.83) v2(39.52,74.34) v2(40.74,39.77) v2(41.03,32.56) v2(42.38,24.51) v2(42.37,23.92) v2(42.5,41.67) v2(42.5,40.15) v2(43.47,0.51) v2(44.56,41.62) v2(44.81,23.9) v2(45.08,113.13) v2(45.34,34.08) v2(45.34,32.56) v2(45.37,132.49) v2(46.53,55.15) v2(46.53,52.1) v2(46.78,117.66) v2(47.41,117.66) v2(47.61,41.69) v2(47.61,40.17) v2(47.63,32.56) v2(48.03,117.68) v2(48.67,117.68) v2(49.2,55.15) v2(49.65,41.77) v2(49.64,40.25) v2(49.91,34.08) v2(49.91,32.56) v2(51.09,0.51) v2(51.49,53.62) v2(51.69,32.18) v2(52.45,40.25) v2(52.76,53.24) v2(52.99,132.49) v2(53.82,34.08) v2(57.58,96.7) v2(57.57,96.08) v2(58.32,97.33) v2(58.71,0.51) v2(59,97.34) v2(59.85,96.63) v2(59.9,95.97) v2(60.28,7.46) v2(60.28,6.83) v2(60.61,132.49) v2(60.57,97.3) v2(61.24,97.31) v2(62.05,96.67) v2(62.04,96.04) v2(62.76,97.28) v2(62.92,4.04) v2(63.28,3.5) v2(63.44,97.29) v2(64.23,96.59) v2(64.22,95.97) v2(64.64,97.26) v2(64.7,3.12) v2(65.31,97.27) v2(66.03,97.22) v2(66.33,0.51) v2(66.62,97.19) v2(67.21,97.37) v2(67.85,136.52) v2(67.88,97.38) v2(68.52,97.34) v2(69.13,97.32) v2(69.72,97.42) v2(70.4,97.43) v2(71.33,96.9) v2(71.32,96.27) v2(71.31,15.52) v2(72.14,97.35) v2(72.81,97.37) v2(73.49,139.74) v2(73.79,97.06) v2(73.78,96.44) v2(73.95,0.51) v2(74.44,102.93) v2(74.43,102.34) v2(74.45,101.74) v2(74.44,101.11) v2(74.65,97.35) v2(75.33,97.37) v2(76.52,97.37) v2(77.13,97.37) v2(77.3,41.67) v2(77.62,54.83) v2(77.62,53.31) v2(79.03,39.77) v2(79.48,52.94) v2(80.35,40.15) v2(80.57,143.53) v2(80.62,125.02) v2(80.62,124.41) v2(80.64,123.79) v2(80.75,54.85) v2(80.75,53.32) v2(80.75,51.8) v2(81.43,32.56) v2(82.34,132.57) v2(83,53.32) v2(83.17,32.18) v2(84.7,32.56) v2(84.8,130.23) v2(85.24,54.83) v2(85.24,53.3) v2(85.24,51.78) v2(85.2,41.67) v2(85.2,40.15) v2(85.26,133.78) v2(85.75,130.23) v2(86,95.43) v2(86.55,148.53) v2(86.64,123.37) v2(86.62,122.78) v2(86.98,32.56) v2(87.26,122.78) v2(87.4,19.24) v2(87.4,17.51) v2(87.78,54.87) v2(87.78,53.35) v2(87.86,41.67) v2(87.86,40.15) v2(89.05,55.25) v2(89.05,52.97) v2(89.66,39.77) v2(89.73,0.52) v2(90.32,54.87) v2(90.32,53.35) v2(90.32,51.82) v2(90.93,40.15) v2(91.68,31.41) v2(92,155.85) v2(92.36,55.15) v2(92.36,52.1) v2(93.53,146.65) v2(93.53,146.06) v2(93.46,32.56) v2(93.82,41.67) v2(93.82,40.15) v2(94.9,54.01) v2(95.02,162.92) v2(94.95,31.8) v2(96.17,55.15) v2(96.17,53.63) v2(96.24,1.53) v2(96.4,95.4) v2(96.84,2.17) v2(96.91,41.4) v2(97.35,0.52) v2(97.53,1.47) v2(97.59,96.34) v2(97.7,139.97) v2(97.72,139.36) v2(98.19,2.12) v2(98.85,96.32) v2(98.93,1.48) v2(98.99,105.2) v2(99.55,2.13) v2(100.03,96.36) v2(100.36,1.51) v2(100.77,2.11) v2(101.24,95.39) v2(101.26,168.2) v2(101.54,1.52) v2(101.93,152.31) v2(102,103.52) v2(102.05,2.12) v2(102.83,133.33) v2(103.55,1.43) v2(104.06,2.11) v2(104.92,138.93) v2(104.97,0.52) v2(105.85,62.47) v2(107.55,168.97) v2(107.74,175.05) v2(107.75,64.2) v2(108.29,14.28) v2(108.3,13.69) v2(109.35,164.82) v2(109.45,61.78) v2(109.95,164.83) v2(110.4,178.97) v2(110.38,84.01) v2(110.79,61.73) v2(111.3,69.8) v2(111.72,74.23) v2(111.84,72.9) v2(112.22,68.4) v2(112.55,15.63) v2(112.59,0.52) v2(113.15,71.96) v2(113.18,15.62) v2(113.51,89.98) v2(113.55,88.53) v2(113.56,91.86) v2(114.92,90.74) v2(114.94,5.05) v2(115.35,88.35) v2(115.37,68.46) v2(115.55,5.47) v2(116.1,134.94) v2(116.34,172.13) v2(116.26,171.55) v2(116.86,171.56) v2(117.5,15.57) v2(117.67,2.22) v2(117.99,178.97) v2(118.08,15.56) v2(118.99,2.22) v2(120.21,0.52) v2(120.71,2.35) v2(121.46,76.97) v2(122.11,21.97) v2(122.17,83.3) v2(122.23,2.49) v2(122.84,84.96) v2(122.84,83.32) v2(122.85,88.2) v2(123.48,84.95) v2(123.57,88.21) v2(125.51,88.2) v2(125.66,178.97) v2(125.91,129.24) v2(126.15,88.2) v2(126.83,131.87) v2(126.81,88.2) v2(126.86,65.34) v2(127.26,65.79) v2(127.61,129.47) v2(127.55,68.63) v2(127.67,131.87) v2(127.83,0.52) v2(128.44,68.63) v2(128.95,76.96) v2(129.45,87.44) v2(129.53,174.22) v2(129.57,76.96) v2(129.71,77.66) v2(130.88,129.43) v2(132.45,129.41) v2(133.28,178.97) v2(134.88,129.53) v2(135.45,0.52) v2(135.61,132.68) v2(136.57,129.46) v2(136.67,93.39) v2(136.82,77.01) v2(137.26,93.38) v2(137.33,75.49) v2(137.43,80.95) v2(137.8,78.29) v2(140.88,178.97) v2(141.75,93.1) v2(142.29,123.81) v2(142.88,123.82) v2(143.07,0.52) v2(145,83.77) v2(148.2,135.36) v2(148.5,178.97) v2(150.69,0.52) v2(152.53,56.73) v2(154.28,136.01) v2(154.28,135.42) v2(154.39,80.92) v2(154.39,80.31) v2(154.86,136.01) v2(154.86,135.42) v2(155.45,136.01) v2(155.45,135.42) v2(155.37,50.14) v2(155.4,49.14) v2(155.4,48.22) v2(156.1,178.97) v2(156.41,50.12) v2(156.45,49.2) v2(156.46,48.26) v2(156.72,136.06) v2(156.72,135.48) v2(157.5,50.07) v2(157.47,49.22) v2(157.47,48.27) v2(158.15,55.95) v2(158.31,0.52) v2(162.16,174.17) v2(162.16,173.53) v2(162.16,172.9) v2(162.67,119.56) v2(162.66,45.54) v2(162.99,119.05) v2(163.3,119.56) v2(163.29,45.54) v2(163.77,178.97) v2(165.93,0.52) v2(171.38,178.97) v2(173.55,0.52) v2(174.26,181.4) v2(175.23,66.09) v2(175.23,65.45) v2(178.77,183.83) v2(179.84,169.47) v2(181.17,0.52) v2(183.92,74.08) v2(185.47,84.57) v2(185.54,83.79) v2(186.37,183.83) v2(188.79,0.52) v2(190.33,74.3) v2(192.12,42.36) v2(192.08,40.56) v2(194.01,183.83) v2(195.14,17.41) v2(195.16,20.39) v2(195.17,19.73) v2(195.16,18.95) v2(195.16,18.35) v2(195.16,16.77) v2(196.04,117.48) v2(196.04,116.9) v2(196.41,0.52) v2(196.62,117.49) v2(196.63,116.87) v2(198.83,149.2) v2(200.78,149.68) v2(201.61,106.98) v2(201.61,99.36) v2(201.61,91.74) v2(201.61,84.12) v2(201.67,183.83) v2(202.6,129.84) v2(202.6,122.22) v2(202.6,114.6) v2(202.59,76.54) v2(202.59,32.84) v2(204.03,0.52) v2(205.4,168.75) v2(205.99,168.75) v2(206.27,28.67) v2(206.48,136.31) v2(206.57,168.75) v2(207.32,23.34) v2(207.97,182.93) v2(208.47,2.99) v2(208.6,4.84) v2(209.76,6.51) v2(210.78,28.69) v2(211.7,178.97) v2(212.15,173.29) v2(212.15,165.63) v2(212.15,158.04) v2(212.15,150.38) v2(212.14,142.8) v2(212.14,139.32) v2(212.14,24.85) v2(212.14,17.22) v2(212.14,9.61) v2(212.16,6.61) v3(18.49,24.28) v3(24.85,23.84) v3(25.2,9.87) v3(40.75,72.84) v3(60.33,129.63) v3(61.59,129.77) v3(65.67,12.29) v3(85.71,122.6) v3(101.94,136.22) v3(102.81,1.6) v3(104.62,1.94) v3(120.09,41.25) v3(153.64,135.19) v3(160.98,174.01) v3(172.23,123.73) v3(173.53,137.04) v3(174.84,151.97) v3(207,169.14) v4(20.04,97.61) v4(20.02,96.97) v4(20.06,99.54) v4(20.06,98.89) v4(20.06,98.24) v4(20.05,96.28) v4(20.73,96.92) v4(20.73,96.29) v4(20.77,99.49) v4(20.77,98.85) v4(20.77,98.2) v4(20.75,97.56) v4(21.44,97.57) v4(21.42,96.92) v4(21.42,96.25) v4(21.46,99.5) v4(21.47,98.85) v4(21.46,98.2) v4(22.13,99.52) v4(22.13,98.87) v4(22.13,98.22) v4(22.11,97.59) v4(22.09,96.95) v4(22.14,96.26) v4(22.79,99.54) v4(22.8,98.89) v4(22.8,98.25) v4(22.78,97.61) v4(22.76,96.97) v4(22.77,96.26) v4(26.46,126.88) v4(26.46,126.23) v4(26.47,125.54) v4(27.1,126.88) v4(27.1,126.23) v4(27.11,125.54) v4(27.78,126.9) v4(27.78,126.25) v4(27.79,125.56) v4(28.16,121.15) v4(28.44,126.89) v4(28.44,126.24) v4(28.45,125.54) v4(29.11,126.89) v4(29.11,126.24) v4(29.12,125.55) v4(29.76,126.91) v4(29.76,126.26) v4(30.12,92.2) v4(32.21,98.2) v4(32.19,96.27) v4(32.23,91.82) v4(32.26,98.87) v4(32.26,97.56) v4(32.25,96.92) v4(32.85,96.27) v4(32.9,99.52) v4(32.92,98.87) v4(32.87,98.2) v4(32.92,97.57) v4(32.9,96.92) v4(32.9,91.81) v4(33.38,5.49) v4(33.4,4.79) v4(33.42,3.97) v4(33.43,3.29) v4(33.44,2.58) v4(33.51,98.23) v4(33.54,96.96) v4(33.53,96.28) v4(33.45,1.92) v4(33.56,99.54) v4(33.56,98.89) v4(33.56,97.6) v4(34.08,4.68) v4(34.08,3.99) v4(34.07,3.3) v4(34.08,2.61) v4(34.09,1.96) v4(34.2,99.54) v4(34.2,98.89) v4(34.15,98.23) v4(34.2,97.6) v4(34.18,96.96) v4(34.17,96.28) v4(34.17,10.12) v4(34.19,9.42) v4(34.71,4.7) v4(34.74,4.01) v4(34.72,3.32) v4(34.72,2.63) v4(34.74,1.99) v4(34.84,99.51) v4(34.84,97.57) v4(34.84,96.89) v4(34.84,96.25) v4(34.86,98.86) v4(34.86,98.2) v4(35.39,4.67) v4(35.39,4.03) v4(35.36,3.34) v4(35.37,2.64) v4(35.38,1.97) v4(36.03,4.67) v4(36.04,4) v4(36.01,3.31) v4(36.02,2.62) v4(36.02,1.97) v4(36.65,3.25) v4(36.66,4.66) v4(36.67,3.98) v4(36.66,2.61) v4(36.71,1.94) v4(37.4,1.96) v4(40.25,105.4) v4(40.89,105.4) v4(41.52,105.4) v4(42.16,105.4) v4(51.6,130.23) v4(51.6,129.54) v4(55,15.2) v4(55.02,14.5) v4(55.72,15.18) v4(55.71,14.5) v4(56.29,129.28) v4(56.29,128.57) v4(56.29,8.16) v4(56.94,8.16) v4(57.32,128.53) v4(57.57,8.17) v4(58.08,128.53) v4(58.21,8.18) v4(59.16,128.53) v4(59.93,128.53) v4(60.92,128.53) v4(61.68,128.53) v4(65.33,10.2) v4(65.36,10.84) v4(66,10.82) v4(66,10.18) v4(66.72,10.82) v4(66.73,10.17) v4(67.36,10.82) v4(67.37,10.16) v4(68,10.83) v4(68.04,10.18) v4(68.7,10.84) v4(68.69,10.14) v4(74.86,128.26) v4(75.41,128.81) v4(75.37,127.76) v4(75.92,129.31) v4(75.9,128.32) v4(76.45,129.81) v4(76.4,128.83) v4(76.93,129.33) v4(78.85,6.4) v4(79.2,6.97) v4(87.86,6.91) v4(88.54,6.92) v4(89.25,6.93) v4(89.9,6.92) v4(103.03,32.86) v4(105.3,33.76) v4(106.49,50.41) v4(107.2,50.41) v4(107.88,50.41) v4(108.56,50.39) v4(116.01,40.99) v4(116.02,40.35) v4(116.03,39.71) v4(116.05,39.05) v4(116.05,37.63) v4(116.06,38.26) v4(116.75,37.56) v4(116.75,38.22) v4(117.39,38.22) v4(117.39,37.58) v4(118.03,38.22) v4(118.03,37.59) v4(162.55,133.24) v4(162.55,132.57) v4(162.77,152.14) v4(162.79,151.5) v4(162.8,150.81) v4(162.8,150.14) v4(163.2,133.25) v4(163.2,132.58) v4(163.29,127) v4(163.28,126.35) v4(163.83,134.6) v4(163.85,133.95) v4(163.86,133.26) v4(163.86,132.6) v4(163.99,152.13) v4(164.02,151.49) v4(164.03,150.8) v4(164.03,150.14) v4(163.97,127.01) v4(163.96,126.36) v4(164.64,126.98) v4(164.64,126.34) v4(165.23,154.16) v4(165.28,127) v4(165.27,126.36) v4(165.42,154.79) v4(165.53,169.25) v4(165.55,167.34) v4(165.86,154.1) v4(166.5,154.1) v4(166.93,171.41) v4(167.6,164.01) v4(167.6,163.31) v4(168.25,164.01) v4(168.25,163.34) v4(168.88,163.99) v4(168.91,163.33) v4(169.54,163.99) v4(169.57,163.33) v4(170.23,163.99) v4(170.23,163.3) v4(170.22,125.39) v4(170.21,124.74) v4(170.88,164.02) v4(170.88,163.32) v4(171.22,151.14) v4(171.24,135.72) v4(171.27,135.05) v4(171.3,134.39) v4(171.34,133.72) v4(171.8,151.48) v4(171.8,150.84) v4(171.81,150.15) v4(171.92,135.72) v4(171.96,135.05) v4(171.99,134.38) v4(172.02,133.71) v4(172.46,151.49) v4(172.49,150.82) v4(172.51,150.15) v4(172.6,135.72) v4(172.64,135.05) v4(172.67,134.38) v4(172.7,133.71) v4(173.13,151.49) v4(173.16,150.82) v4(173.19,150.15) v4(173.27,135.73) v4(173.3,135.06) v4(173.33,134.39) v4(173.37,133.72) v4(173.74,148.13) v4(173.71,145.72) v4(173.81,151.49) v4(173.84,150.82) v4(173.79,147.02) v4(173.88,150.15) v4(173.92,135.73) v4(173.95,135.06) v4(173.98,134.39) v4(174.02,133.72) v4(174.15,123.02) v4(174.47,151.49) v4(174.51,150.83) v4(174.54,150.16) v4(174.64,148.15) v4(174.6,135.75) v4(174.64,135.08) v4(174.62,134.4) v4(174.71,146.99) v4(174.71,145.7) v4(174.65,133.73) v4(174.85,123.69) v4(174.82,123) v4(175.18,151.49) v4(175.16,150.83) v4(175.19,150.19) v4(175.29,135.75) v4(175.32,135.08) v4(175.29,134.4) v4(175.32,133.73) v4(175.52,123.69) v4(175.5,123) v4(175.61,146.92) v4(175.61,145.66) v4(175.69,148.16) v4(175.81,151.52) v4(175.79,150.83) v4(175.83,150.16) v4(176.2,123.68) v4(176.17,122.99) v4(176.49,151.52) v4(176.46,150.84) v4(176.49,150.17) v4(177.13,151.51) v4(177.15,150.84) v4(177.17,150.17) v4(182.66,140.25) v4(182.84,137.52) v4(183.33,140.27) v4(183.51,137.56) v4(186.37,139.08) v4(186.41,137.53) v4(187.22,138.26) v4(187.56,166.64) v4(188.04,137.48) v4(188.06,139.07) v4(188.53,167.28) v4(188.51,166.6) v4(196.74,4.93) v4(197.44,4.92) v4(198.14,4.92) v4(198.24,8.17) v4(198.23,6.31) v4(198.23,5.6) v4(198.94,8.17) v4(198.92,6.3) v4(198.92,5.59) v4(200.98,12.22) v4(202.01,12.21) v4(202.67,12.19) v4(203.35,12.18) v4(204.03,12.19) v4(204.69,12.18) v4(205.34,12.18) v4(206,12.17) v4(206.68,12.16) v4(207.32,12.16)
