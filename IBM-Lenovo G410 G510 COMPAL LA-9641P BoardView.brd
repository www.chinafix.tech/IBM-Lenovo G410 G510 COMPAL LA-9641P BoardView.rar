# Allegro board IBM-Lenovo G410 G510 COMPAL LA-9641P BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 141.28,127.74 141.28,125.05 141.11,124.88 139.86,124.88 139.64,125.1 139.64,128.69 139.72,128.77 140.26,128.77
GND on TOP (solid shape): 144.43,124.64 144.43,123.66 144.36,123.59 141.69,123.59 141.52,123.76 141.52,124.64 141.69,124.81 144.26,124.81
GND on TOP (solid shape): 157.08,136.93 157.08,135.3 156.78,135 152.05,135 151.91,135.14 151.91,136.93 152.08,137.09 156.92,137.09
GND on TOP (solid shape): 166.6,128.36 166.6,126.4 166.28,126.08 159.98,126.08 159.53,126.53 159.53,128.21 159.94,128.62 166.34,128.62
GND on TOP (solid shape): 175.47,66.63 175.47,65.36 175.26,65.15 174.2,65.15 174.06,65.28 174.06,66.7 174.18,66.82 175.27,66.82
GND on TOP (solid shape): 196.51,21.18 196.51,16.38 196.29,16.15 194.61,16.15 194.37,16.39 194.37,21.17 194.55,21.35 196.35,21.35
GND on TOP (solid shape): 207.23,169.26 207.23,167.7 207.13,167.6 205.09,167.6 204.86,167.83 204.86,169.26 205,169.4 207.09,169.4
GND on TOP (solid shape): 19.5,29.63 19.5,28.22 19.31,28.03 17.63,28.03 17.53,28.14 17.53,29.25 17.71,29.43 18.82,29.43 19.12,29.74 19.38,29.74
GND on TOP (solid shape): 30.89,22.61 30.89,21.06 31.15,20.8 31.15,19.19 31.02,19.06 30.11,19.06 30,19.17 30,22.44 30.33,22.78 30.72,22.78
GND on TOP (solid shape): 33.16,91.95 33.16,91.69 33.03,91.56 31.93,91.56 31.67,91.82 30.91,91.82 30.83,91.9 30.83,92.01 30.9,92.08 33.02,92.08
GND on TOP (solid shape): 34.45,10.27 34.45,9.27 34.32,9.14 33.78,9.14 33.62,8.98 33.5,8.98 33.44,9.04 33.44,9.93 33.94,10.43 34.29,10.43
GND on TOP (solid shape): 36.19,47.78 36.19,46.8 36.07,46.67 34.01,46.67 33.9,46.55 33.64,46.55 33.52,46.68 33.52,47.73 33.75,47.97 36,47.97
GND on TOP (solid shape): 42.64,25.14 42.64,23.23 42.41,22.99 41.41,22.99 41.24,23.17 41.24,25.17 41.37,25.3 42.48,25.3
GND on TOP (solid shape): 49.96,117.78 49.96,117.78 49.96,116.13 49.77,115.94 47.04,115.94 46.53,116.44 46.53,117.78 46.72,117.97 49.77,117.97
GND on TOP (solid shape): 143.42,131.2 143.42,130.07 143.28,129.93 140.39,129.93 140.27,130.05 140.27,130.52 140.43,130.67 141.55,130.67 142.36,131.49 143.14,131.49
GND on TOP (solid shape): 163.66,47.99 163.66,45.54 163.42,45.3 162.52,45.3 162.38,45.44 162.38,46.81 162.73,47.16 162.73,48.1 162.75,48.13 163.52,48.13
GND on TOP (solid shape): 33.25,6.78 33.25,5.96 33.66,5.55 33.66,4.65 33.54,4.53 33.19,4.53 33.05,4.67 33.05,6.78 33.08,6.82 33.22,6.82
GND on TOP (solid shape): 37.58,24.1 39.49,24.1 39.6,23.99 39.6,23.54 39.49,23.43 36.07,23.43 35.91,23.59 35.91,23.97 36.04,24.1 37.58,24.1
GND on TOP (solid shape): 58.54,8.23 58.54,6.06 58.22,5.74 56.08,5.74 56.02,5.79 56.02,8.27 56.18,8.43 58.34,8.43
GND on TOP (solid shape): 148.98,151.74 148.98,150.43 148.85,150.3 145.56,150.3 145.37,150.49 145.37,150.8 145.52,150.95 145.92,150.95 146.13,151.16 146.13,151.66 146.42,151.95 148.77,151.95
GND on TOP (solid shape): 167.23,171.52 167.23,170.37 166.93,170.07 166.93,166.7 166.87,166.63 165.56,166.63 165.16,167.04 165.16,170.18 165.93,170.95 165.93,171.52 166.16,171.75 167,171.75
GND on TOP (solid shape): 167.46,134.79 167.46,132.48 166.99,132 159.64,132 159.2,132.45 159.2,134.91 159.45,135.16 167.1,135.16
GND on TOP (solid shape): 151.82,53.63 151.82,53.16 152.22,52.77 152.22,52.33 152.12,52.23 151.55,52.23 151.04,52.74 150.28,52.74 150.23,52.79 150.23,53.41 150.61,53.79 151.66,53.79
GND on TOP (solid shape): 182.44,171.18 182.44,168.67 182.33,168.55 180.47,168.55 179.55,169.48 179.55,170.15 179.89,170.49 181.17,170.49 181.36,170.69 181.36,171.36 181.4,171.4 182.23,171.4
GND on TOP (solid shape): 35.09,60.28 35.09,57.67 34.99,57.57 33.3,57.57 33.21,57.67 33.21,59.54 33.17,59.59 33.17,59.6 32.89,59.88 32.87,59.88 32.61,60.14 32.61,60.64 32.7,60.73 34.64,60.73
GND on TOP (solid shape): 62.29,130.21 62.29,127.69 61.84,127.24 56.98,127.24 56.01,128.2 51.56,128.2 51.23,128.53 51.23,130.27 51.81,130.84 61.66,130.84
GND on TOP (solid shape): 116.41,135.86 116.41,134.89 116.13,134.61 116.13,134.16 115.97,134 115.18,134 114.96,134.21 114.96,135.53 115.44,136.01 116.26,136.01
GND on TOP (solid shape): 152.83,56.88 152.83,55.9 152.6,55.67 152.06,55.67 151.68,55.29 151.68,54.98 151.43,54.72 150.73,54.72 150.41,55.04 149.65,55.04 149.4,55.29 149.4,55.99 150.48,57.07 152.64,57.07
GND on TOP (solid shape): 155.11,83.99 155.11,80.31 154.73,79.93 153.02,79.93 152.45,80.5 151.37,80.5 150.98,80.88 150.98,81.52 151.37,81.9 152.06,81.9 153.08,82.92 153.08,84.19 153.46,84.57 154.54,84.57
GND on TOP (solid shape): 158.38,56.09 158.38,55.83 158.25,55.7 157.9,55.7 157.74,55.53 157.74,55.03 158.02,54.75 158.02,54.25 157.95,54.18 156.6,54.18 156.47,54.31 156.47,56.1 156.59,56.22 158.25,56.22
GND on TOP (solid shape): 183.95,137.77 185.18,137.77 185.24,137.7 185.24,137.6 185.19,137.55 183.98,137.55 183.69,137.26 182.74,137.26 182.54,137.46 182.54,137.67 182.66,137.79 182.69,137.82 183.9,137.82
GND on TOP (solid shape): 22.11,123.45 26.34,123.45 26.48,123.31 26.48,122.3 26.31,122.13 25.42,122.13 24.89,121.59 24.89,119.15 24.57,118.84 21.55,118.84 21.29,119.11 21.29,122.4 20.89,122.81 20.89,123.38 20.96,123.46 22.1,123.46
GND on TOP (solid shape): 105.18,139.02 105.18,138.15 105.04,138.01 104.6,138.01 104.28,137.69 103.35,137.69 103.28,137.75 103.28,139.12 103.34,139.18 105.02,139.18
GND on TOP (solid shape): 129.08,70.91 129.08,68.88 128.57,68.37 127.8,68.37 127.74,68.38 127.68,68.37 127.43,68.37 127.3,68.5 127.3,69.9 127.74,70.34 127.74,70.91 127.87,71.04 128.95,71.04
GND on TOP (solid shape): 172.72,166.23 172.72,161.16 172.57,161.01 171.2,161.01 171.19,161.02 170.54,161.02 170.24,160.73 167.45,160.73 167.11,161.07 167.11,164.08 167.51,164.48 171.15,164.48 171.82,165.15 171.82,166.22 171.89,166.3 172.65,166.3
GND on TOP (solid shape): 177.54,151.48 177.54,149.08 177.21,148.75 177.21,144.52 172.97,144.52 172.86,144.64 172.86,147.94 171.95,148.85 171.95,149.51 171.52,149.94 171.52,149.95 170.94,150.53 170.94,151.43 171.46,151.95 177.07,151.95
GND on TOP (solid shape): 184.28,139.76 185.18,139.76 185.24,139.71 185.24,139.61 185.19,139.56 184.11,139.56 183.67,140 182.44,140 182.37,140.07 182.37,140.46 182.44,140.53 183.52,140.53
GND on TOP (solid shape): 137.67,127.83 137.67,127 137.66,126.99 137.66,126.7 137.57,126.6 137.4,126.6 137.33,126.54 137.33,124.89 137.14,124.7 135.81,124.7 135.68,124.83 135.68,126.54 135.55,126.67 134.65,126.67 134.47,126.85 134.47,127.76 134.7,128 137.5,128
GND on TOP (solid shape): 23.49,101.28 23.49,100.28 24.13,99.64 24.68,99.64 24.89,99.43 24.89,94.31 24.8,94.22 24.12,94.22 22.59,95.74 18.71,95.74 18.64,95.81 18.64,97.06 18.66,97.07 19.15,97.07 19.54,97.46 19.54,100.68 20.4,101.54 23.23,101.54
GND on TOP (solid shape): 37.83,99.11 37.83,96.19 37.61,95.96 33.83,95.96 33.76,95.97 33.7,95.96 30.97,95.96 30.58,95.57 29.32,95.57 29.19,95.7 29.19,96.2 29.27,96.28 29.6,96.28 29.67,96.35 29.67,99.77 29.69,99.79 37.14,99.79
GND on TOP (solid shape): 120.82,45.39 120.82,28.94 120.57,28.69 119.49,28.69 119.17,29 119.17,35.93 118.28,36.81 116.42,36.81 115.48,37.76 115.48,41.44 115.9,41.85 118.75,41.85 118.92,42.02 118.92,44.18 118.41,44.69 117.2,44.69 117.08,44.82 117.08,46.3 117.36,46.58 119.63,46.58
GND on TOP (solid shape): 31.19,128.71 31.19,124.8 31.49,124.49 31.49,121.69 31.23,121.42 30.27,121.42 30.08,121.62 30.08,122.79 28.54,124.33 27.28,124.33 26.2,125.41 26.19,125.46 26.19,127.8 26.29,127.9 30.22,127.9 30.35,128.03 30.35,128.7 30.37,128.72 31.17,128.72
GND on TOP (solid shape): 172.26,141.97 172.26,138.86 172.99,138.13 173.92,138.13 175.75,136.3 175.75,133.75 175.43,133.43 170.47,133.43 170.1,133.8 170.1,134.64 170.31,134.85 170.68,134.85 170.86,135.03 170.86,135.79 171.52,136.46 171.52,138.17 171.19,138.5 171.19,138.53 171.14,138.58 171.14,142.06 171.3,142.22 172,142.22
GND on TOP (solid shape): 172.3,128.24 172.3,125.65 172.45,125.5 177.69,125.5 177.83,125.35 177.83,123.19 177.37,122.73 171.93,122.73 171.03,123.63 170.3,123.63 169.86,124.06 169.86,124.59 169.86,124.59 169.86,125.84 170.42,126.4 171.67,126.4 171.67,127.99 171.66,128 170.35,128 170.35,128.23 170.39,128.27 172.27,128.27
GND on TOP (solid shape): 119.59,5.13 119.59,1.29 118.63,0.33 96.41,0.33 95.49,1.25 95.49,3.86 95.61,3.99 99.42,3.99 99.73,4.29 99.73,4.89 99.91,5.06 100.73,5.06 100.86,4.94 100.86,3.92 101.18,3.6 102.32,3.6 102.51,3.79 102.51,4.56 102.7,4.75 103.22,4.75 107.18,0.78 112.94,0.78 113.37,1.22 113.37,5.34 114.22,6.19 118.52,6.19
GND on TOP (solid shape): 163.81,122.16 163.81,117.08 163.68,116.95 162.93,116.95 162.85,116.99 162.83,117.06 162.75,117.33 162.51,117.46 162.44,117.49 162.41,117.56 162.41,122.03 162.73,122.35 163.62,122.35
GND on TOP (solid shape): 132.2,141.79 133.41,141.79 133.58,141.96 134.11,141.96 134.3,141.77 135.32,141.77 135.52,141.96 136.04,141.96 136.27,141.73 137.36,141.73 137.6,141.97 138.13,141.97 138.42,141.68 139.34,141.68 139.62,141.96 140.14,141.96 140.63,141.47 143.68,141.47 144.3,140.86 145.01,140.86 145.14,140.73 145.14,140.46 145.01,140.34 143.93,140.34 143.63,140.63 142.48,140.63 142.19,140.92 131.13,140.92 131.03,141.03 131.03,141.37 131.61,141.95 131.61,141.99 132.01,141.99
GND on TOP (solid shape): 167.54,152.07 167.54,149.76 167.06,149.28 159.48,149.28 159.24,149.53 159.27,149.56 159.32,149.91 159.05,150.13 159.01,150.14 159.01,150.37 159.09,150.59 159.01,150.82 159.01,151.92 159.52,152.43 167.17,152.43
GND on TOP (solid shape): 87.36,-0.46 79.36,-0.46 79.36,3.6 79.86,3.6 80.97,6.02 83.42,7.03 87.36,7.03
GND on TOP (solid shape): 124.21,85.33 124.21,84.48 124.38,84.31 124.65,84.31 124.75,84.41 124.92,84.41 125.07,84.25 125.07,84.06 124.87,83.86 124.87,83.61 125.11,83.37 125.11,83.21 125.32,83.01 125.32,82.85 125.22,82.76 124.43,82.76 124.34,82.85 124.34,82.99 124.53,83.18 124.53,83.48 123.91,84.11 123.02,84.11 122.83,83.92 122.83,83.68 123.07,83.44 123.07,83.23 122.69,82.85 122.69,82.04 122.58,81.92 122.18,81.92 121.95,82.16 121.95,83.67 121.39,84.23 121.39,84.58 121.49,84.69 122.21,84.69 122.72,85.19 122.96,85.19 123.07,85.08 123.28,85.08 123.73,85.53 124.01,85.53
GND on TOP (solid shape): 143.76,155.99 143.76,154.06 143.5,153.79 140.47,153.79 140.3,153.96 140.3,154.71 140.3,154.71 140.3,155.23 140.35,155.32 140.43,155.33 140.83,155.48 140.8,155.91 140.78,156.02 140.87,156.08 143.67,156.08
GND on TOP (solid shape): 212.4,5.4 211.4,5.4 210.23,4.92 209.75,3.75 209.75,2.07 209.31,1.61 209.15,1 209.15,0.25 207.4,0.25 207.4,7.75 212.4,7.75
GND on TOP (solid shape): 50.29,82.54 50.29,81.45 47.61,78.77 47.61,74.09 48.11,73.58 48.25,73.58 48.26,73.58 48.48,73.54 48.7,73.58 48.71,73.58 49.16,73.58 49.17,73.58 49.39,73.54 49.62,73.58 49.62,73.58 50.08,73.58 50.34,73.53 50.6,73.58 50.61,73.58 50.65,73.58 50.78,73.45 50.78,73.01 50.65,72.88 47.78,72.88 47.02,73.64 47.02,79.32 49.41,81.71 49.41,82.59 49.46,82.64 50.19,82.64
GND on TOP (solid shape): 121.88,77.57 121.94,77.49 122.02,77.44 122.03,77.43 122.13,77.34 122.13,76.76 121.61,76.24 120.65,76.24 120.54,76.35 120.54,76.76 120.55,76.84 120.54,76.92 120.54,77.2 120.58,77.25 120.61,77.26 120.65,77.25 120.92,77.23 121.04,77.48 121.06,77.56 121.14,77.6 121.86,77.6
GND on TOP (solid shape): 15.22,109.84 15.22,108.95 15.03,108.76 14.05,108.76 13.97,108.8 13.95,108.88 13.95,108.94 13.95,109.34 13.7,109.6 13.44,109.34 13.44,108.94 13.45,108.88 13.43,108.8 13.35,108.76 11.6,108.76 11.48,108.89 11.48,109.9 11.6,110.03 15.03,110.03
GND on TOP (solid shape): 141.21,139.58 141.21,138.16 141.09,138.04 141.09,136.85 140.99,136.76 140.4,136.76 140.11,136.47 140.11,134.99 139.95,134.83 139.38,134.83 138.89,135.32 138.89,135.47 139.17,135.74 139.29,135.74 139.49,135.94 139.49,136.77 139.26,137 139.26,137.24 139.29,137.26 139.33,137.32 139.37,137.35 139.39,137.36 139.49,137.47 139.49,137.49 140.31,138.3 140.31,138.57 140.3,138.57 140.3,138.67 140.06,138.92 131.15,138.92 130.81,138.58 130.81,137.83 131.14,137.49 138.55,137.49 138.7,137.34 138.7,137.02 138.57,136.89 131,136.89 130.75,136.63 130.43,136.63 130.35,136.71 130.35,138.36 130.12,138.6 130.12,139.23 130.22,139.33 130.7,139.33 130.92,139.55 140.12,139.55 140.12,139.55 140.16,139.6 141.19,139.6
GND on TOP (solid shape): 128.76,147.38 131.5,147.38 131.69,147.57 132.4,147.57 132.44,147.53 132.44,147.05 132.06,146.67 129.98,146.67 129.62,146.31 129.62,145.84 129.56,145.78 127.79,145.78 127.72,145.82 127.26,146.28 127.26,146.46 127.28,146.5 127.3,146.55 127.31,146.61 127.31,146.66 127.9,146.66 127.9,146.61 127.9,146.55 127.92,146.5 127.94,146.46 127.97,146.42 128.01,146.38 128.05,146.35 128.1,146.33 128.15,146.31 128.2,146.3 128.25,146.3 128.3,146.31 128.35,146.33 128.4,146.35 128.44,146.38 128.48,146.42 128.51,146.46 128.53,146.5 128.55,146.55 128.56,146.61 128.56,146.66 128.55,146.71 128.53,146.76 128.51,146.8 128.48,146.85 128.44,146.88 128.4,146.91 128.35,146.94 128.3,146.95 128.25,146.96 128.2,146.96 128.15,146.95 128.1,146.94 128.05,146.91 128.01,146.88 127.97,146.85 127.94,146.8 127.92,146.76 127.9,146.71 127.9,146.66 127.31,146.66 127.3,146.72 127.28,146.78 127.26,146.82 127.26,147.36 127.5,147.6 128.54,147.6
GND on TOP (solid shape): outline of 81 points within 9.51,122.67 14.27,129.11
GND on TOP (solid shape): outline of 87 points within 58.73,1.1 90.17,13.33
GND on TOP (solid shape): 12.86,78.88 13.75,78.88 13.84,78.79 13.84,76.13 12.89,75.17 10.92,75.17 9.59,76.49 9.59,76.81 8.47,78.06 7.11,77.06 1.1,77.06 1.01,77.07 0.92,77.09 0.87,77.14 0.87,78.95 1.23,79.31 3.52,79.31 3.96,78.95 4.51,78.81 6.19,78.81 6.95,79.08 7.39,79.75 7.54,79.89 11.85,79.89
GND on TOP (solid shape): outline of 89 points within 130.91,144.51 142.22,146.44
GND on TOP (solid shape): 202.85,30.2 203.21,29.31 204.1,28.95 212.4,28.95 212.4,5.4 211.61,5.4 211.61,5.39 210.31,4.99 209.75,3.75 209.75,2.07 209.31,1.61 209.15,1 209.15,0.25 27.47,0.25 26.84,0.84 26,1.05 25,1.05 24.16,0.84 23.53,0.25 6.35,0.25 6.35,0.76 23.27,0.76 24.05,1.35 25,1.56 26,1.56 26.95,1.35 27.73,0.76 204.37,0.76 205.15,0.54 205.93,0.76 208.64,0.76 208.64,1 208.8,1.73 209.24,2.32 209.24,3.75 209.48,4.75 210.17,5.53 210.75,5.81 211.4,5.91 211.89,5.91 211.89,28.44 204.1,28.44 202.85,28.95 202.34,30.2 202.34,33.95 202.85,33.95
GND on TOP (solid shape): outline of 246 points within 15.03,9 26.33,25.51
GND on TOP (solid shape): outline of 230 points within 126.85,75.81 129.94,78.92
GND on TOP (solid shape): outline of 290 points within 122.29,86.91 130.86,89.76
GND on TOP (solid shape): outline of 589 points within 56.7,93.61 78.35,97.69
GND on TOP (solid shape): outline of 106 points within 44.81,69.81 212.4,184.11
GND on BOTTOM (solid shape): 23.16,100.57 23.16,94.73 22.46,94.03 19.73,94.03 19.03,94.73 19.03,100.06 19.67,100.7 23.03,100.7
GND on BOTTOM (solid shape): 26.87,36.98 26.87,33.52 26.44,33.08 23.46,33.08 23.08,33.47 23.08,37.03 23.27,37.23 26.62,37.23
GND on BOTTOM (solid shape): 36.18,98.5 36.18,95.93 36.11,95.87 31.97,95.87 31.73,96.11 31.73,99.58 32.16,100.01 34.67,100.01
GND on BOTTOM (solid shape): 58.59,8.32 58.59,6.78 58.33,6.51 56.02,6.51 55.83,6.71 55.83,8.34 56.08,8.6 58.31,8.6
GND on BOTTOM (solid shape): 77.32,130.69 77.32,129.14 75.55,127.38 73.88,127.38 72.31,128.94 72.31,129.97 74.38,132.04 75.97,132.04
GND on BOTTOM (solid shape): 109.19,50.53 109.19,48.46 108.87,48.14 105.93,48.14 105.63,48.44 105.63,50.56 105.97,50.89 108.83,50.89
GND on BOTTOM (solid shape): 109.37,14.55 109.37,13.37 109.24,13.23 108.04,13.23 107.96,13.31 107.96,14.55 108.07,14.66 109.27,14.66
GND on BOTTOM (solid shape): 118.39,15.64 118.39,14.24 118.19,14.04 116.04,14.04 115.85,14.24 115.85,15.65 116,15.8 118.22,15.8
GND on BOTTOM (solid shape): 157.13,136.3 157.13,135.3 156.93,135.09 153.95,135.09 153.79,135.25 153.79,136.86 154.12,137.19 156.24,137.19
GND on BOTTOM (solid shape): 166.8,155.43 166.8,153.91 166.67,153.78 165.15,153.78 164.95,153.97 164.95,154.73 165.72,155.5 166.73,155.5
GND on BOTTOM (solid shape): 194.76,160.12 194.76,157.02 194.38,156.64 192.34,156.64 191.97,157.01 191.97,160.12 192.26,160.41 194.47,160.41
GND on BOTTOM (solid shape): 196.88,118.12 196.88,115.85 196.29,115.26 192.35,115.26 191.96,115.65 191.96,117.87 192.46,118.38 196.63,118.38
GND on BOTTOM (solid shape): 207.62,13.21 207.62,11.25 207.2,10.83 200.74,10.83 200.36,11.21 200.36,13.33 200.5,13.46 207.36,13.46
GND on BOTTOM (solid shape): 87.74,124.26 87.72,124.24 87.72,122.82 87.33,122.43 85.47,122.43 85.08,122.81 85.08,124.45 85.33,124.7 87.3,124.7
GND on BOTTOM (solid shape): 110.44,168.62 110.44,164.88 110,164.45 109.07,164.45 108.93,164.59 108.93,168.63 109.13,168.83 110.23,168.83
GND on BOTTOM (solid shape): 28.39,117.11 28.39,114.21 28.08,113.91 27.85,113.91 27.71,114.05 27.71,116.13 27.55,116.29 27.55,117.18 27.61,117.25 28.25,117.25
GND on BOTTOM (solid shape): 28.41,121.29 28.41,121.01 28.29,120.89 27.33,120.89 26.99,121.22 25.49,121.22 25.44,121.27 25.44,121.37 25.5,121.43 28.27,121.43
GND on BOTTOM (solid shape): 95.03,147.62 95.03,145.08 94.8,144.85 93.5,144.85 93.3,145.05 93.3,147.03 93.33,147.05 93.33,147.97 93.44,148.08 94.56,148.08
GND on BOTTOM (solid shape): 131.06,77.07 131.06,76.07 130.89,75.91 128.32,75.91 128.27,75.95 128.27,76.58 128.58,76.89 128.58,77.12 128.68,77.22 130.91,77.22
GND on BOTTOM (solid shape): 163.75,122.22 163.75,118.92 163.56,118.73 160.64,118.73 160.32,119.05 160.32,122.35 160.51,122.54 163.43,122.54
GND on BOTTOM (solid shape): 98.09,141.37 98.09,139.35 97.87,139.13 97.49,139.13 97.45,139.17 97.45,139.17 97.14,139.49 97.14,139.88 95.99,141.03 95.99,141.46 96.12,141.59 97.87,141.59
GND on BOTTOM (solid shape): 142,93.33 142,92.94 141.83,92.77 141.36,92.77 139.17,92.77 139.13,92.8 139.13,93.33 139.36,93.56 139.52,93.56 140.01,94.05 141.27,94.05
GND on BOTTOM (solid shape): 113.51,15.8 113.51,15.2 113.11,14.8 113.11,13.43 112.95,13.28 112.67,13.28 112.52,13.43 112.52,14.76 112.16,15.11 112.16,15.8 112.32,15.95 113.37,15.95
GND on BOTTOM (solid shape): 189.5,167.99 189.5,166.47 189.97,166 189.97,165.56 189.87,165.46 186.64,165.46 186.51,165.6 186.51,166.43 187.17,167.1 187.17,168.1 187.33,168.26 189.23,168.26
GND on BOTTOM (solid shape): 62.6,130.31 62.6,127.33 62.49,127.23 57,127.23 56.99,127.24 56.99,128.04 56.86,128.17 48.19,128.17 47.93,128.43 47.93,130.46 48.29,130.82 62.09,130.82
GND on BOTTOM (solid shape): 116.08,136.66 116.08,136.08 115.94,135.94 115.12,135.94 115.06,135.87 115.06,135.6 114.09,134.64 112.78,134.64 112.64,134.78 112.64,134.98 113.33,135.66 114.2,135.66 115.27,136.74 116,136.74
GND on BOTTOM (solid shape): 126.41,79.7 126.41,79.34 126.62,79.13 126.9,79.13 127,79.03 127,78.71 126.41,78.13 126.41,75.04 126.25,74.88 125.87,74.88 125.72,75.03 125.72,79.71 125.85,79.84 126.27,79.84
GND on BOTTOM (solid shape): 189.6,140.42 189.6,139.93 189.39,139.72 189.39,135.58 189.29,135.48 188.84,135.48 188.36,135.96 185.65,135.96 185.3,136.3 185.3,139.17 184.61,139.86 184.61,140.54 184.71,140.64 189.38,140.64
GND on BOTTOM (solid shape): 20.17,56.57 20.17,53.64 21,52.82 23.92,52.82 24.81,51.93 24.81,48.75 24.3,48.24 18.65,48.24 16.94,49.96 16.94,55.55 14.97,57.52 13.44,57.52 13,57.96 13,59.87 13.38,60.25 16.5,60.25
GND on BOTTOM (solid shape): 38.42,5.88 38.42,1.83 38.11,1.52 33.41,1.52 33.18,1.75 33.18,3.54 33.03,3.7 33.03,5.63 33.22,5.82 33.48,5.82 33.66,5.64 33.66,5.31 33.9,5.08 34.57,5.08 34.89,5.39 36.4,5.39 37.04,6.03 38.27,6.03
GND on BOTTOM (solid shape): 116.57,9.27 116.57,5.96 116,5.39 116,4.32 116.44,3.88 122.59,3.88 122.87,3.6 122.87,2.35 122.37,1.85 114.53,1.85 114.09,2.29 114.09,6.19 115.05,7.15 115.05,8.78 115.63,9.36 116.48,9.36
GND on BOTTOM (solid shape): 123.07,85.11 123.07,84.74 123.14,84.66 123.14,83.26 122.92,83.03 122.92,82.25 122.71,82.05 121.87,82.05 121.75,82.17 121.75,83.31 121.4,83.66 121.4,84.22 121.5,84.32 122.21,84.32 122.32,84.44 122.32,84.82 122.71,85.21 122.96,85.21
GND on BOTTOM (solid shape): 103.09,6.14 103.09,5.93 103.07,5.9 101.81,5.9 101.79,5.88 101.79,4.29 101.81,4.26 104.27,4.26 105.13,3.4 105.13,1.54 104.72,1.13 95.67,1.13 95.29,1.52 95.29,3.27 95.44,3.43 100.97,3.43 101.12,3.58 101.12,6.13 101.18,6.18 103.06,6.18
GND on BOTTOM (solid shape): 132.08,80.22 132.08,79.6 131.81,79.33 130.42,79.33 130.35,79.26 130.35,79.02 130.34,78.96 130.35,78.9 130.35,78.57 130.28,78.5 129.82,78.5 129.74,78.58 129.74,79.25 129.61,79.38 129.25,79.38 129.07,79.56 129.07,80.41 129.17,80.52 131.79,80.52
GND on BOTTOM (solid shape): 102.28,152.33 102.28,150.68 102.05,150.45 100.92,150.45 100.77,150.59 100.56,150.62 100.48,150.64 100.45,150.72 100.45,152.17 100.9,152.62 101.99,152.62
GND on BOTTOM (solid shape): 117.56,171.24 118.12,171.24 118.22,171.14 118.22,169.91 118.1,169.79 115.51,169.79 115.43,169.87 115.43,171.07 115.2,171.31 112.62,171.31 112.21,170.9 112.21,169.99 112.14,169.91 111.59,169.91 111.48,170.02 111.48,171.85 111.78,172.16 113.1,172.16 113.24,172.3 114.84,172.3 114.9,172.36 116.44,172.36
GND on BOTTOM (solid shape): 104.42,136.66 104.42,135.14 104.27,135 103.37,135 103.21,134.84 103.21,134.07 103.35,133.93 104.26,133.93 104.51,133.68 104.51,133.24 104.35,133.07 103.91,133.07 103.91,133.06 103.83,133.06 103.09,133.06 101.72,133.06 101.57,133.22 101.57,136.4 101.94,136.76 104.32,136.76
GND on BOTTOM (solid shape): 200.24,11.03 200.24,10.74 200.13,10.63 199.75,10.63 199.55,10.83 198.39,10.83 198.37,10.81 198.37,9.33 198.46,9.24 199.55,9.24 199.59,9.2 199.59,5.58 199.57,5.56 199.57,5.07 199,4.5 193.9,4.5 193.75,4.66 193.75,5.81 193.96,6.03 197.08,6.03 197.65,6.6 197.65,10.8 197.65,10.8 197.65,11.06 197.74,11.15 200.11,11.15
GND on BOTTOM (solid shape): 108.71,167.23 103.5,167.23 103.5,168.46 106.23,168.46 107.11,168.82 107.48,169.71 107.48,173.5 108.71,173.5
GND on BOTTOM (solid shape): 162.41,174.55 162.41,172.77 162.16,172.51 159.25,172.51 159.17,172.56 159.16,172.65 159.13,172.95 158.9,173.14 158.86,173.15 158.86,174.67 158.99,174.8 162.16,174.8
GND on BOTTOM (solid shape): 136.72,93.65 136.96,93.56 137.21,93.65 137.72,93.65 137.93,93.58 138.14,93.65 138.61,93.65 138.75,93.51 138.75,92.45 138.64,92.34 136.41,92.34 136.27,92.47 136.27,93.53 136.4,93.65
GND on BOTTOM (solid shape): 69.03,11.38 69.03,9.23 68.74,8.94 65.55,8.94 65.1,8.48 65.1,5.98 64.92,5.8 64.92,2.89 64.82,2.79 63.13,2.79 62.62,3.3 62.62,4.09 63.33,4.8 63.89,4.8 64.1,5.01 64.1,6.34 64.51,6.75 64.51,7.51 64.1,7.92 64.1,9.2 63.75,9.56 61.93,9.56 61.64,9.27 61.64,6.36 61.55,6.27 59.93,6.27 59.75,6.45 59.75,10.63 60.85,11.73 68.68,11.73
GND on BOTTOM (solid shape): 177.52,151.62 177.52,150.1 176.77,149.35 176.77,144.84 177.19,144.41 179.54,144.41 179.71,144.24 179.71,143.16 179.65,143.1 176.18,143.1 175.93,142.85 175.93,141.97 176.64,141.26 176.64,136.41 176.13,135.9 176.13,133.6 175.65,133.12 171.47,133.12 170.95,133.64 170.95,135.84 171.26,136.14 172.23,136.14 172.61,136.52 172.61,146.05 172.64,146.07 172.64,149.48 172.61,149.5 172.61,149.52 172.37,149.76 171.84,149.76 170.9,150.7 170.9,151.62 171.5,152.22 176.92,152.22
GND on BOTTOM (solid shape): 137.51,175.35 137.51,173.09 137.26,172.84 136.65,172.84 136.43,173.06 136.43,175.23 136.24,175.42 134.77,175.42 134.48,175.13 134.48,174.04 134.4,173.96 133.11,173.96 132.82,174.26 132.82,174.55 132.7,174.66 132.7,175.25 132.6,175.35 131.89,175.35 131.78,175.25 131.78,174.67 131.7,174.59 131.11,174.59 131.02,174.69 131.02,175.22 130.88,175.36 130.2,175.36 130.07,175.22 130.07,174.72 129.94,174.59 129.94,174.06 129.81,173.92 129.28,173.92 129.12,174.09 129.12,174.86 129.33,175.07 129.33,175.51 129.71,175.9 136.96,175.9
GND on BOTTOM (solid shape): 125.98,130.71 125.98,130.48 126.29,130.17 136.68,130.17 136.89,129.96 136.89,129.39 136.72,129.23 136.71,129.23 136.51,129.23 136.36,129.39 136.35,129.39 136.31,129.44 135.14,129.44 134.99,129.29 134.79,129.29 134.6,129.48 132.85,129.48 132.54,129.17 132.37,129.17 132.18,129.36 131.14,129.36 130.95,129.17 130.79,129.17 130.6,129.36 129.44,129.36 129.29,129.21 129.15,129.21 128.96,129.4 127.89,129.4 127.72,129.23 127.52,129.23 127.33,129.42 126.43,129.42 126,128.99 125.79,128.99 125.66,129.12 125.66,129.34 125.44,129.56 124.82,129.56 124.59,129.79 124.59,130.76 124.78,130.95 125.74,130.95
GND on BOTTOM (solid shape): 130.54,87.87 130.54,86.98 130.48,86.93 130.28,86.93 130.07,86.72 130.07,85.26 130.36,84.98 130.6,84.98 130.74,84.83 130.74,83.63 130.31,83.2 129.71,83.2 129.59,83.08 128.02,83.08 127.88,83.22 127.88,83.56 128.18,83.86 128.9,83.86 129.09,84.05 129.09,84.62 129.22,84.76 129.22,85.15 129.33,85.25 129.33,85.34 129.35,85.41 129.42,85.44 129.71,85.76 129.42,86.08 129.35,86.11 129.33,86.18 129.33,86.67 129.23,86.76 129.23,86.93 129.24,86.94 129.24,87.7 129.45,87.91 129.51,87.92 129.57,87.95 130.45,87.95
GND on BOTTOM (solid shape): 122.79,90.21 122.86,90.21 122.95,90.12 122.95,88.6 123.09,88.46 123.64,88.46 123.81,88.3 123.81,88.01 123.99,87.83 125.15,87.83 125.28,87.96 125.28,88.33 125.56,88.61 125.56,89.16 125.65,89.26 126.1,89.26 126.24,89.11 126.24,88.64 126.42,88.46 127.04,88.46 127.28,88.22 127.28,87.31 127.2,87.23 121.79,87.23 121.67,87.35 121.67,87.39 121.68,87.4 121.71,87.54 121.68,87.68 121.67,87.69 121.67,88.05 121.71,88.13 121.8,88.15 122.16,88.29 122.11,88.68 122.34,88.91 122.34,89.22 122.39,89.39 122.34,89.57 122.34,90.16 122.41,90.23 122.77,90.23
GND on BOTTOM (solid shape): outline of 81 points within 146.53,132.86 148.62,135.69
GND on BOTTOM (solid shape): outline of 95 points within 57.13,95.6 78.06,98.68
GND on BOTTOM (solid shape): 202.85,30.2 203.21,29.31 204.1,28.95 212.4,28.95 212.4,5.4 211.4,5.4 211.33,5.4 211.25,5.4 210.18,4.87 209.75,3.75 209.75,2.07 209.31,1.61 209.15,1 209.15,0.25 27.47,0.25 26.84,0.84 26,1.05 25,1.05 24.16,0.84 23.53,0.25 6.35,0.25 6.35,0.76 23.27,0.76 24.05,1.35 25,1.56 26,1.56 26.95,1.35 27.73,0.76 204.37,0.76 205.15,0.54 205.93,0.76 208.64,0.76 208.64,1 208.8,1.73 209.24,2.32 209.24,3.75 209.48,4.75 210.17,5.53 210.75,5.81 211.4,5.91 211.89,5.91 211.89,28.44 204.1,28.44 202.85,28.95 202.34,30.2 202.34,33.95 202.85,33.95
GND on BOTTOM (solid shape): outline of 87 points within 126.19,131.52 135.94,133.8
GND on BOTTOM (solid shape): outline of 113 points within 10.55,69.81 212.4,184.11
GND on VCC (solid shape): 115.29,6.02 106.48,6.02 106.38,6.49 105.91,6.5 105.91,12.99 115.29,12.99
GND on IN1 (solid shape): 24.43,15.35 24.43,6.91 24.11,6.59 18.21,6.59 17.44,7.35 17.44,10.65 18.46,11.67 18.46,16.18 19.22,16.94 22.84,16.94
GND on IN1 (solid shape): 20.17,58.72 20.17,53.64 21,52.82 22.71,52.82 23.41,52.12 23.41,49.01 22.65,48.24 18.65,48.24 16.94,49.96 16.94,55.55 14.97,57.52 13.44,57.52 13,57.96 13,59.87 13.38,60.25 18.65,60.25
GND on IN1 (solid shape): 13.36,77.91 13.36,75.64 12.89,75.17 10.92,75.17 9.59,76.49 9.59,76.81 8.47,78.06 7.11,77.06 1.1,77.06 1.01,77.07 0.92,77.09 0.87,77.14 0.87,78.95 1.23,79.31 3.52,79.31 3.96,78.95 4.51,78.81 6.19,78.81 6.95,79.08 7.39,79.75 7.54,79.89 11.37,79.89
GND on IN1 (solid shape): 202.85,30.2 203.21,29.31 204.1,28.95 212.4,28.95 212.4,5.4 211.42,5.4 210.24,4.93 209.75,3.75 209.75,2.07 209.31,1.61 209.15,1 209.15,0.25 27.47,0.25 26.84,0.84 26,1.05 25,1.05 24.16,0.84 23.53,0.25 6.35,0.25 6.35,0.76 23.27,0.76 24.05,1.35 25,1.56 26,1.56 26.95,1.35 27.73,0.76 204.37,0.76 205.15,0.54 205.93,0.76 208.64,0.76 208.64,1 208.8,1.73 209.24,2.32 209.24,3.75 209.48,4.75 210.17,5.53 210.75,5.81 211.4,5.91 211.89,5.91 211.89,28.44 204.1,28.44 202.85,28.95 202.34,30.2 202.34,33.95 202.85,33.95
GND on IN1 (solid shape): outline of 113 points within 10.55,69.81 212.4,184.11
GND on IN2 (solid shape): 24.43,15.35 24.43,6.91 24.11,6.59 18.21,6.59 17.44,7.35 17.44,10.65 18.46,11.67 18.46,16.18 19.22,16.94 22.84,16.94
GND on IN2 (solid shape): 13.89,127.73 13.89,126.67 14.46,126.1 14.46,124.39 13.28,124.39 12.99,124.1 12.92,124.07 12.85,124.1 12.44,124.15 12.25,123.78 12.26,123.76 11.1,122.6 9.82,122.6 9.25,123.17 9.25,128.45 9.89,129.08 12.54,129.08
GND on IN2 (solid shape): outline of 126 points within 13,28.62 22.98,60.25
GND on IN2 (solid shape): 202.85,30.2 203.21,29.31 204.1,28.95 212.4,28.95 212.4,5.4 211.4,5.4 211.31,5.4 210.2,4.89 209.75,3.75 209.75,2.07 209.31,1.61 209.15,1 209.15,0.25 27.47,0.25 26.84,0.84 26,1.05 25,1.05 24.16,0.84 23.53,0.25 6.35,0.25 6.35,0.76 23.27,0.76 24.05,1.35 25,1.56 26,1.56 26.95,1.35 27.73,0.76 204.37,0.76 205.15,0.54 205.93,0.76 208.64,0.76 208.64,1 208.8,1.73 209.24,2.32 209.24,3.75 209.48,4.75 210.17,5.53 210.75,5.81 211.4,5.91 211.89,5.91 211.89,28.44 204.1,28.44 202.85,28.95 202.34,30.2 202.34,33.95 202.85,33.95
GND on IN2 (solid shape): outline of 113 points within 10.55,69.81 212.4,184.11
GND on GND (solid shape): outline of 155056 points within 0.26,0.26 212.4,184.11
GND on VCC: 125.43,24.5 125.48,24.44 125.48,21.08 125.2,20.8 117.93,20.8 117.84,20.89 117.84,25.6 122.79,30.55 122.79,44.14 125.81,47.17 129.5,47.17 131.17,48.84 131.17,52.4 135.59,56.82 140.93,56.82 141.94,57.83 144.77,57.83 144.98,57.63 144.98,54.94 144.15,54.11 136.21,54.11 134.11,52 134.11,44.38 133.7,43.98 127.49,43.98 125.43,41.92
GND on VCC: 17.76,111.96 17.06,112.66 17.06,117.79 15.34,119.52 15.34,129.36 15.96,129.98 35.93,129.98 36.08,129.83 36.08,128.67 35.95,128.54 25.78,128.54 25.64,128.39 25.64,126.26 26.07,125.83 26.07,125.15 26.86,124.36 26.86,122.89 26.05,122.09 26.05,122.09 25.76,121.8 25.76,120.17 26.78,119.16 26.78,117.77 27.25,117.3 28.23,117.3 28.3,117.22 28.3,113.55 26.84,112.09 21.24,112.09 21.11,111.96
GND on VCC: 156.22,153 156.14,152.96 153.78,152.96 153.78,153.37 157.97,157.57 157.97,157.93 161.12,161.08 164.35,161.08 164.42,161.06 164.46,160.99 164.81,160.65 165.17,160.99 165.2,161.06 165.27,161.08 165.57,161.08 165.86,161.37 165.86,162.91 165.92,162.95 165.96,163 166.04,163.03 166.11,163 166.76,163.28 166.1,163.53 166.02,163.5 165.95,163.52 165.9,163.57 165.84,163.6 165.81,163.61 165.81,164.17 166.31,164.67 166.73,164.67 166.73,164.67 171.45,164.67 172.27,165.49 174.06,165.49 174.44,165.1 174.44,160.95 174.9,160.5 176.08,160.5 176.16,160.42 176.16,156.2 176.11,156.12 176.01,156.11 175.47,155.76 176.01,155.42 176.11,155.41 176.16,155.32 176.16,153.27 176.6,152.83 177.42,152.83 177.65,152.6 177.65,149.88 175.88,148.11 175.88,136.93 175.62,136.68 175.62,133.65 175.37,133.4 165.72,133.4 165.72,146.97 159.73,152.96 157,152.96 156.92,153 156.9,153.09 156.57,153.56 156.23,153.09
GND on VCC: 109.05,31.93 108.57,32.41 108.57,32.95 108.69,33.23 108.57,33.52 108.57,42.49 110.07,43.99 118.33,43.99 118.33,32.39 117.87,31.93
GND on VCC: 29.57,84.14 39.47,94.04 43.3,94.04 43.31,94.03 43.52,94.03 43.54,94.04 44.57,94.04 44.58,94.03 44.79,94.03 44.81,94.04 70.51,94.04 70.9,94.44 70.91,94.44 71.07,94.6 71.07,99.91 70.72,100.26 70.72,103.91 67.93,106.71 67.93,110.6 68.12,110.79 73.41,110.79 76.58,107.62 83.15,107.62 85.91,110.39 95.91,110.39 100.95,105.35 100.95,104.67 100.06,103.79 100.06,98.75 101.33,97.48 101.33,94.13 100.57,93.37 100.57,89.39 103.15,86.81 106.04,86.81 106.26,86.59 106.28,86.57 106.28,52.22 97.13,43.07 97.13,30 96.14,29 53.97,29 50.09,32.89 50.07,32.91 35.16,32.91 33.27,34.8 31.75,34.8 29.57,36.98
GND on VCC: 185.01,167.47 185.05,167.55 185.15,167.57 185.64,167.93 185.15,168.3 185.05,168.31 185.01,168.4 185.01,169.85 193.38,169.85 193.8,169.5 194.21,169.85 196.2,169.85 196.2,163.5 185.66,163.5 184.89,162.73 183.64,162.73 183.62,162.74 183.62,163.64 183.64,163.66 184.02,163.66 184.21,163.85 184.21,165.92 185.01,166.72
GND on VCC: 121.51,72.57 121.51,67.31 121.5,67.31 114.49,67.31 114.45,67.35 114.45,71.55 115.52,72.62 116.2,72.62 118.22,74.63 120.74,74.63 120.9,74.79 120.9,75.69 120.92,75.71 121.42,75.71 122.3,76.59 123.24,76.59 123.25,76.59 123.25,74.31
GND on VCC: 202.83,20.5 202.8,20.53 202.8,22.29 202.83,22.36 202.9,22.39 203.23,22.61 203.16,22.99 203.14,23.06 203.16,23.13 203.23,23.51 202.9,23.72 202.83,23.75 202.8,23.82 202.8,28.46 202.84,28.49 204.85,28.49 205.16,28.18 211.4,28.18 211.4,20.5
GND on VCC: 193.15,13.91 193.64,14.4 200.79,14.4 201.28,13.91 201.28,8.79 200.42,7.93 194.01,7.93 193.15,8.79
GND on VCC: 87.84,128.19 86.72,129.31 86.72,133.55 87.46,134.29 89.88,134.29 91.37,135.78 91.37,146.07 100.04,154.73 101.86,154.73 101.97,154.63 102.07,154.43 102.26,154.33 102.72,153.87 102.72,146.77 102.47,146.42 102.72,146.06 102.72,133.75 102.41,133.35 102.72,132.95 102.72,129.73 102.33,129.33 98.17,129.33 97.03,128.19
GND on VCC: 200.38,136.31 196.7,139.98 196.7,169.6 196.95,169.85 200.71,169.85 209.34,178.48 211.69,178.48 211.69,139.53 208.98,136.82 204.29,136.82 204.28,136.8 203.68,136.64 203.16,136.31
GND on VCC: outline of 530 points within 1.02,0.32 79.85,129.98
GND on VCC: outline of 132 points within 16.34,89.1 44.94,128.02
GND on VCC: 182.07,133.4 181.87,133.6 181.87,140.66 182.53,141.32 189.67,141.32 190.28,140.71 190.28,133.67 190.01,133.4
GNDA on GND (solid shape): outline of 1065 points within 145.5,40.91 158.55,57.83
GNDA on VCC: 146,40.91 145.65,41.05 145.51,41.4 145.51,51.01 145.5,51.03 145.5,57.45 145.88,57.83 150.37,57.83 151.62,56.58 151.62,53.66 154.29,51 154.29,47.83 155.09,47.03 155.55,47.03 155.56,47.04 157.1,47.04 157.21,46.93 157.21,45.79 158.56,44.44 158.56,41.12 158.55,41.12 158.34,40.91
VCC_VCORE2 on TOP (solid shape): 27.89,91.62 29.35,91.62 29.43,91.54 29.43,90.11 29.13,89.81 27.12,89.81 27.05,89.88 27.05,91.67 27.16,91.78 27.73,91.78
VIN on TOP (solid shape): 191.8,156.01 191.8,153.95 191.09,153.24 191.05,153.23 191,153.21 190.96,153.18 190.92,153.14 190.88,153.1 190.85,153.06 190.83,153.01 190.82,152.97 189.08,151.23 189.08,147.08 188.62,146.62 186.74,146.62 185.96,145.84 185.36,145.84 185.34,145.86 185.34,147.36 184.84,147.86 184.84,148.23 184.94,148.33 185.68,148.33 185.96,148.61 185.96,149.61 186.1,149.75 186.1,151.09 185.96,151.23 185.96,152.62 188.29,152.62 188.29,152.57 188.31,152.51 188.33,152.46 188.35,152.41 188.39,152.37 188.43,152.33 188.47,152.3 188.52,152.27 188.57,152.25 188.63,152.24 188.68,152.24 188.74,152.25 188.79,152.26 188.85,152.28 188.89,152.31 188.94,152.35 188.97,152.39 189,152.44 189.03,152.49 189.04,152.54 189.05,152.6 189.05,152.65 189.04,152.71 189.03,152.76 189,152.81 188.97,152.86 188.94,152.9 188.89,152.93 188.85,152.96 188.79,152.98 188.74,153 188.68,153.01 188.63,153 188.57,152.99 188.52,152.97 188.47,152.95 188.43,152.92 188.39,152.88 188.35,152.83 188.33,152.79 188.31,152.73 188.29,152.68 188.29,152.62 185.96,152.62 185.96,155.93 186.26,156.22 191.59,156.22
VIN on BOTTOM (solid shape): 188.95,149.47 188.95,146.9 188.69,146.64 186.5,146.64 186.09,146.23 185.14,146.23 184.68,146.69 184.68,149.25 185.56,150.13 188.29,150.13
24737_SN on BOTTOM (solid shape): 169.69,155.48 169.69,153.82 169.45,153.58 167.47,153.58 167.18,153.87 167.18,155.33 167.59,155.74 169.42,155.74
+1.1_AVDDL on TOP (solid shape): 37.76,28.88 37.76,27.35 37.7,27.29 37.25,27.29 36.94,27.61 36.93,27.6 36.57,27.6 36.46,27.71 36.46,28.4 37,28.94 37.7,28.94
+1.1_AVDDL on TOP (solid shape): 30.19,25.02 30.19,24.12 30.13,24.06 30,24.06 29.96,24.1 29.12,24.1 28.63,23.61 28.63,23.6 28.46,23.43 28.46,22.18 28.95,21.69 28.95,20.91 28.77,20.73 28.77,18.55 29.37,17.95 32.54,17.95 32.6,17.88 32.6,16.76 32.51,16.66 28.65,16.66 27.69,17.62 27.69,23.54 27.69,23.54 27.69,23.93 28.57,24.82 29.73,24.82 29.99,25.08 30.13,25.08
+1.1_AVDDL on IN1 (solid shape): 33.76,34.12 33.76,32.79 33.6,32.64 33.1,32.64 32.89,32.85 32.89,33.37 32.49,33.76 29.02,33.76 28.77,33.52 28.77,33.04 28.73,32.96 28.65,32.94 28.22,32.59 28.65,32.24 28.73,32.22 28.77,32.14 28.77,27.79 28.71,27.7 28.6,27.72 28,27.46 28.6,27.21 28.71,27.23 28.77,27.13 28.77,22.62 28.74,22.61 28.56,22.29 28.74,21.98 28.77,21.97 28.77,21.14 28.38,20.75 27.62,20.75 27.22,21.16 27.22,29.66 27.25,29.74 27.33,29.76 27.74,30.11 27.33,30.47 27.25,30.49 27.22,30.57 27.22,34.27 27.56,34.61 33.27,34.61
+1.1_AVDDL_L on TOP (solid shape): 32.34,22.64 32.34,18.54 31.96,18.16 29.46,18.16 28.98,18.64 28.98,20.58 29.14,20.75 29.66,20.75 29.85,20.57 29.85,19.06 30,18.92 31.21,18.92 31.39,19.1 31.39,20.83 31.06,21.16 31.06,22.75 31.17,22.86 32.12,22.86
+1.1_DVDDL on TOP (solid shape): 33.8,20.6 33.8,19.48 33.95,19.33 39.29,19.33 39.42,19.21 39.42,18.01 39.24,17.84 38.18,17.84 37.75,17.41 37.75,16.55 37.51,16.31 33.08,16.31 32.81,16.59 32.81,20.59 32.93,20.71 33.7,20.71
+2.7_AVDDH on TOP (solid shape): 37.76,31.73 37.76,31.23 37.64,31.1 37.07,31.1 36.88,30.91 36.88,30.66 36.73,30.51 36.22,30.51 36.15,30.58 36.15,31.7 36.22,31.77 37.73,31.77
+CHGRTC on TOP (solid shape): 197.51,28.01 197.51,27.07 197.31,26.88 195.04,26.88 195,26.92 195,27.89 195.31,28.19 197.33,28.19
+CPU_CORE on TOP (solid shape): outline of 2822 points within 45.64,97.75 77.79,126.38
+CPU_CORE on BOTTOM (solid shape): outline of 6863 points within 27.68,93.32 80.82,126.34
+CPU_CORE on VCC (solid shape): outline of 6272 points within 39.54,94.55 70.56,123.93
+CPU_CORE on IN1 (solid shape): outline of 349 points within 38.8,109.05 65.01,127.62
+CPU_CORE on IN2 (solid shape): outline of 1733 points within 56.51,99.92 70.29,114.94
+DP_V33 on TOP (solid shape): 81.77,131.05 81.77,130.67 81.33,130.22 81.33,127.81 81.2,127.68 79.83,127.68 79.62,127.9 79.62,131.25 79.74,131.37 81.45,131.37
+DP_V33 on BOTTOM (solid shape): 83.6,129.58 83.6,127.79 83.23,127.43 80.82,127.43 80.63,127.62 80.63,128.83 80.82,129.02 81.61,129.02 81.62,129.01 81.71,128.99 81.81,128.98 81.84,128.97 81.86,128.94 82.07,128.65 82.43,128.7 82.56,128.92 82.51,129.17 82.51,129.52 82.65,129.66 83.51,129.66
+DP_VDDR on TOP (solid shape): 147.94,131.87 147.94,130.99 147.81,130.86 145.52,130.86 145.37,131.02 145.37,131.97 145.52,132.13 147.68,132.13
+DP_VDDR on TOP (solid shape): 144.65,129.26 144.65,129.25 144.84,129.07 145.11,129.09 145.12,129.09 145.27,128.94 145.27,128.48 145.17,128.38 143.75,128.38 143.68,128.46 143.68,128.87 143.43,129.12 143.09,129.12 142.94,129.26 142.94,129.61 143.14,129.8 144.1,129.8
+DP_VDDR on BOTTOM (solid shape): outline of 201 points within 140.99,127.7 146.01,130.31
+EC_VCCA on TOP (solid shape): 159.1,91.08 159.1,89.47 158.95,89.32 156.8,89.32 156.73,89.39 156.73,90.99 157.08,91.34 158.84,91.34
+LCDVDD_CONN on TOP (solid shape): 93,144.99 93.3,144.82 93.52,144.69 94.42,144.04 94.44,143.95 94.07,143.44 93.91,143.45 92.72,144.28 92.39,144.28 91.82,144.28 91.3,144.8 91.3,145.46 91.67,145.83 92.16,145.83
+LCDVDD_CONN on BOTTOM (solid shape): 93.12,146.87 93.12,143.58 93.01,143.47 91.46,143.47 91.32,143.61 91.32,144.38 91,144.7 90.09,144.7 89.8,145 89.8,146.68 90.28,147.16 92.83,147.16
+LDO_1.8V on TOP (solid shape): 162.34,48 162.34,47.13 162.28,47.06 161.58,47.06 161.15,47.49 160.55,47.49 160.5,47.54 160.5,48.05 160.59,48.13 162.21,48.13
+LDO_OUT_3.3V on TOP (solid shape): 152.29,48.85 152.3,48.85 152.3,48.37 152.24,48.31 151.05,48.31 150.37,47.63 150.37,47.04 150.3,46.97 149.63,46.97 149.58,47.02 149.58,47.9 150.59,48.91 152.23,48.91
+LEDVDD on TOP (solid shape): 99.83,153.88 100.81,153.16 100.88,153.12 100.89,153.12 100.92,153.08 100.92,152.69 100.25,152.02 100.01,152.02 98.98,152.73 98.94,152.97 99.47,153.84 99.5,153.89 99.76,153.93
+LEDVDD on BOTTOM (solid shape): 100.99,153.5 100.99,152.95 100.25,152.22 100.25,150.74 99.99,150.47 97.59,150.47 97.45,150.61 97.45,152.05 97.66,152.25 97.92,152.25 99.68,154.02 100.47,154.02
+LX on TOP (solid shape): 33.97,24.85 34.32,24.85 35.91,23.26 39.08,23.26 39.45,22.9 39.45,20.59 39.19,20.33 35.64,20.33 35.64,20.33 35.42,20.33 35.04,20.71 35.04,22.94 33.94,24.04 33.66,24.04 33.57,24.13 33.57,25 33.65,25.08 33.74,25.08
+MPV18 on TOP (solid shape): outline of 727 points within 121.66,148.24 130.59,153.03
+PCH_USB_DCPSUS1 on BOTTOM (solid shape): 128.05,89.59 128.05,88.26 128.41,87.9 128.69,87.9 128.69,87.89 128.81,87.87 128.92,87.89 128.93,87.9 129.09,87.9 129.15,87.84 129.15,87.54 129.14,87.54 129.13,87.44 129.14,87.34 129.15,87.33 129.15,86.98 129.03,86.86 128.46,86.86 128.19,87.13 127.51,87.13 127.41,87.23 127.41,89.56 127.56,89.72 127.92,89.72
+PCH_USB_DCPSUS2 on BOTTOM (solid shape): 128.88,80.21 128.88,79.57 129.16,79.28 129.32,79.28 129.49,79.12 129.49,78.6 129.36,78.47 129.05,78.47 128.82,78.57 128.58,78.47 128.09,78.47 127.99,78.57 127.99,79.18 128.15,79.33 128.15,79.78 128,79.93 127.73,79.93 127.58,80.08 127.58,80.29 127.74,80.45 128.63,80.45
+PCH_VCC on TOP (solid shape): 121.47,75.7 121.59,75.7 121.69,75.6 121.69,75.4 121.56,75.27 121.56,73.93 121.33,73.7 119.95,73.7 119.84,73.59 118.77,73.59 117.43,72.25 117.43,69.17 117.25,68.99 117.25,68.97 116.55,68.97 116.4,69.12 116.4,72.73 118.24,74.57 120.9,74.57 121.04,74.71 121.04,75.59 121.16,75.7 121.47,75.7
+PCH_VCCCFUSE on TOP (solid shape): 138.91,72.87 138.91,71.61 138.67,71.38 137.5,71.38 137.5,71.12 136.98,70.59 135.59,70.59 135.52,70.65 135.52,71.62 135.61,71.7 136.18,71.7 136.37,71.89 136.37,72.91 136.63,73.17 138.6,73.17
+PCH_VCCCLK on TOP (solid shape): outline of 112 points within 124.31,79.01 127.32,82.59
+PCH_VCCCLK on BOTTOM (solid shape): 125.58,80.89 125.58,76.44 125.58,76.44 125.58,75.02 125.8,74.79 126.37,74.79 126.47,74.69 126.47,74.13 126.35,74 125.83,74 125.72,73.89 125.69,73.89 125.69,73.89 124.47,73.89 124.4,73.96 124.4,75.61 124.91,76.12 124.91,80.9 125.03,81.02 125.45,81.02
+PCH_VCCCLK3_3 on TOP (solid shape): 131.22,83.54 131.22,82.34 131.4,82.17 131.4,81.91 131.27,81.79 131.11,81.79 131.1,81.79 130.99,81.82 130.87,81.79 130.86,81.79 130.51,81.79 130.46,81.81 130.39,81.82 130.21,82 130.21,83.59 130.31,83.69 131.07,83.69
+PCH_VCCCLK3_3 on BOTTOM (solid shape): outline of 155 points within 127.77,79.8 136.55,82.35
+PCH_VCCDSW3_3 on BOTTOM (solid shape): 137.4,88.87 137.4,88.21 137.37,88.19 137.19,87.99 137.2,87.72 137.2,87.71 137.2,87.65 137.13,87.57 136.79,87.57 136.52,87.3 136.52,86.78 136.5,86.76 135.97,86.76 135.85,86.88 135.85,87.64 135.9,87.69 136.26,87.66 136.45,87.97 136.45,88.24 136.61,88.41 136.61,88.85 136.75,88.99 137.29,88.99
+PCH_VPROC on BOTTOM (solid shape): 124.06,90.1 124.06,88.87 124.06,88.87 124.06,88.75 124.17,88.64 124.17,88.59 124.22,88.59 124.44,88.37 124.44,88.07 124.35,87.99 124.07,87.99 123.93,88.12 123.93,88.35 123.71,88.57 123.31,88.57 123.24,88.65 123.24,90.11 123.3,90.18 123.98,90.18
+PCIE_VDDR on TOP (solid shape): 139.44,128.64 139.44,124.94 139.61,124.77 139.61,123.52 139.56,123.47 138.64,123.47 138.33,123.77 138.33,126.61 138,126.95 138,128.16 138.63,128.8 139.28,128.8
+RTCVCC on BOTTOM (solid shape): 141.46,92.49 141.46,91.49 141.31,91.35 140.56,91.35 140.41,91.2 140.41,90.53 140.28,90.4 138.88,90.4 138.75,90.53 138.75,91.23 138.59,91.4 136.61,91.4 136.4,91.19 136.14,91.19 135.92,90.97 135.83,90.84 135.8,90.68 135.76,90.61 135.69,90.58 135.34,90.58 135.21,90.71 135.21,91.35 136.01,92.14 138.73,92.14 139.23,92.64 141.31,92.64
+SPLL_VDDC on BOTTOM (solid shape): outline of 411 points within 146.61,149.65 154.85,153.46
+SPV18 on TOP (solid shape): 149.1,150.02 149.88,150.02 149.95,149.96 149.95,148.93 149.7,148.68 148.39,148.68 148.35,148.7 148.31,148.72 148.25,148.79 148.26,148.87 147.96,149.38 147.72,148.85 147.73,148.74 147.64,148.68 146.35,148.68 146.11,148.91 146.11,150.05 146.21,150.15 148.98,150.15
+SWR_LX on TOP (solid shape): 86.05,124.94 86.05,120.75 85.88,120.58 84.88,120.58 84.69,120.77 84.69,125.15 85,125.46 85.54,125.46
+SWR_V12 on TOP (solid shape): 83.91,126.18 83.91,120.74 83.83,120.67 82.11,120.67 81.89,120.89 81.89,126.24 82.06,126.41 83.68,126.41
+SWR_VDD on TOP (solid shape): 87.62,125.56 88.22,125.56 88.31,125.47 88.31,124.73 88.17,124.59 86.48,124.59 86.31,124.76 86.31,125.33 85.88,125.76 85.88,126.89 85.98,126.99 86.19,126.99
+SWR_VDD on BOTTOM (solid shape): 88.91,127.95 88.91,127.24 88.68,127.01 87.46,127.01 87.43,126.98 87.41,126.97 87.12,126.67 87.31,126.3 87.31,125.04 87.15,124.88 85.14,124.88 85.01,125.01 85.01,127.3 85.92,128.21 88.65,128.21
+TSVDD on TOP (solid shape): 145.8,130.12 145.8,129.62 146.64,128.79 146.98,128.79 147.01,128.76 147.01,128.15 146.92,128.05 146.23,128.05 146.01,128.27 145.52,128.27 145.45,128.34 145.45,129.16 145.28,129.33 145.28,129.35 145.09,129.69 144.71,129.61 144.57,129.61 144.22,129.97 143.72,129.97 143.62,130.08 143.62,131.2 143.77,131.35 144.57,131.35
+USB3_VCCA on TOP (solid shape): outline of 142 points within 14.11,29.87 22.08,52.5
+USB3_VCCA on BOTTOM (solid shape): 20.73,36.21 20.73,35.08 21.29,34.52 21.29,33.39 20.88,32.98 18.15,32.98 17.65,33.48 17.65,36.23 17.95,36.53 20.41,36.53
+USB_VCCB on TOP (solid shape): 203.94,154.48 203.94,152.51 203.63,152.19 203.63,149.91 203.31,149.59 201.91,149.59 201.78,149.72 201.78,154.29 202.17,154.67 203.75,154.67
+USB_VCCB on TOP (solid shape): 200.79,135.21 200.79,119.85 200.01,119.07 198.67,119.07 198.33,119.41 198.33,121.92 199.54,125.17 198.35,128.43 198.33,128.45 198.33,128.47 196.62,130.18 196.62,135.64 197,136.02 199.98,136.02
+USB_VCCB on BOTTOM (solid shape): 201.3,130.77 201.3,110.9 201,110.6 197.15,110.6 196.95,110.79 196.95,115.22 197.33,115.61 197.33,121.03 199.53,125.52 196.74,129.68 196.74,129.68 195.4,131.02 195.4,132.3 195.96,132.85 199.22,132.85
+USB_VCCB on IN1 (solid shape): 196.71,137.39 196.71,137.05 197.96,135.8 197.96,131.59 197.7,131.34 196.23,131.34 195,132.57 195,137.63 195.16,137.78 196.32,137.78
+USB_VCCB on IN1 (solid shape): outline of 183 points within 196.48,148.43 203.21,151.82
+VGA_B+ on TOP (solid shape): 180.52,147.81 180.52,146.67 179.69,145.85 179.69,145.71 179.69,145.7 179.64,145.52 179.69,145.34 179.69,139.91 179.33,139.55 174.79,139.55 173.75,138.51 173.04,138.51 172.84,138.7 172.84,143.24 173.08,143.48 177.34,143.48 178.06,144.21 178.06,147.88 178.38,148.19 180.13,148.19
+VGA_B+ on BOTTOM (solid shape): 179.68,142.65 179.68,141.9 178.99,141.21 178.99,139.78 178.38,139.17 177.08,139.17 176.85,139.4 176.85,141.51 176.85,141.63 176.24,142.24 176.24,142.68 176.26,142.7 179.64,142.7
+VGA_B+ on BOTTOM (solid shape): 178.84,148.59 179.97,148.59 179.99,148.58 180.32,148.58 180.55,148.35 180.55,147.42 180.55,147.41 180.55,146.72 180.4,146.57 179.14,146.57 178.52,147.19 177.31,147.19 176.91,147.59 176.91,149.11 177.08,149.28 177.15,149.28 177.16,149.29 178.14,149.29
+VGA_CORE on TOP (solid shape): outline of 86 points within 131.08,134.74 140.2,138.67
+VGA_CORE on TOP (solid shape): outline of 1702 points within 129.87,137.39 167.54,147.77
+VGA_CORE on BOTTOM (solid shape): 132.08,147.99 132.39,147.8 132.7,147.99 132.71,148.02 132.97,148.02 133.59,147.4 133.59,147.21 133.46,147.09 132.62,147.09 132.35,146.82 132.35,146.58 133.13,145.8 133.13,145.55 132.95,145.36 132.76,145.36 131.96,146.16 131.69,146.16 129.98,144.44 129.72,144.44 129.59,144.57 129.59,145.83 131.78,148.02 132.06,148.02
+VGA_CORE on BOTTOM (solid shape): 158.38,149.6 158.68,149.6 159,149.42 159.3,149.62 162.87,149.62 163,149.49 163,148.43 162.86,148.28 160.52,148.28 160.49,148.25 160.49,147.53 160.54,147.47 162.92,147.47 162.99,147.4 162.99,136.04 162.88,135.93 160.4,135.93 160.32,135.86 160.32,135.16 160.39,135.09 162.69,135.09 162.86,134.92 162.86,133.63 162.78,133.55 162.41,133.59 162.18,133.3 162.17,133.26 159.84,133.26 159.18,133.93 159.18,134.72 156.55,137.35 151.71,137.35 151.21,137.84 151.21,142.83 151.8,143.41 154.63,143.41 155.1,143.89 156.36,143.89 157.45,144.98 157.45,149.07 158.01,149.62 158.36,149.62
+VGA_CORE on IN1 (solid shape): outline of 4211 points within 128.02,134.52 164.45,147.8
+VGA_CORE on IN2 (solid shape): outline of 2738 points within 130.06,134.67 142.72,147.73
+VGA_CORE on VCC: 144.95,133.68 143.51,135.13 131.32,135.13 131.05,135.4 131.05,147.14 131.41,147.5 147.9,147.5 152.85,152.45 159.52,152.45 165.21,146.75 165.21,133.9 164.99,133.68
+VREF_1V65 on TOP (solid shape): 152.55,46.94 152.55,44.43 152.49,44.37 152,44.37 151.58,43.96 151.58,43.24 151.51,43.17 150.94,43.17 150.84,43.27 150.84,44.18 151.82,45.16 151.82,46.56 152.32,47.05 152.43,47.05
+VREF_CA on TOP (solid shape): 77.52,39.23 77.52,38.69 77.25,38.42 76.78,38.42 76.28,37.92 76.28,36.14 76.16,36.02 75.6,36.02 75.55,36.06 75.55,36.51 75.2,36.87 74.62,36.87 74.52,36.96 74.52,38.81 74.66,38.95 75.55,38.95 75.97,39.37 77.39,39.37
+VREF_CA_R on TOP (solid shape): outline of 120 points within 51,77.87 54.63,81.8
+VREF_DQ_DIMMA on TOP (solid shape): 32.91,59.5 32.91,57.49 33.17,57.24 35.13,57.24 35.13,57.24 35.21,57.17 35.21,56.32 35.16,56.23 35.06,56.23 34.66,56.17 34.57,55.78 34.56,55.69 34.48,55.64 33.46,55.64 33.26,55.84 33.26,56.23 32.96,56.53 32.38,56.53 32.2,56.71 32.2,56.73 32.23,56.89 32.21,57.06 32.2,57.07 32.2,58.26 32.15,58.32 32.15,59.57 32.2,59.62 32.79,59.62
+VREF_DQ_DIMMA_R on TOP (solid shape): outline of 301 points within 80.57,94.76 87.27,96.23
+VREF_DQ_DIMMB on TOP (solid shape): 31.9,59.57 31.9,58.54 31.72,58.37 30.39,58.37 30.31,58.44 30.31,58.96 31,59.65 31.82,59.65
+VREF_DQ_DIMMB on TOP (solid shape): 36.2,46.29 36.2,45.72 35.84,45.36 35.84,44.82 35.68,44.66 34.67,44.66 34.58,44.67 34.48,44.67 33.67,44.67 33.61,44.67 33.48,44.66 33.32,44.82 33.32,46.19 33.42,46.29 34.02,46.29 34.13,46.4 36.1,46.4
+VREF_DQ_DIMMB_R on TOP (solid shape): outline of 443 points within 79.46,92.83 87.31,94.64
+VSB on TOP (solid shape): 192.17,60.17 192.17,59.62 192.04,59.49 190.6,59.49 190.6,59.5 190.44,59.5 190.26,59.68 190.26,60.11 190.43,60.28 192.06,60.28
ADP_ID on TOP (solid shape): 196.65,79.74 196.65,77.59 196.45,77.39 195.69,77.39 195.63,77.45 195.63,79.8 195.71,79.89 196.5,79.89
APDIN on BOTTOM (solid shape): 196.29,155.81 196.29,149.07 196.07,148.85 191.72,148.85 191.32,149.26 191.32,152.57 191.52,152.89 191.32,153.22 191.32,155.7 191.85,156.23 195.87,156.23
APDIN1 on TOP (solid shape): 193.02,151.64 193.02,146.68 192.75,146.42 189.99,146.42 189.71,146.7 189.71,150.91 191.42,152.63 192.02,152.63
APDIN1 on BOTTOM (solid shape): 191.03,151.97 191.03,148.95 191.48,148.49 194.71,148.49 195.18,148.02 195.18,144.14 194.97,143.93 192.23,143.93 191.98,144.18 191.98,145.73 191.69,146.02 189.41,146.02 189.12,146.3 189.12,152.14 189.27,152.29 190.71,152.29
B+ on TOP (solid shape): 60.42,2.87 60.42,1.64 60.17,1.39 58.04,1.39 57.8,1.63 57.8,2.88 58.06,3.14 60.15,3.14
B+ on TOP (solid shape): 79.96,136.74 79.96,135.94 78.25,134.22 76.99,134.22 75.26,135.95 75.26,137.13 76.93,138.8 77.9,138.8
B+ on TOP (solid shape): 93.37,3.71 93.37,1.5 93.19,1.32 92.03,1.32 91.85,1.51 91.85,3.66 92.04,3.86 93.22,3.86
