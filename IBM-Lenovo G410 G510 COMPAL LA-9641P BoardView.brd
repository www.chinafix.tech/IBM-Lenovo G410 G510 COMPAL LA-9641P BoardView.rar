# Allegro board IBM-Lenovo G410 G510 COMPAL LA-9641P BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
B_BA2: length 55.7
  TOP w0.102: v2(146.41,168.9) 146.41,168.63 146.34,168.57 146.07,168.57 146,168.63 146,169.2 146.32,169.52 146.5,169.52 146.57,169.45 146.57,169.31 146.74,169.14 146.9,169.14 146.98,169.21 146.98,169.97 146.88,170.06 146.8,170.06 UV12.M3 ; UV9.M3 130.78,166.77 130.7,166.85 130.7,167.19 130.82,167.31 131.41,167.31 131.68,167.57 131.68,168.1 131.6,168.17 131.36,168.17 131.27,168.08 v2(131.27,167.83)
  IN1 w0.127: v2(146.41,168.9) 146.41,168.81 146,168.4 146,168.03 146.18,167.84 146.18,167.64 146.1,167.55 145.79,167.55 145.64,167.7 145.44,167.7 145.07,167.33 144.94,167.33 144.72,167.55 144.57,167.55 144.38,167.36 144.38,167.23 144.61,167 144.61,166.86 144.39,166.65 144.25,166.65 144.05,166.85 143.87,166.85 143.73,166.71 143.73,166.53 143.64,166.44 143.01,166.44 141.26,164.69 140.28,164.69 140.08,164.49 139.21,164.49 v2(139.11,164.59) 138.8,164.59 138.19,163.99 137.76,163.99 137.45,164.3 137.45,164.43 136.78,165.1 135.48,165.1 134.69,165.89 134.45,165.89 134.32,166.02 134.32,166.38 134.2,166.51 133.94,166.51 133.82,166.38 133.82,166.02 133.69,165.89 132.98,165.89 132.6,166.27 132.6,166.45 132.79,166.63 132.79,166.81 132.61,166.99 132.43,166.99 132.24,166.81 132.06,166.81 131.27,167.6 v2(131.27,167.83)
  IN2 w0.102: v2(138.09,151.46) 138.09,151.3 137.93,151.13 137.76,151.13 137.68,151.21 137.68,152.38 137.78,152.47 137.91,152.47 138.02,152.59 138.02,152.79 137.93,152.88 137.75,152.88 137.68,152.95 137.68,153.07 138.36,153.74 138.55,153.74 138.64,153.65 138.64,153.3 138.7,153.24 138.91,153.24 138.97,153.3 138.97,154.12 138.77,154.32 138.77,154.94 138.88,155.05 139.44,155.05 139.54,155.15 139.54,156.78 139.66,156.91 139.66,157.31
  IN2 w0.249: 139.66,157.31 139.66,161.5 139.14,162.02 139.14,163.69 139.3,163.85 139.5,163.85 139.63,163.97 139.63,164.7 139.5,164.82 139.34,164.82 v2(139.11,164.59)
  BOTTOM w0.102: v2(131.27,167.83) 131.27,167.95 130.89,168.33 130.89,168.87 130.99,168.97 131.24,168.97 131.34,169.08 131.34,169.28 131.24,169.38 130.99,169.38 130.89,169.48 130.89,169.89 UV10.M3 ; UV11.M3 146.55,166.77 146.49,166.82 146.49,167.09 146.58,167.18 147.17,167.18 147.33,167.34 147.33,167.46 147.22,167.56 146.56,167.56 146.5,167.62 146.5,167.76 146.79,168.05 146.79,168.41 146.41,168.79 v2(146.41,168.9) ; v2(138.09,151.46) 137.85,151.46 137.46,151.07 UV1.AA8
BATT+:
  vias: v2(174.63,169.92) v2(174.63,169.3) v2(174.66,168.7) v2(175.24,168.7) v2(175.31,169.92) v2(175.27,169.29) v2(175.94,169.92) v2(175.89,169.29) v2(175.9,168.69) v2(176.59,169.9) v3(174.33,167.8)
BATT_CHG_LED#: length 126.6
  TOP w0.102: v1(182.51,44.05) 182.04,43.59 v2(182.04,43.25) JLED1.8 ; U31.90 161.75,78.96 162.3,79.5 162.63,79.5 163.05,79.09 v2(163.05,79.08) ; LED5.1 v2(150.59,1.6)
  BOTTOM w0.102: v2(150.59,1.6) 151,1.19 160.53,1.19 163.2,3.87 181.67,3.87 181.86,3.87 182.64,4.65 182.64,42.37 182.45,42.56 182.45,42.84 v2(182.04,43.25) 181.12,43.25 177.43,46.94 177.43,53.11 174.49,56.04 168.4,56.04 166.26,58.19 166.26,70.17 163.14,73.29 163.14,77.54 162.69,77.98 162.69,78.72 v2(163.05,79.08)
BATT_LEN#: length 36.8
  TOP w0.102: U31.38 172.79,89.72 173.17,89.34 173.86,89.34 v2(174.18,89.02)
  TOP w0.254: v2(184.83,71.43) PQ205.2 184.06,71.88 182.98,72.96 v3(181.65,72.96) 181.44,72.76 PR220.1
  IN1 w0.127: v2(184.64,89.48) 184.46,89.3 184.46,78.05 184.83,77.68 v2(184.83,71.43)
  IN2 w0.127: v2(174.18,89.02) 174.5,89.35 182.38,89.35 182.5,89.48 v2(184.64,89.48)
BATT_LOW_LED#: length 122.5
  TOP w0.102: JLED1.7 179.07,44.25 v2(179.03,44.21) ; LED2.1 151.68,4.23 v2(151.78,4.33) ; v1(157.84,78.03) 157.92,78.1 159.13,78.1 159.48,77.76 U31.93 161.86,77.76 v2(162.11,77.51)
  BOTTOM w0.102: v2(162.11,77.51) 162.68,76.93 162.68,73.1 165.8,69.98 165.8,58 168.21,55.59 174.31,55.59 176.97,52.92 176.97,46.27 v2(179.03,44.21) 182.1,41.14 182.1,4.75 181.67,4.33 v2(151.78,4.33)
BATT_OUT: length 117.1
  TOP w0.102: v3(182.44,148.82) 182.55,148.93 v2(183.31,148.93)
  TOP w0.254: PQ202.6 181.84,65.65 182.4,66.21 182.4,68.17 182.19,68.38 PR214.1 182.2,69.02 183.17,69.02 183.41,69.26 PQ205.1 183.41,70.42 183.6,70.61 184.55,70.61 184.83,70.34 v2(184.83,69.83)
  IN1 w0.254: v2(184.83,69.83) 184.83,69.85 185.41,70.42 185.41,78.03 184.78,78.66 184.78,82.11 186.17,83.5 186.17,87.34 185.62,87.89 185.62,113.84 v2(185.81,114.03)
  IN2 w0.254: v2(185.81,114.03) 185.88,114.11 185.88,120.42 185.2,121.1 185.2,121.83 183.89,123.14 183.89,125.18 185.03,126.31 186.1,126.31 193.58,133.79 193.58,137.08 193.81,137.31 193.81,148.3 190.38,151.74 188.23,151.74 185.42,148.93 v2(183.31,148.93)
  BOTTOM w0.254: PQ314.2 177.86,152.47 178.49,151.84 178.49,149.89 PQ306.2 180.1,149.16 180.33,148.93 v2(183.31,148.93)
BATT_TEMP: length 195.3
  TOP w0.102: U31.63 162.79,92.47 162.79,92.47 C663.1 162.14,93.47 v2(161.39,93.47) ; v2(172.07,109.92) 171.25,109.1 v2(162.05,109.1)
  TOP w0.254: v2(190.48,118.36) 190.48,116.16 188.45,114.13 PU101.3 ; v2(185.45,81.72) 182.99,81.72 182.49,81.23 182.49,75.46 183.35,74.61 189.16,74.61 189.97,73.8 190.51,73.8 190.96,74.25 192.27,74.25 192.59,73.94 192.59,69.05 192.03,68.49 188.94,68.49 188.21,67.75 PU201.3
  IN1 w0.254: v2(185.45,81.72) 185.45,82.24 186.55,83.34 186.55,87.5 186,88.05 186,112.94 186.55,113.49 186.55,114.43 v2(190.48,118.36)
  IN2 w0.127: 186.8,118.36 186.8,113.32 183.86,110.37 172.52,110.37 v2(172.07,109.92) ; 186.8,118.36 v2(190.48,118.36) ; 186.8,118.36 186.8,123.53 188.04,124.77 188.04,127.08 194.41,133.45 194.41,136.73 194.64,136.97 194.64,148.64 191.89,151.39 191.89,165.76 187.53,170.12 186.59,170.12 186.44,169.97 185.76,169.97 v2(185.38,170.36)
  BOTTOM w0.102: v2(162.05,109.1) 162.05,101.47 v1(161.7,101.13) 161.7,97.39 161.04,96.73 161.04,93.81 v2(161.39,93.47)
  BOTTOM w0.254: v2(185.38,170.36) 184.51,170.36 184.22,170.65 PR207.2
BBS_BIT0_R: length 9.4
  TOP w0.089: 117.6,96.74 119.68,94.66 119.9,94.66 120.21,94.36 120.21,93.8 U4.AU2
  TOP w0.102: 117.6,96.74 117.6,99.03 v1(117.08,99.55) 116.04,100.59 RP15.3
BBS_BIT1: length 29.6
  TOP w0.102: v1(123.92,103.93) 123.5,103.51 v2(123.5,103.38) 123.54,103.38 R182.1 ; v2(134.15,89.7) 134.4,89.96 U4.C10
  IN1 w0.089: 120.81,94.79 120.81,94.61 122.75,92.67 122.75,90.38 122.96,90.18 125.66,90.18 126.66,89.18 127.45,89.18 127.68,88.95 133.4,88.95 v2(134.15,89.7)
  IN1 w0.127: v2(123.5,103.38) 123.5,103.13 122.39,102.02 122.39,100.8 120.81,99.22 120.81,94.9 120.81,94.89 120.81,94.79
BEEP#: length 42.6
  TOP w0.102: CA37.1 168.04,55.12 170.66,57.73 171.48,57.73 v2(171.89,57.33) ; v2(175.14,85.75) 175.55,85.34 175.56,85.34 175.57,85.36 U31.23
  BOTTOM w0.102: v2(175.14,85.75) 176.23,84.66 176.23,83.97 176.58,83.62 176.58,70.2 v1(174.02,67.65) 174.02,62.03 171.89,59.9 v2(171.89,57.33)
BKOFF#: length 154.7
  TOP w0.102: v2(100.62,150.26) R716.1 99.23,149.69 99.19,149.73 JLVDS1.7 ; v2(165.7,73.71) 165.59,73.82 U31.105
  IN1 w0.127: v2(163.11,116.56) 161.79,115.24 151.96,115.24 151.29,115.91 141.43,115.91 141.22,116.12 130.48,116.12 129.02,114.65 123.41,114.65 122.16,115.9 112.57,115.9 111.69,116.78 102.32,116.78 99.93,114.39 98.86,114.39 98.33,114.92 98.33,122.35 99.11,123.13 99.11,146.26 100.62,147.78 v2(100.62,150.26)
  BOTTOM w0.102: v2(165.7,73.71) 165.7,76.02 166.96,77.28 166.96,78.79 167.7,79.53 167.7,84.77 166.9,85.56 166.9,88.74 164.93,90.71 v1(164.93,91.34) 164.93,94.32 165.07,94.46 165.07,107.68 164.87,107.88 164.87,114.81 v2(163.11,116.56)
BLUE: length 12.7
  IN2 w0.127: JCRT1.3 6.8,117.9 10.09,117.9 v2(10.17,117.83)
  BOTTOM w0.102: v2(10.17,117.83) 10.17,116.3 10.56,115.91 11.81,115.91 12.05,115.67 U10.5 12.05,113.87 C527.1 10.94,112.75 L32.2
BOOT1_1_VGA: length 1.5
  TOP w0.102: PC858.1 181.79,142.78 181.35,142.34 v1(181.02,142.34)
BOOT1_VGA: length 1.9
  TOP w0.102: PR852.2 184.67,142.77 183.67,141.78 v1(183.67,141.56)
BOOT2_2_VGA: length 1
  TOP w0.102: v1(181.13,138.45) 180.73,138.05 180.73,137.6
BOOT2_VGA:
  vias: v1(183.36,135.67)
BQ24737VCC: length 0.7
  BOTTOM w0.102: 186.09,163.78 186.09,163.74 186.28,163.55 v1(186.28,163.14)
  vias: v4(185.87,165.22)
BQ24737VDD: length 17.1
  TOP w0.508: PR310.1 194.94,164.62 v4(194.94,164.62)
  IN1 w0.508: v4(194.94,164.62) 194.94,165.01 193.33,166.62 193.33,168.63 192.44,169.52 189.39,169.52 187.81,167.93 v4(185.26,167.93)
  BOTTOM w0.102: v1(184.78,168.59) 184.78,168.42 185.26,167.95 v4(185.26,167.93)
  BOTTOM w0.508: PR307.1 v4(194.94,164.62) ; v4(185.26,167.93) 185.56,167.63 PC312.1
BRDID: length 7.6
  TOP w0.102: v2(163.39,86.97) 163.4,86.96 163.4,85.59 162.77,84.96 U31.75
  BOTTOM w0.102: R694.1 163.41,85.37 R695.2 162.31,85.61 v1(162.31,86.34) 162.31,86.48 162.4,86.57 162.91,86.57 163.3,86.97 v2(163.39,86.97)
BST_0.95V: length 6.3
  TOP w0.254: PU604.6 173.46,129.12 173.46,130.33 v4(173.13,130.67)
  BOTTOM w0.254: v4(173.13,130.67) 173.13,130.02 172.7,129.59 v1(172.27,129.59) PC632.1
BST_1.5V: length 4
  TOP w0.508: PC602.1 v1(196.65,11.12) 196.65,11.85 v2(196.34,12.16)
  BOTTOM w0.254: v2(196.34,12.16) 196.54,12.16 196.81,11.88 PU601.6
BST_1.05VSP:
  vias: v1(100.63,34.67)
BST_1.05VSP_1: length 2.6
  TOP w0.102: PR713.2 v1(100.92,38.65)
  TOP w0.254: PC707.1 102.14,37.24 PR713.2
BST_1.35V:
  vias: v1(35.5,8.07)
BST_1.35V-1: length 0.7
  TOP w0.102: 38.36,7.81 v1(39.1,7.81)
BST_3V:
  vias: v1(64.79,5.55)
BST_3V_1: length 1.6
  TOP w0.102: PC402.1 68.35,5.06 v1(68.35,5.6)
BST_5V: length 1.4
  TOP w0.102: PR422.1 96.3,6.77 v1(96.26,6.73)
  vias: v4(99.68,7.47)
BST_5V_1: length 1.2
  TOP w0.102: v1(97.34,9.67) 97.57,9.45 97.57,8.58
BST_CHG: length 2.4
  TOP w0.102: v1(181.24,164.21) 181.24,164.6 182.38,165.75 PR320.1
BST_CPU_PHASE1: length 0.8
  BOTTOM w0.102: 27.26,124.58 27.08,124.58 v1(26.68,124.99)
BST_CPU_PHASE1-1: length 1.6
  BOTTOM w0.102: PR925.2 29.19,124.79 v1(30.14,125.74)
BST_CPU_PHASE3: length 4.1
  TOP w0.508: PR924.1 27.89,117.22 v2(27.44,117.67)
  BOTTOM w0.203: PU901.19 25.09,118.42 25.84,117.67 v1(26.73,117.67) v2(27.44,117.67)
BST_CPU_PHASE3-2: length 2.4
  TOP w0.102: v1(25.46,118.62) 25.64,118.62 26.29,117.96 PC913.1
  TOP w0.508: PC913.1 26.48,116.87 PR924.2
BSTA2: length 1.2
  TOP w0.102: PR936.1 29.01,94.16 v1(28.01,94.16)
BSTA2_1: length 2
  TOP w0.102: 31.72,94.71 v1(33.76,94.71)
BUF_CPU_RST#: length 5.9
  TOP w0.089: v1(50.53,103.91) 50.53,104.15 49.74,104.94 v2(49.74,104.94) 49.18,104.39 49.18,103.73 48.49,103.04 48.24,103.04
  TOP w0.102: R37.2 47.27,103.04 48.24,103.04
  BOTTOM w0.089: JCPU1.AT26 v2(49.74,104.94)
CAPS_LED#: length 115.3
  TOP w0.102: v2(160.56,1.87) 160.83,1.6 LED6.1 ; v1(182.86,42.12) 182.34,42.65 v2(182.04,42.65) 181.64,42.25 JLED1.9 ; U31.91 161.93,78.56 v2(162.47,79.1)
  BOTTOM w0.102: v2(162.47,79.1) 162.47,77.89 162.91,77.45 162.91,73.2 166.03,70.08 166.03,58.09 168.31,55.81 174.4,55.81 177.2,53.02 177.2,46.65 181.2,42.65 v2(182.04,42.65) 182.41,42.28 182.41,4.75 181.76,4.1 162.79,4.1 160.56,1.87 v2(160.56,1.87)
CASA0#: length 34.2
  TOP w0.102: 120.81,141.14 123.42,141.14 123.56,141 124.51,141 125.42,140.09 v1(127.81,140.09) 127.98,140.09 128.12,140.23 128.12,140.49 v2(127.93,140.68) ; UV5.K3 111.29,133.25 111.42,133.37 111.42,133.51 111.29,133.64 110.93,133.64 110.8,133.51 110.8,132.8 110.68,132.67 110.35,132.67 v2(110.22,132.8)
  TOP w0.203: 120.81,141.14 120.29,141.14 120.01,141.42 118.21,141.42 118.14,141.5 v2(118.14,141.92)
  IN1 w0.102: v2(110.22,132.8) 110.31,132.8 110.97,133.46 111.12,133.46 111.42,133.16 111.56,133.16 111.74,133.33 111.74,133.48 111.47,133.75 111.47,133.89 111.62,134.03 111.76,134.03 112.03,133.76 112.17,133.76 112.3,133.9 112.3,134.04 112.05,134.3 112.05,134.46 112.17,134.58 112.37,134.58 112.62,134.33 112.62,134.21 112.75,134.08 112.95,134.08 113.08,134.21 113.08,134.46 113.2,134.58 113.37,134.58 113.6,134.35 113.96,134.35
  IN1 w0.127: 113.96,134.35 116.23,136.63 116.23,140.45 116.6,140.81 117.29,140.81 118.14,141.66 v2(118.14,141.92)
  BOTTOM w0.102: v2(127.93,140.68) 128.05,140.8 UV1.K20 ; v2(110.22,132.8) 110.13,132.8 109.77,132.43 109.21,132.43 108.39,133.25 UV6.K3
CASA1#: length 35.5
  TOP w0.102: 120.81,144.62 121.09,144.62 121.22,144.49 121.22,143.81 121.34,143.69 123.92,143.69 124.06,143.82 124.06,144.45 124.23,144.61 124.85,144.61 125.08,144.84 127.64,144.84 127.77,144.71 127.77,144.45 127.64,144.33 v2(127.46,144.33) ; v2(109.05,151.6) 108.86,151.79 108.6,151.79 108.48,151.66 108.48,151.52 108.75,151.25 108.75,151.1 108.6,150.96 108.46,150.96 108.19,151.23 108.04,151.23 107.98,151.17 UV7.K3
  TOP w0.203: v2(117.3,143.88) 117.3,144.37 v1(117.43,144.5) 117.55,144.62 120.81,144.62
  IN1 w0.127: v2(109.05,151.6) 108.94,151.48 108.94,151.31 109.05,151.2 110.16,151.2 110.34,151.02 110.52,151.02 110.65,151.14 110.83,151.14 111.01,150.96 111.01,150.78 110.88,150.66 110.88,150.48 111.06,150.3 111.24,150.3 111.37,150.42 111.55,150.42 111.73,150.24 111.73,150.06 111.6,149.94 111.6,149.76 111.78,149.58 111.96,149.58 112.08,149.7 112.26,149.7 112.44,149.52 112.44,149.34 112.32,149.22 112.32,149.04 112.67,148.69 112.78,148.69 113.09,149 114.15,149 114.78,148.37 114.78,147.48 115.39,146.87 115.39,146.69 115.19,146.5 115.19,146.32 117.3,144.22 v2(117.3,143.88)
  BOTTOM w0.102: UV8.K3 110.9,151.41 110.75,151.41 110.46,151.11 110.31,151.11 110.17,151.25 110.17,151.4 110.47,151.69 110.47,151.89 110.22,152.14 110.11,152.14 109.95,151.98 109.43,151.98 v2(109.05,151.6) ; v2(127.46,144.33) 128.05,143.73 UV1.K17
CASB0#: length 38.9
  TOP w0.102: UV9.K3 129.37,166.91 129.29,166.99 129.1,166.99 128.87,167.22 128.87,167.31 128.95,167.4 129.22,167.4 129.3,167.48 129.3,168.1 129.23,168.17 128.96,168.17 128.89,168.1 v2(128.89,167.83)
  IN1 w0.102: 130.03,165.06 130.03,166.57 128.89,167.71 v2(128.89,167.83)
  IN1 w0.127: 130.03,165.06 131.83,163.26 133.83,163.26 134.75,162.34 137.17,162.34 137.26,162.43 137.26,162.84 137.41,163 137.69,163 137.76,162.92 137.76,161.93 137.65,161.82 136.69,161.82 136.36,161.49 135.45,161.49 135.35,161.39 135.35,161.27 135.58,161.04 136.73,161.04 v2(136.99,161.3)
  IN2 w0.102: 136.59,153.84 136.07,153.32 135.65,153.32 135.42,153.1 135.42,151.9 135.19,151.66 135.19,150.12 v2(135.63,149.68)
  IN2 w0.249: v2(136.99,161.3) 136.91,161.3 136.59,160.98 136.59,153.84
  BOTTOM w0.102: UV1.W10 135.26,149.68 v2(135.63,149.68) ; v2(128.89,167.83) 128.89,167.44 128.84,167.38 128.7,167.38 128.49,167.6 128.49,168.72 128.83,169.06 129.29,169.06 129.78,169.54 129.78,169.83 129.64,169.97 UV10.K3
CASB1#: length 37.7
  TOP w0.102: v2(148.78,168.9) 148.84,168.9 148.97,169.03 148.97,169.19 148.84,169.31 148,169.31 147.87,169.44 147.87,170.03 148,170.16 148.18,170.16 148.3,170.03 UV12.K3
  IN1 w0.127: v2(148.78,168.9) 148.89,169.01 148.89,170.18 148.76,170.3 147.56,170.3 147.44,170.19 147.44,169.66 147.52,169.58 148.24,169.58 148.37,169.45 148.37,168.03 146.55,166.2 145.66,166.2 144.37,164.91 144.37,164.59 143.13,163.36 141.18,163.36 141.09,163.27 139.73,163.27 v2(139.62,163.38)
  IN2 w0.102: v2(138.07,149.91) 138.57,150.41 138.57,152.49 139.17,153.09 139.17,154.12 139.74,154.69 139.74,156.69 140.11,157.06 140.11,157.31
  IN2 w0.249: 140.11,157.31 140.11,163.08 139.81,163.38 v2(139.62,163.38)
  BOTTOM w0.102: v2(138.07,149.91) 137.89,149.91 UV1.AA10 ; UV11.K3 148.3,167.17 149.16,168.03 149.16,168.52 v2(148.78,168.9)
CFG0: length 7.3
  BOTTOM w0.089: 48.54,97.93 48.24,97.64
  BOTTOM w0.102: T16.1 44.91,96.52 47.12,96.52 48.24,97.64 ; JCPU1.AT20 49.55,98.94 48.54,97.93
CFG1: length 6.6
  BOTTOM w0.102: JCPU1.AR20 51.14,99.32 49.41,99.32 46.99,96.91 T17.1
CFG2: length 9
  TOP w0.089: v1(49.78,98.36) 49.49,98.07 v2(49.49,97.8)
  BOTTOM w0.089: 48.24,96.09 48.47,96.31
  BOTTOM w0.102: 48.24,96.09 48.24,95.77 47.04,94.56 R62.1 ; 48.47,96.31 49.49,97.33 v2(49.49,97.8) 50.05,98.37 51.94,98.37 JCPU1.AP20
CFG3: length 5.7
  TOP w0.089: 48.24,99.38 51.01,99.38 v2(52.04,100.41)
  TOP w0.102: T18.1 48.24,99.38
  BOTTOM w0.089: v2(52.04,100.41) 52.51,100.88 JCPU1.AP22
CFG4: length 5.2
  BOTTOM w0.102: R63.1 46.87,98.19 v1(47.33,98.65) 49.61,100.94 JCPU1.AT22
CFG5: length 10.8
  TOP w0.089: v2(48.78,97.51) 48.24,97.51
  TOP w0.102: v1(48.03,97.46) 48.08,97.51 48.24,97.51
  BOTTOM w0.089: v2(48.78,97.51) 48.46,97.19 48.36,97.19
  BOTTOM w0.102: v2(48.78,97.51) 48.78,97.74 49.59,98.56 51.65,98.56 51.88,98.79 51.88,98.96 52.26,99.33 52.67,99.33 52.97,99.64 52.97,100.4 JCPU1.AN22 ; R67.1 46.67,95.5 48.36,97.19
CFG6: length 4.7
  TOP w0.089: v2(49.79,103.94) 49.79,103.38 49.35,102.93 49.35,102.38 49.04,102.08 v1(48.75,102.08) 48.24,102.08
  TOP w0.102: R68.1 48.24,102.08
  BOTTOM w0.089: JCPU1.AT25 v2(49.79,103.94)
CFG7: length 6.9
  BOTTOM w0.102: v1(47.29,100.25) 48.6,100.25 49.8,101.45 53.02,101.45 JCPU1.AN23
CFG16: length 8
  BOTTOM w0.102: JCPU1.AR21 51.11,99.54 49.19,99.54 47.17,97.52 T19.1
CFG_RCOMP: length 4.7
  TOP w0.089: v1(50.01,108.81) 50.01,108.82 49.41,109.42 v2(49.28,109.42) 49.13,109.42 48.56,109.99 48.24,109.99
  TOP w0.102: R309.2 48.24,109.99
  BOTTOM w0.089: JCPU1.AT31 49.8,109.94 v2(49.28,109.42)
CHASSIS1_GND: length 16.8
  GND w0.203: 3.6,99.11 JLAN1.10 ; JLAN1.10 5.35,100.02 ; JLAN1.10 7.1,100.02 ; JLAN1.10 3.6,100.02 ; JLAN1.10 7.1,99.11 ; JLAN1.9 7.1,79.15 ; JLAN1.9 3.6,79.15 ; JLAN1.9 5.35,79.15 ; JLAN1.9 7.1,80.06 ; JLAN1.9 3.6,80.06
  vias: v1(12.49,100.06) v2(8.19,101.17) v2(8.19,100.54) v2(8.19,99.9) v2(14.57,80.57) v2(14.57,79.94) v2(19.66,84.55) v2(19.66,83.93) v2(19.66,79) v2(19.66,78.38)
CHG: length 0.8
  TOP w0.102: v4(166.68,165.74) v1(165.87,165.74)
  vias: v4(166.7,165.07) v4(167.34,165.76) v4(167.35,165.09) v4(168.04,165.76) v4(168.06,165.09) v4(168.73,165.77) v4(168.74,165.1) v4(169.42,165.08)
CHG_B+:
  vias: v1(181.16,165.53) v4(175.55,165.37) v4(175.53,164.73) v4(175.56,164.07) v4(176.22,165.39) v4(176.21,164.74) v4(176.24,164.08) v4(176.88,165.39) v4(176.87,164.74) v4(176.9,164.08) v4(177.53,165.41) v4(177.52,164.77) v4(177.54,164.11)
CKEA0: length 36.9
  TOP w0.102: v2(127.16,139.47) 127.16,139.76 127.03,139.88 125.34,139.88 124.43,140.79 120.81,140.79 ; v2(109.58,132.81) 109.1,132.81 108.33,133.58 107.76,133.58 107.62,133.44 107.62,132.97 107.49,132.84 106.2,132.84 106.08,132.97 106.08,133.12 106.2,133.25 UV5.K9
  TOP w0.203: 120.81,140.79 120.15,140.79 119.86,141.08 117.78,141.08 v1(117.54,141.31) v2(117.54,141.88)
  IN1 w0.102: v2(109.58,132.81) 109.46,132.81 109.83,133.18 110.38,133.18 111.99,134.79 113.84,134.79
  IN1 w0.127: 113.84,134.79 115.9,136.85 115.9,140.58 116.48,141.17 117.18,141.17 117.56,141.55 117.56,141.87 v2(117.54,141.88)
  BOTTOM w0.102: UV6.K9 113.39,133.25 113.52,133.37 113.52,133.56 113.39,133.68 111.2,133.68 110.69,133.18 109.95,133.18 v2(109.58,132.81) ; UV1.K21 127.45,139.47 v2(127.16,139.47)
CKEA1: length 35.1
  TOP w0.102: 120.81,142.43 121.01,142.43 121.26,142.68 122.39,142.68 v1(123.24,141.83) 123.34,141.73 123.56,141.73 123.89,141.4 124.7,141.4 124.96,141.15 126.39,141.15 126.75,140.78 v2(126.75,140.67) ; v2(109.76,151.6) 109.76,151.41 110.38,150.78 111.51,150.78 111.66,150.93 111.66,151.39 111.79,151.52 112.66,151.52 112.78,151.39 UV7.K9
  TOP w0.203: v2(116.96,141.84) 116.96,142.2 117.2,142.43 120.81,142.43
  IN1 w0.127: v2(116.96,141.84) 116.95,141.85 116.95,142.92 117.75,143.72 117.75,144.23 115.77,146.22 115.77,146.97 115.11,147.62 115.11,148.5 114.29,149.33 113.43,149.33 113.42,149.32 113.11,149.32 113.11,149.33 112.99,149.33 110.72,151.6 v2(109.76,151.6)
  BOTTOM w0.102: v2(126.75,140.67) 127.25,141.17 UV1.J20 ; v2(109.76,151.6) 109.64,151.6 109.23,151.19 108.87,151.19 108.37,150.68 107.13,150.68 106.69,151.12 UV8.K9
CKEB0: length 38.6
  TOP w0.102: UV9.K9 129.03,171.57 128.89,171.43 128.89,170.78 129.3,170.37 129.45,170.37 129.71,170.12 129.71,169.37 128.89,168.56 v2(128.89,168.55)
  IN1 w0.102: v2(128.89,168.55) 128.89,169.73 128.99,169.82 129.18,169.82 129.27,169.73 129.27,167.64 130.23,166.68 130.23,165.16 131.07,164.33 131.21,164.33 131.61,163.93 131.66,163.93
  IN1 w0.127: 131.66,163.93 132,163.59 133.97,163.59 134.87,162.68 136.43,162.68 136.83,163.08 v2(136.9,163.08)
  IN2 w0.102: v2(133.33,149.91) 133.69,150.26 134.47,150.26 134.98,150.77 134.98,151.74 135.22,151.98 135.22,153.18 135.57,153.53 135.57,154.02 136.14,154.59
  IN2 w0.249: 136.14,154.59 136.14,161.16 136.67,161.7 136.67,162.85 v2(136.9,163.08)
  BOTTOM w0.102: v2(133.33,149.91) 133.77,149.47 UV1.U10 ; UV10.K9 129.69,165.17 129.81,165.28 129.81,166.79 129.29,167.31 129.29,168.03 128.89,168.43 v2(128.89,168.55)
CKEB1: length 39.5
  TOP w0.102: v2(148.78,168.19) 148.78,167.7 147.97,166.89 147.97,166.62 148.29,166.29 148.44,166.29 148.64,166.09 148.64,165.5 UV12.K9 ; 138.24,157.31 138.24,157.29 138.27,157.31 138.27,154.23 137.34,153.3 137.34,149.78 v2(136.85,149.29)
  TOP w0.203: 138.24,157.31 138.24,157.7 138.4,157.86 138.55,157.86 138.78,157.63 138.98,157.63 139.35,158 139.35,158.21 139.14,158.43 139.14,158.59 139.52,158.98 139.74,158.98 139.94,158.77 140.12,158.77 140.51,159.16 140.51,159.35 140.28,159.58 140.28,159.73 140.7,160.15 140.7,160.73 140.51,160.92 140.51,161.31 140.7,161.5 140.7,162.73 140.26,163.17 140.05,163.17 139.67,162.79 v2(139.63,162.79)
  IN1 w0.127: v2(148.78,168.19) 148.78,167.96 146.8,165.97 145.75,165.97 145.19,165.41 145.19,163.26 144.96,163.03 141.32,163.03 141.08,162.79 v2(139.63,162.79)
  BOTTOM w0.102: UV1.AA11 v2(136.85,149.29) ; UV11.K9 148.3,171.48 147.87,171.05 147.87,169.95 148.37,169.45 148.37,168.72 148.78,168.31 v2(148.78,168.19)
CLK_BUF_BCLK: length 8.5
  TOP w0.089: U4.AT24 120.41,84.41 v2(120.12,84.12)
  TOP w0.102: R194.2 113.4,84.17 113.68,83.88 113.84,83.88 v2(114.03,84.07)
  IN1 w0.089: 115.91,84.25 115.95,84.21 117.4,84.21 117.88,83.72 120.18,83.72 120.29,83.83 120.29,83.96 v2(120.12,84.12)
  IN1 w0.127: 115.91,84.25 114.69,84.25 114.4,83.96 114.13,83.96 v2(114.03,84.07)
CLK_BUF_BCLK#: length 8.8
  TOP w0.089: U4.AR24 121,84.42 v2(120.72,84.13)
  TOP w0.102: v2(114.03,83.48) 113.89,83.62 113.6,83.62 R193.2
  IN1 w0.089: 115.91,83.94 115.91,83.94 117.29,83.94 117.77,83.46 120.29,83.46 120.55,83.72 120.56,83.73 120.56,83.97 v2(120.72,84.13)
  IN1 w0.127: v2(114.03,83.48) 114.2,83.66 114.53,83.66 114.81,83.94 115.91,83.94
CLK_BUF_CKSSCD: length 6.2
  TOP w0.089: 113.96,93.09 114.17,93.09 114.17,93.09 114.78,93.09 115.82,92.04 116.81,92.04 117.13,91.72 U4.BC6
  TOP w0.102: 113.96,93.09 113.15,93.09 112.91,93.34 112.91,93.74 R203.2
CLK_BUF_CKSSCD#: length 5.6
  TOP w0.089: 114.06,92.83 114.07,92.83 114.08,92.83 114.16,92.83 114.17,92.83 114.67,92.83 115.72,91.79 116.64,91.79 U4.BE6
  TOP w0.102: 114.06,92.83 v4(113.33,92.83) 113.04,92.83 112.61,93.25 112.61,93.7 R202.2
CLK_BUF_DMI: length 3.4
  TOP w0.089: v2(119.52,84.13) 119.21,84.44 U4.AW24
  BOTTOM w0.089: v2(119.52,84.13) 119.32,83.94 119.32,83.71 119.08,83.47 118.28,83.47 117.82,83.01 117.74,83.01 R192.2
CLK_BUF_DMI#: length 2.9
  TOP w0.089: v2(118.91,84.13) 118.62,84.43 U4.AY24
  BOTTOM w0.089: v2(118.91,84.13) 119.07,83.97 119.07,83.82 118.97,83.72 118.17,83.72 117.72,83.26 117.63,83.26 R183.2
CLK_BUF_DOT96: length 2.7
  TOP w0.102: v2(133.09,80.12) 132.78,80.43 U4.G33
  BOTTOM w0.102: v2(133.09,80.12) 132.92,79.95 132.92,79.72 133.16,79.47 133.16,79.03 133.28,78.92 133.44,78.92 R199.2
CLK_BUF_DOT96#: length 3.1
  TOP w0.102: U4.H33 132.18,80.44 v2(132.47,80.16)
  BOTTOM w0.102: v2(132.47,80.16) 132.54,80.09 132.65,79.97 132.65,79.61 132.9,79.36 132.9,78.92 133.17,78.65 133.5,78.65 R197.2
CLK_CPU_DMI: length 70.3
  TOP w0.089: 87.23,104.27 86.81,104.27 86.1,104.98 82.42,104.98 v2(82.02,105.37)
  TOP w0.102: v2(124.31,77.68) 124.55,77.44 U4.AF40 ; v2(98.92,103.45) 99.08,103.29 99.08,103.05 98.97,102.94 97.97,102.94 96.9,104.01 93.94,104.01 93.68,104.27 87.23,104.27
  IN2 w0.089: v2(124.31,77.68) 124.18,77.81 123.96,77.81 123.85,77.7 123.85,76.83 122.74,75.73 121.91,75.73 121.43,75.24 121.43,74.85
  IN2 w0.127: v2(116.59,73.56) 116.73,73.7 120.42,73.7 121.43,74.71 121.43,74.85
  BOTTOM w0.089: JCPU1.E26 81.72,105.15 81.81,105.15 v2(82.02,105.37)
  BOTTOM w0.102: v2(116.59,73.56) 116.42,73.73 116.13,73.73 115.18,74.68 115.18,75.35 114.49,76.05 110.96,79.58 106.22,79.58 101.65,84.15 101.65,97.86 99.08,100.43 99.08,103.29 v2(98.92,103.45)
CLK_CPU_DMI#: length 70.3
  TOP w0.089: 87.23,104 87.21,104 87.21,104.01 87.12,104.01 87.12,104.01 86.7,104.01 86,104.72 82.34,104.72 82.02,104.4 v2(82.02,104.41)
  TOP w0.102: U4.AF39 124.57,78.03 v2(124.31,78.29) ; 87.23,104 93.57,104 93.83,103.74 96.79,103.74 97.86,102.68 99.08,102.68 99.34,102.94 99.34,103.29 v2(99.5,103.45)
  IN2 w0.089: 121.13,74.85 121.13,74.86 121.15,74.88 121.15,74.97 121.17,74.99 121.17,75.36 121.8,75.99 122.63,75.99 123.58,76.94 123.58,77.81 123.85,78.08 124.1,78.08 v2(124.31,78.29)
  IN2 w0.127: 121.13,74.85 121.13,74.84 120.29,74 116.73,74 v2(116.59,74.14)
  BOTTOM w0.089: JCPU1.D26 82.15,104.58 82.15,104.53 82.02,104.4 v2(82.02,104.41)
  BOTTOM w0.102: v2(116.59,74.14) 116.45,74 116.24,74 115.45,74.79 115.45,75.46 115.3,75.61 114.68,76.24 111.07,79.84 106.33,79.84 101.91,84.26 101.91,97.97 99.34,100.54 99.34,103.29 v2(99.5,103.45)
CLK_CPU_DPLL: length 83
  TOP w0.089: 85.68,109.02 85.67,109.02 85.66,109.02 85.57,109.02 85.57,109.01 85.23,109.01 84.11,107.89 84.11,107.88 83.21,106.98 79.17,106.98 79.04,107.11 v2(79.04,107.43)
  TOP w0.102: U4.AF36 124.71,79.4 124.59,79.52 v2(124.24,79.52) ; 85.68,109.02 91.85,109.02 95.36,105.51 97.93,105.51 98.2,105.25 98.2,105.04 v2(98.51,104.72)
  IN2 w0.089: v2(124.24,79.52) 124.24,79.64 124.42,79.82 124.66,79.82 125.24,79.24 125.24,76.36 124.25,75.37 123.4,75.37 123.17,75.14 123.1,75.07 123.08,75.07 123.07,75.07
  IN2 w0.127: v2(118.85,73.19) 118.86,73.19 119.14,72.91 120.91,72.91 123.07,75.07
  BOTTOM w0.089: JCPU1.H28 78.81,107.24 78.85,107.24 v2(79.04,107.43)
  BOTTOM w0.102: v2(118.85,73.19) 118.65,72.98 116.1,72.98 114.68,74.41 114.68,75.16 110.74,79.09 106.02,79.09 98.83,86.28 98.83,91 95.98,93.85 95.98,97.82 98.27,100.11 98.27,104.49 98.51,104.72 v2(98.51,104.72)
CLK_CPU_DPLL#: length 83.2
  TOP w0.089: 85.68,108.76 85.33,108.76 84.29,107.71 84.29,107.7 83.31,106.73 79.34,106.73 v2(78.99,106.37)
  TOP w0.102: v2(124.23,80.14) 124.55,79.83 U4.AF35 ; v2(97.93,104.72) 97.93,105.14 97.82,105.24 95.25,105.24 91.74,108.76 85.68,108.76
  IN2 w0.089: v2(124.23,80.14) 124.29,80.08 124.77,80.08 125.51,79.35 125.51,76.25 124.36,75.11 123.51,75.11 123.29,74.89 123.29,74.86 123.28,74.85
  IN2 w0.127: v2(118.85,72.6) 121.04,72.6 123.28,74.85
  BOTTOM w0.089: v2(78.99,106.37) 79.1,106.49 79.1,106.53 JCPU1.G28
  BOTTOM w0.102: v2(97.93,104.72) 98.01,104.65 98.01,100.22 95.71,97.93 95.71,93.74 98.57,90.89 98.57,86.17 105.91,78.83 110.63,78.83 114.41,75.05 114.41,74.3 115.99,72.71 118.74,72.71 v2(118.85,72.6)
CLK_CPU_SSC_DPLL: length 70.7
  TOP w0.089: 87.23,106.38 85,106.38 84.65,106.03 82.79,106.03 82.5,105.74 81.36,105.74 v2(81.01,105.39)
  TOP w0.102: 87.23,106.38 87.37,106.38 R26.2 88.53,106.43 92.28,106.43 94.22,104.49 97.1,104.49 97.66,103.93 99.98,103.93 100.27,104.23 100.27,104.53 v2(100.43,104.69) ; v2(123.2,78.29) 123.46,78.03 U4.AJ39
  IN2 w0.089: v2(116.57,75.39) 116.73,75.23 118.96,75.23 120.27,76.54 121.64,76.54 122.52,77.43 122.52,77.9 122.74,78.11 123.03,78.11 v2(123.2,78.29)
  BOTTOM w0.089: JCPU1.E27 81.51,105.9 v2(81.01,105.39)
  BOTTOM w0.102: v2(100.43,104.69) 100.27,104.53 100.27,101.29 102.66,98.9 102.66,84.57 106.64,80.59 111.38,80.59 116.12,75.85 116.12,75.42 116.28,75.26 116.43,75.26 v2(116.57,75.39)
CLK_CPU_SSC_DPLL#: length 70.6
  TOP w0.089: 87.23,106.63 84.89,106.63 84.55,106.28 82.68,106.28 82.4,106 81.36,106 v2(81.01,106.35)
  TOP w0.102: v2(123.2,77.68) 123.44,77.44 U4.AJ40 ; v2(99.85,104.69) 100.01,104.53 100.01,104.34 99.87,104.2 97.77,104.2 97.21,104.76 94.33,104.76 92.39,106.7 88.4,106.7 R27.2 87.38,106.63 87.23,106.63
  IN2 w0.089: 116.61,74.85 116.73,74.97 119.07,74.97 120.38,76.27 121.75,76.27 122.79,77.31 122.79,77.78 122.85,77.85 123.03,77.85 v2(123.2,77.68)
  IN2 w0.127: v2(116.57,74.81) 116.61,74.85
  BOTTOM w0.089: JCPU1.F27 80.6,105.94 v2(81.01,106.35)
  BOTTOM w0.102: v2(116.57,74.81) 116.38,74.99 116.17,74.99 115.86,75.31 115.86,75.74 111.27,80.32 106.53,80.32 102.4,84.46 102.4,98.79 100.01,101.18 100.01,104.53 v2(99.85,104.69)
CLK_ENABLE#_VGA: length 4.3
  TOP w0.102: PR830.2 191.54,135.1 v1(191.1,135.54)
  TOP w0.203: PU801.40 189.02,135.38 189.75,134.65 PR830.2
CLK_PCH_14M: length 3.6
  TOP w0.089: 133.98,72.63 133.98,74.26 132.93,75.32 U4.F45
  TOP w0.102: 133.98,72.63 R205.2
CLK_PCI_EC: length 58.5
  TOP w0.102: v2(179.41,80.22) 179.41,80.35 R589.1 178.8,80.96 U31.12 ; R211.1 v2(134.93,70.74)
  IN1 w0.127: v2(134.93,70.74) 142.34,70.74 144.86,73.26 144.86,78.37 v2(144.02,79.21)
  IN2 w0.127: v2(144.02,79.21) 144.71,79.89 155.03,79.89 155.85,79.07 157.55,79.07 158.3,79.82 170.31,79.82 170.73,79.4 175.43,79.4 176.71,80.68 178.95,80.68 v2(179.41,80.22)
CLK_PCI_EC_R: length 4.5
  TOP w0.089: U4.E44 133.27,75.97 133.27,75.35 134.18,74.43 134.18,73.45 134.93,72.7
  TOP w0.102: 134.93,72.7 134.93,72.29 R211.2
CLK_PCI_LPBACK: length 17.7
  TOP w0.102: U4.D17 133.84,87.25 133.54,87.55 133.54,87.56 v2(133.54,87.56)
  IN2 w0.102: v2(133.54,87.56) 133.54,87.56 133.04,87.07 132.65,87.07 132.52,86.94 132.52,86.6 132.15,86.23 131.33,86.23 130.86,85.76 130.86,85.05 131.64,84.26 131.64,83.75 131.22,83.33 131.22,82.97 131.57,82.62 132.32,82.62 135.12,79.82 135.12,78.61 v2(136.19,77.54)
  BOTTOM w0.102: v2(136.19,77.54) 136.19,76.82 136.56,76.45 136.56,75.99 R209.1
CLK_PCI_LPBACK_R: length 3
  TOP w0.089: v2(133.62,76.51) 133.99,76.15 U4.D44
  BOTTOM w0.102: R209.2 135.25,76.29 135.01,76.53 v1(134.88,76.53) 134.86,76.5 134.84,76.51 v2(133.62,76.51)
CLK_PCIE_LAN: length 143.3
  TOP w0.102: R187.1 123.97,68.67 124.36,68.28 v2(125.4,68.28) ; v2(29.41,22.79) 29.55,22.93 30.11,22.93 30.89,23.72 UL1.33
  IN2 w0.127: v2(29.41,22.79) 30.2,22.79 31.25,21.74 33.29,21.74 33.96,22.4 39.67,22.4 40.71,21.36 46.49,21.36 47.18,22.04 114.78,22.04 123.25,30.51 123.25,67.28 124.25,68.28 v2(125.4,68.28)
CLK_PCIE_LAN#: length 143.2
  TOP w0.102: v2(125.4,68.86) 125.08,68.55 124.47,68.55 124.24,68.78 124.24,69 R185.1 ; UL1.32 30.49,24.08 30.62,23.94 30.62,23.83 30,23.2 29.57,23.2 v2(29.4,23.38)
  IN2 w0.127: v2(29.4,23.38) 29.42,23.38 29.7,23.1 30.32,23.1 31.38,22.04 33.17,22.04 33.83,22.71 39.79,22.71 40.84,21.66 46.36,21.66 47.05,22.35 114.66,22.35 122.94,30.64 122.94,67.41 124.12,68.58 125.1,68.58 125.38,68.86 v2(125.4,68.86)
CLK_PCIE_LAN#_R: length 6.7
  TOP w0.089: U4.AD43 125.59,75.94 125.88,75.65 125.88,74.52 v4(124.75,73.39) 124.52,73.17 124.52,72.66 124.53,72.65 124.53,72.63
  TOP w0.102: 124.53,72.63 124.53,70.84 R185.2
CLK_PCIE_LAN_R: length 6.7
  TOP w0.089: U4.AD45 125.59,75.51 125.47,75.63 125.2,75.63 125.08,75.5 125.08,75.3 125.2,75.17 125.52,75.17 125.62,75.07 125.62,74.61 124.27,73.26 124.27,72.65 124.26,72.64 124.26,72.63
  TOP w0.102: R187.2 124.26,70.81 v4(124.26,71.84) 124.26,72.63
CLK_PCIE_VGA: length 103.2
  TOP w0.102: v2(123.08,69.22) 122.77,69.54 122.77,70.88 122.82,70.93 122.82,71.4 122.94,71.52 123.11,71.52 R188.2
  IN2 w0.102: 137.03,126.41 137.03,126.44 137.01,126.45 137.01,128.38 137.32,128.68 v2(137.56,128.68)
  IN2 w0.127: 137.03,126.41 137.03,126.18 137.66,125.55 151.58,125.55 152.57,124.55 152.57,122.79 153.88,121.49 153.88,121.09 v2(154.05,120.91)
  BOTTOM w0.102: UV1.AB35 137.85,128.97 v2(137.56,128.68) ; v2(154.05,120.91) 153.89,120.76 153.89,120.11 154.08,119.92 154.08,118.81 154.06,118.78 154.06,115.78 152.95,114.68 152.95,109.01 151.41,107.48 151.41,101.75 149.38,99.72 149.38,76.78 143.42,70.81 136.86,70.81 136.53,71.15 124.36,71.15 122.92,69.71 122.92,69.38 v2(123.08,69.22)
CLK_PCIE_VGA#: length 103.2
  TOP w0.102: R186.2 122.5,71.2 v2(122.5,69.22)
  IN2 w0.102: v2(137.37,129.27) 137.37,129.13 136.74,128.5 136.74,126.45 136.72,126.44 136.72,126.41
  IN2 w0.127: v2(153.47,120.91) 153.58,121.02 153.58,121.36 152.27,122.67 152.27,124.43 151.45,125.24 137.53,125.24 136.72,126.06 136.72,126.41
  BOTTOM w0.102: UV1.AA36 137.05,128.95 v2(137.37,129.27) ; v2(122.5,69.22) 122.66,69.38 122.66,69.82 124.25,71.41 136.64,71.41 136.97,71.08 143.31,71.08 149.12,76.89 149.12,99.83 151.15,101.86 151.15,107.59 152.69,109.12 152.69,114.79 153.79,115.89 153.79,118.89 153.82,118.92 153.82,119.81 153.63,120 153.63,120.76 v2(153.47,120.91)
CLK_PCIE_VGA#_R: length 12.6
  TOP w0.089: v2(122.48,73.05) 122.55,72.99 122.55,72.63
  TOP w0.102: U4.AB35 126.51,79.83 v2(126.8,80.12) ; 122.55,72.63 122.55,72.51 R186.1
  IN2 w0.089: 126.42,74.85 126.49,74.91 126.49,77.03 125.75,77.76 125.75,79.51 126.16,79.91 126.59,79.91 v2(126.8,80.12)
  IN2 w0.127: v2(122.48,73.05) 122.64,73.21 122.64,73.48 123.25,74.09 125.66,74.09 126.42,74.85
CLK_PCIE_VGA_R: length 12.8
  TOP w0.089: 122.82,72.63 122.82,72.8 v2(123.07,73.05)
  TOP w0.102: U4.AB36 126.55,79.23 v2(126.81,79.49) ; 122.82,72.63 122.82,72.23 122.94,72.11 123.08,72.11 R188.1
  IN2 w0.089: 126.77,74.85 126.77,74.87 126.75,74.89 126.75,77.14 126.02,77.87 126.02,79.4 126.27,79.65 126.65,79.65 v2(126.81,79.49)
  IN2 w0.127: v2(123.07,73.05) 122.94,73.18 122.94,73.35 123.38,73.78 125.79,73.78 126.77,74.77 126.77,74.85
CLK_PCIE_WLAN: length 141.2
  TOP w0.102: R189.1 125.48,71.22 125.48,70.77 125.39,70.69 125.39,70.02 125.61,69.8 126,69.8 v2(126.13,69.67)
  IN2 w0.127: v2(153.97,108.1) 154.01,108.14 156.9,108.14 158.26,106.78 184.56,106.78 193.1,115.32 193.1,116.58 198.97,122.45 198.97,130.77 198.96,130.77 198.96,144.37 198.24,145.09 v2(197.49,145.09)
  BOTTOM w0.102: v2(126.13,69.67) 143.35,69.67 150.13,76.45 150.13,99.39 152.16,101.42 152.16,107.14 153.12,108.1 v2(153.97,108.1) ; v2(197.49,145.09) 197.6,144.98 197.95,144.98 198.17,145.2 JWLN1.13
CLK_PCIE_WLAN#: length 141
  TOP w0.102: R313.1 125.97,71.63 125.85,71.63 125.75,71.52 125.75,70.66 125.66,70.57 125.66,70.13 125.72,70.06 125.94,70.06 v2(126.13,70.25)
  IN2 w0.127: v2(197.49,144.51) 197.5,144.51 197.78,144.79 198.12,144.79 198.66,144.25 198.66,130.64 198.66,130.64 198.66,122.57 192.79,116.7 192.79,115.45 184.43,107.08 158.39,107.08 157.03,108.44 154.21,108.44 v2(153.97,108.68)
  BOTTOM w0.102: v2(153.97,108.68) 153.65,108.36 153.01,108.36 151.9,107.25 151.9,101.53 149.87,99.5 149.87,76.56 143.24,69.93 126.45,69.93 v2(126.13,70.25) ; v2(197.49,144.51) 197.69,144.71 197.92,144.71 198,144.64 198,144.47 198.07,144.4 JWLN1.11
CLK_PCIE_WLAN#_R: length 4.7
  TOP w0.089: 125.95,73.04 125.95,73.06 125.94,73.07 125.94,73.37 v4(126.19,73.62) 126.84,74.27 126.84,75.5 126.4,75.94 U4.AB43
  TOP w0.102: R313.2 125.95,72.56 125.95,73.04
CLK_PCIE_WLAN_R: length 4.6
  TOP w0.089: U4.AB45 126.28,75.63 126.16,75.63 126.05,75.52 126.05,75.22 126.13,75.14 126.51,75.14 126.59,75.07 126.59,74.37 125.69,73.47 125.69,73.07 125.68,73.06 125.68,73.04
  TOP w0.102: R189.2 125.68,72.71 125.68,73.04
CLK_REQ_VGA#: length 104.6
  IN2 w0.127: v2(153.02,134.13) 153.22,134.34 153.22,136.47 153.23,136.47 153.23,136.74 155.24,138.75 155.24,143.76 154.06,144.94 154.06,146.02 v2(152.13,147.95) ; v2(156.12,106.26) 155.9,106.05 150.41,106.05 148.55,107.91 140.3,107.91 139.97,108.24 134.09,108.24 133.76,107.91 127.55,107.91 124.53,104.89 v2(124.26,104.89)
  BOTTOM w0.089: R178.2 124.04,94.43 124.04,94.79
  BOTTOM w0.102: v2(156.12,106.26) 156.23,106.37 156.23,118.61 155.61,119.23 155.61,123.24 154.82,124.03 154.82,127.84 155.58,128.6 158.15,128.6 158.8,129.25 158.8,133.56 158.22,134.13 v2(153.02,134.13) ; 124.04,94.79 124.04,96.97 123.36,97.65 123.36,100.1 123.86,100.59 123.86,102.19 124.56,102.89 v1(124.56,104.33) 124.26,104.62 v2(124.26,104.89) ; v2(152.13,147.95) 151.87,147.7 150.65,147.7 150.23,147.27 148.22,147.27 148.08,147.42 147,147.42 UV1.AN13
CLKA0: length 43.3
  TOP w0.102: v2(109.12,131.12) 109.12,131.34 108.84,131.61 108.84,132.47 108.5,132.81 107.94,132.81 107.83,132.7 107.83,132.55 107.94,132.45 UV5.J7
  TOP w0.109: RV60.1 104.02,136.53 104.71,136.53 v2(104.92,136.31)
  IN2 w0.102: 120.97,138.87 120.98,138.87 121,138.89 121.22,138.89 121.68,138.43 124.15,138.43 124.84,137.74 124.84,136.72 125.65,135.91 125.65,135.31 126.08,134.88 v2(126.08,134.78) ; v2(109.12,131.12) 109.12,131.42 108.9,131.64 108.77,131.77 108.77,133.16 108.75,133.18 108.75,133.21
  IN2 w0.14: v2(109.12,131.12) 109.57,130.67 109.94,130.67 110.22,130.94 110.22,131.24 110.88,131.9 110.88,136.15 112.11,137.39 114.77,137.39 115.33,137.94 117.66,137.94 118.59,138.87 120.97,138.87 ; v2(104.92,136.31) 104.96,136.31 105.1,136.46 107.58,136.46 108.75,135.28 108.75,133.21
  BOTTOM w0.102: UV6.J7 111.06,132.45 110.77,132.16 110.77,131.75 110.43,131.4 110.43,131.11 110.02,130.7 109.69,130.7 109.27,131.12 v2(109.12,131.12) ; v2(126.08,134.78) 126.45,135.15 UV1.H27
CLKA0#: length 43.8
  TOP w0.102: v2(109.82,131.11) 109.71,131.11 109.29,131.53 109.24,131.53 109.04,131.72 109.04,132.56 108.58,133.02 108.25,133.02 UV5.K7
  TOP w0.109: v2(104.92,136.9) 104.76,136.74 103.95,136.74 RV61.1
  IN2 w0.102: 120.97,139.12 120.98,139.12 121,139.11 121.31,139.11 121.77,138.64 124.23,138.64 125.05,137.83 125.05,136.81 125.86,136 125.86,135.4 126.01,135.26 126.21,135.26 126.33,135.39 126.33,135.68 v2(126.25,135.77) ; v2(109.82,131.11) 109.74,131.11 109.32,131.53 108.99,131.86 108.99,133.16 109.01,133.18 109.01,133.21
  IN2 w0.14: v2(104.92,136.9) 104.96,136.9 105.14,136.71 107.68,136.71 109.01,135.39 109.01,133.21 ; v2(109.82,131.11) 109.85,131.11 109.96,131.22 109.96,131.35 110.62,132.01 110.62,136.26 112,137.64 114.67,137.64 115.23,138.2 117.56,138.2 118.48,139.12 120.97,139.12
  BOTTOM w0.102: UV1.G27 125.74,135.27 v2(126.25,135.77) ; v2(109.82,131.11) 110.14,131.11 110.22,131.19 110.22,131.49 110.57,131.83 110.57,132.24 111.1,132.78 111.45,132.78 111.58,132.91 111.58,133.12 111.45,133.25 UV6.K7
CLKA1: length 41.6
  TOP w0.102: v2(109.07,153.3) 109.39,153.61 109.87,153.61 110.37,153.11 110.37,152.16 110.73,151.8 111.06,151.8 UV7.J7
  TOP w0.109: RV66.1 103.91,150.58 104.54,150.58 v2(104.71,150.76)
  IN2 w0.102: 108.34,151.89 108.34,151.91 108.36,151.93 108.36,152.54 109.07,153.25 v2(109.07,153.3) ; v2(126.96,145.43) 126.85,145.55 126.83,145.57 126.83,145.76 126.46,146.12 124.19,146.12 123.93,146.38 123.93,146.95 123.67,147.22 123.03,147.22 122.19,148.06 120.86,148.06 120.84,148.08 120.83,148.08
  IN2 w0.14: 120.83,148.08 117.67,148.08 116.7,149.04 114.77,149.04 114.55,149.26 113.57,149.26 113.35,149.04 112.99,149.04 112.85,149.18 112.85,150.01 112.56,150.3 111.85,150.3 111.58,150.03 111.58,149.34 111.45,149.21 110.78,149.21 110.65,149.34 110.65,152.68 110.14,153.19 110.14,153.31 109.82,153.63 109.41,153.63 v2(109.07,153.3) ; 108.34,151.89 108.34,150.93 107.95,150.54 104.93,150.54 v2(104.71,150.76)
  BOTTOM w0.089: 108.72,152.99 109.03,153.3 v2(109.07,153.3)
  BOTTOM w0.102: v2(126.96,145.43) 126.88,145.51 126.88,145.84 127.11,146.07 UV1.J14 ; UV8.J7 107.89,151.92 107.77,151.8 107.77,151.62 107.89,151.5 108.23,151.5 108.48,151.75 108.48,151.96 108.3,152.15 108.3,152.56 108.72,152.99
CLKA1#: length 41.8
  TOP w0.102: UV7.K7 111.38,151.12 111.46,151.19 111.46,151.51 111.37,151.6 110.65,151.6 110.17,152.08 110.17,152.78 109.72,153.22 v2(109.67,153.22)
  TOP w0.109: v2(104.71,150.17) 104.51,150.37 103.91,150.37 RV69.1
  IN2 w0.102: v2(126.14,145.42) 126.14,145.14 126.26,145.02 126.44,145.02 126.56,145.14 126.56,145.72 126.37,145.91 124.1,145.91 123.72,146.29 123.72,146.86 123.58,147 122.94,147 122.1,147.84 120.86,147.84 120.84,147.82 120.83,147.82 ; 108.6,151.89 108.6,151.9 108.58,151.92 108.58,152.45 109.04,152.91 109.35,152.91 v2(109.67,153.22)
  IN2 w0.14: 120.83,147.82 117.56,147.82 116.59,148.79 114.66,148.79 114.45,149.01 113.68,149.01 113.46,148.79 112.88,148.79 112.59,149.08 112.59,149.91 112.45,150.05 111.96,150.05 111.83,149.92 111.83,149.23 111.56,148.96 110.67,148.96 110.4,149.23 110.4,152.58 109.75,153.22 v2(109.67,153.22) ; 108.6,151.89 108.6,150.83 108.06,150.29 104.83,150.29 v2(104.71,150.17)
  BOTTOM w0.102: v2(109.67,153.22) 109.58,153.22 109.29,152.93 108.95,152.93 108.5,152.48 108.5,152.23 108.69,152.04 108.69,151.66 108.32,151.29 108.15,151.29 UV8.K7 ; v2(126.14,145.42) 126.47,145.74 126.47,146.06 UV1.H14
CLKB0: length 47.1
  TOP w0.102: UV9.J7 128.57,170.2 128.67,170.31 128.82,170.31 128.93,170.2 128.93,169.5 128.59,169.16 127.8,169.16 127.52,168.88 v2(127.24,168.88)
  TOP w0.109: v2(133.15,173.52) 132.96,173.71 132.96,174.5 RV72.1
  IN2 w0.102: v2(128.58,150.67) 128.95,151.04 128.95,152.13 129.37,152.55 130.54,152.55 130.83,152.84 132.28,152.84 133.2,153.77 133.2,154.52 132.85,154.87 132.85,157.24 132.83,157.26 132.83,157.31 ; 130.49,167.1 130.48,167.1 130.46,167.12 130.39,167.12 130.37,167.14 128.02,167.14 127.62,167.55 127.29,167.55 126.82,168.02 126.82,168.49 127.2,168.88 v2(127.24,168.88) 127.48,168.88 127.79,169.19 128.38,169.19 128.4,169.21 128.46,169.21 128.48,169.22 128.49,169.22
  IN2 w0.14: v2(133.15,173.52) 133,173.66 133,173.96 132.76,174.2 132.19,174.2 131.41,173.43 131.41,172.03 128.61,169.22 128.49,169.22 ; 132.83,157.31 132.83,160.3 131.97,161.16 131.97,161.85 132.83,162.71 132.83,163.91 132.51,164.23 132.51,165.26 133.18,165.92 133.18,166.83 132.91,167.1 130.49,167.1
  BOTTOM w0.102: UV1.L9 128.98,150.27 v2(128.58,150.67) ; UV10.J7 128.11,167.23 127.87,167.23 127.53,167.57 127.23,167.57 126.82,167.97 126.82,168.46 v2(127.24,168.88)
CLKB0#: length 46.5
  TOP w0.102: UV9.K7 129.15,169.75 129.15,169.42 128.68,168.95 127.89,168.95 127.23,168.29 v2(127.23,168.18)
  TOP w0.109: v2(132.56,173.52) 132.75,173.7 132.75,174.56 RV73.1
  IN2 w0.102: 128.49,168.97 127.88,168.97 127.23,168.32 v2(127.23,168.18) 127.23,167.91 127.38,167.76 127.71,167.76 128.11,167.36 130.49,167.36 ; 133.09,157.31 133.09,157.26 133.07,157.24 133.07,154.96 133.42,154.61 133.42,153.68 132.37,152.63 130.92,152.63 130.63,152.33 129.46,152.33 129.17,152.04 129.17,150.66 129.27,150.56 129.41,150.56 v2(129.59,150.73)
  IN2 w0.14: 128.49,168.97 128.71,168.97 131.66,171.92 131.66,173.32 132.29,173.95 132.66,173.95 132.75,173.86 132.75,173.7 v2(132.56,173.52) ; 130.49,167.36 133.01,167.36 133.43,166.94 133.43,165.82 132.77,165.15 132.77,164.38 133.09,164.06 133.09,162.61 132.22,161.74 132.22,161.27 133.09,160.4 133.09,157.31
  BOTTOM w0.102: UV1.L8 128.96,150.98 128.96,150.75 129.05,150.66 129.51,150.66 v2(129.59,150.73) ; UV10.K7 129.37,166.61 129.24,166.48 129.04,166.48 128.91,166.62 128.91,166.89 128.37,167.43 127.95,167.43 127.23,168.15 v2(127.23,168.18)
CLKB1: length 46.2
  TOP w0.102: UV12.J7 148.98,166.89 148.98,167.22 149.35,167.58 150.29,167.58 150.79,168.08 150.79,168.56 v2(150.48,168.88)
  TOP w0.109: RV79.1 146.5,174.53 146.5,173.31 v2(146.69,173.13)
  IN2 w0.102: v2(140.41,150.68) 140.58,150.86 140.76,150.86 141.04,151.14 141.04,152.24 141.45,152.66 141.45,155.96 141.47,155.98 141.47,156 ; 148.99,169.64 149.02,169.64 149.04,169.62 149.72,169.62 150.2,169.14 150.2,169.05 150.37,168.88 v2(150.48,168.88) 150.83,168.53 150.83,168.09 150.43,167.69 150.17,167.69 150.03,167.54 149.72,167.54 149.7,167.52 149.69,167.52
  IN2 w0.14: 149.69,167.52 148.13,167.52 147.99,167.38 147.99,166.45 147.69,166.15 147.07,166.15 146.78,166.44 146.78,167.38 146.65,167.52 145.97,167.52 145.83,167.38 145.83,165.47 146.34,164.96 146.34,164.45 145.83,163.94 145.26,163.94 145.11,163.79 145.11,163.24 145.37,162.98 145.37,161.99 144.97,161.6 143.7,161.6 143.58,161.48 143.58,160.84 142.4,159.66 142.4,156.93 141.47,156 ; 148.99,169.64 148.48,169.64 148.08,170.04 148.08,171.6 147.33,172.35 146.86,172.35 146.54,172.67 146.54,172.98 v2(146.69,173.13)
  BOTTOM w0.102: UV11.J7 149.1,170.35 149.02,170.43 148.75,170.43 148.68,170.36 148.68,169.73 148.93,169.48 149.13,169.48 149.21,169.55 149.8,169.55 150.17,169.18 150.17,169.18 v2(150.48,168.88) ; v2(140.41,150.68) 140.02,151.07 UV1.AD8
CLKB1#: length 46
  TOP w0.102: v2(150.4,168.28) 150.4,168.23 149.96,167.78 149.26,167.78 148.78,167.3 148.78,166.8 148.62,166.65 148.43,166.65 UV12.K7
  TOP w0.109: v2(146.1,173.13) 146.29,173.31 146.29,174.44 RV81.1
  IN2 w0.102: 149.69,167.78 149.7,167.78 149.72,167.76 149.94,167.76 150.08,167.9 150.3,167.9 150.4,168.01 v2(150.4,168.28) 150.4,168.41 149.97,168.84 149.97,169.06 149.63,169.4 149.04,169.4 149.02,169.38 148.99,169.38 ; 141.29,156.18 141.28,156.17 141.28,156.16 141.29,156.15 141.24,156.1 141.24,155.97 141.24,152.75 140.82,152.33 140.82,151.22 140.67,151.08 140.27,151.08 140.19,151.15 140.19,151.28 v2(140.39,151.48)
  IN2 w0.14: v2(146.1,173.13) 146.29,172.94 146.29,172.56 146.76,172.09 147.23,172.09 147.82,171.5 147.82,169.94 148.38,169.38 148.99,169.38 ; 141.29,156.18 142.15,157.04 142.15,159.77 143.33,160.94 143.33,161.58 143.6,161.85 144.87,161.85 145.11,162.1 145.11,162.88 144.86,163.13 144.86,163.9 145.16,164.2 145.73,164.2 146.08,164.55 146.08,164.85 145.57,165.36 145.57,167.49 145.86,167.78 146.75,167.78 147.04,167.49 147.04,166.55 147.18,166.41 147.58,166.41 147.74,166.56 147.74,167.49 148.03,167.78 149.69,167.78
  BOTTOM w0.102: UV11.K7 148.48,169.8 148.48,169.64 148.84,169.28 149.22,169.28 149.29,169.35 149.71,169.35 150.05,169.02 150.05,168.72 150.4,168.37 v2(150.4,168.28) ; UV1.AD7 139.63,151.87 139.54,151.79 139.54,151.61 139.67,151.48 v2(140.39,151.48)
CLKREQ_LAN#: length 227.9
  TOP w0.089: U4.T3 128.84,93.65 129.27,94.09 129.27,95.23 v2(129.32,95.28)
  TOP w0.102: RL11.2 37.05,26.52 v2(36.73,26.83) 36.36,26.46 UL1.4
  IN1 w0.127: v2(128.87,103.82) 128.88,103.82 129.75,102.94 129.75,98.82 130.17,98.4 130.17,96.18 129.32,95.33 v2(129.32,95.28)
  IN2 w0.127: v2(155.35,100.63) 153.6,102.38 149.55,102.38 147.35,104.58 131,104.58 130.23,103.82 v2(128.87,103.82)
  BOTTOM w0.102: v2(155.35,100.63) 153.35,98.63 153.35,91.32 153.75,90.92 153.75,88.54 154.22,88.07 154.22,81.81 153.69,81.28 153.69,76.38 152.78,75.46 152.78,70.91 151.67,69.81 146.67,69.81 145.44,68.58 138.12,68.58 136.14,66.6 136.14,64.75 119.76,48.37 119.76,29.1 116.31,25.65 96.31,25.65 92.2,29.77 47.53,29.77 45.67,27.91 37.55,27.91 36.73,27.08 v2(36.73,26.83) ; v2(129.32,95.28) 129.12,95.47 v1(129.12,96.3) 129.12,97.86 R201.1
CLKREQ_WLAN#: length 123.1
  TOP w0.089: v2(124.7,92.73) 124.78,92.81 U4.AF3
  IN1 w0.127: v2(124.98,106.54) 126.72,106.54 127.55,105.7 127.55,102.69 127.25,102.38 127.25,101.06 126.14,99.96 126.14,96.99 126.56,96.57 v2(126.56,94.82)
  IN2 w0.127: v2(124.98,106.54) 126.99,108.56 133.42,108.56 133.79,108.93 140.73,108.93 141.73,109.93 156.48,109.93 158.82,107.59 184.22,107.59 192.29,115.66 192.29,116.91 198.15,122.78 198.15,130.43 198.09,130.5 198.09,142.23 v2(197.52,142.8)
  BOTTOM w0.089: v2(124.7,92.73) 125,92.73 125.09,92.82 125.09,93.24 ; R195.1 125.44,93.37 125.69,93.62 125.69,94.51 125.97,94.79
  BOTTOM w0.102: 125.97,94.79 125.99,94.82 v2(126.56,94.82) ; R195.1 125.09,93.24 ; JWLN1.7 v2(197.52,142.8)
CMOS_ON#: length 137.5
  TOP w0.102: v2(177.78,83.08) 177.26,82.56 U31.16
  IN1 w0.127: v2(177.78,83.08) 178.71,84.01 178.71,87.35 180.16,88.8 v2(180.16,112.42)
  IN2 w0.127: v2(180.16,112.42) 180.16,111.96 179.9,111.71 172.89,111.71 169.08,115.52 153.54,115.52 153.03,115.01 142.08,115.01 141.35,115.75 131.98,115.75 129.22,118.51 108,118.51 106.22,116.72 102.41,116.72 102.02,117.11 100.72,117.11 v2(100.38,116.77)
  BOTTOM w0.102: v2(100.38,116.77) 100.34,116.8 100.34,121.78 100.85,122.29 100.85,124.31 100.48,124.69 100.48,127.78 100.85,128.15 v1(100.85,128.36) 100.85,136.82 R435.1
COMP_VGA: length 13.7
  TOP w0.203: PC871.1 191.2,138.95 191.1,138.86 PU801.7
  TOP w0.254: PC871.1 192.65,138.95 PC848.1 193.27,138.33 v2(193.27,138.29)
  BOTTOM w0.254: PC847.1 193.34,142.35 193.93,141.76 v1(193.93,140.1) 193.93,138.95 v2(193.27,138.29) 192.73,138.83 PR841.2 192.65,138.83 PC873.2 190.88,138.83 190.51,138.46 190.51,138.2 189.88,137.57 PR840.1
CPU_B+: length 28.3
  IN1 w0.254: v4(27.11,99.57) 27.11,106.37 24.94,108.54 21.46,108.54 20.53,109.47 v2(20.53,111.57)
  IN2 w0.254: v2(20.53,111.57) 20.53,116.43 17.88,119.09 17.88,120.16 17.51,120.53 v2(16.94,120.53)
  BOTTOM w0.254: v2(16.94,120.53) 17.16,120.31 PR907.2
  vias: v3(42.7,129.19) v4(27.1,98.93) v4(27.1,98.29) v4(27.1,97.62) v4(27.1,96.98) v4(27.09,96.33) v4(37.67,131.35) v4(38.33,131.35) v4(38.98,131.33) v4(39.61,131.34) v4(40.34,131.33) v4(41,131.32) v4(41.64,131.31) v4(42.28,131.31) v4(71.58,132.86) v4(72.03,133.33) v4(72.01,132.38) v4(72.46,132.85) v4(72.46,131.93) v4(72.91,132.4) v4(72.94,131.47) v4(73.39,131.94)
CPU_PLTRST#: length 102.6
  TOP w0.089: U4.AU4 120.31,93.26 119.56,94.01 119.56,94.09 119.25,94.4 119.25,94.41 118.81,94.84 118.81,94.85 118.5,95.16 118.49,95.16 117.65,96.01 115.73,96.01 v2(115.27,96.46)
  TOP w0.102: v1(44.88,102.56) 45.42,103.11 v2(45.56,103.11) 45.57,103.1 R37.1
  IN1 w0.127: v2(45.56,103.11) 47.42,104.96 47.42,107.32 48.36,108.26 48.36,111.3 47.73,111.92 47.73,114.06 48.46,114.78 52.18,114.78 53.53,113.43 55.28,113.43 55.75,112.96 83.38,112.96 85.45,110.89 85.45,103.97 86.49,102.93 86.49,100.23 87.23,99.49 90.37,99.49 91.1,100.23 99.31,100.23 100.24,99.3 104.47,99.3 106,97.76 108.43,97.76 109.18,97.01 114.72,97.01 v2(115.27,96.46)
CRT_DDC_CLK: length 176.4
  TOP w0.089: U4.M43 130.57,76.31 130.57,75.82 130.89,75.5 130.89,73.18 131.38,72.69 132.17,72.69
  TOP w0.102: v2(131.06,68.17) 132.06,69.18 132.06,71.74 R126.2 132.17,72.69
  IN2 w0.127: v2(14.84,117.97) 15.36,117.45 15.36,112.83 15.55,112.64 15.55,106.27 15.2,105.91 15.2,97.19 23.44,88.95 27.7,88.95 29.73,86.91 30.32,86.91 v2(30.54,87.14)
  BOTTOM w0.102: U10.11 11.41,118.56 11.68,118.3 12.74,118.3 13.13,117.9 14.78,117.9 v2(14.84,117.97) ; v2(131.06,68.17) 130.27,68.17 126.33,64.23 110.71,64.23 106.2,68.73 64.58,68.73 64.35,68.5 35.74,68.5 32.44,71.8 v1(32.44,79.03) 32.44,85.59 31.09,86.94 30.74,86.94 v2(30.54,87.14)
CRT_DDC_CLK_CONN: length 8.5
  TOP w0.102: v2(11.86,118.87) 11.52,119.2 R33.2
  BOTTOM w0.102: JCRT1.15 8.55,122.13 10.87,122.13 v1(11.27,121.73) 12.05,120.95 U10.12 12.05,119.06 v2(11.86,118.87)
CRT_DDC_DAT_CONN: length 10.8
  TOP w0.102: R31.2 10.59,119.05 10.46,118.92 v2(10.14,118.92)
  BOTTOM w0.102: v2(10.14,118.92) U10.9 10.14,121.63 10.08,121.69 v1(9.85,121.69) 9.1,121.69 8.68,121.27 8.68,117.59 JCRT1.12
CRT_DDC_DATA: length 175.5
  TOP w0.089: 131.14,72.63 130.47,73.3 U4.M45
  TOP w0.102: 131.14,72.63 R125.2 131.5,72.27 130.61,71.38 130.61,68.01 v2(131.06,67.56)
  IN2 w0.127: v2(30.57,86.46) 30.37,86.66 29.63,86.66 27.65,88.64 23.3,88.64 14.94,97 14.94,106.02 15.3,106.37 15.3,112.53 15.11,112.72 15.11,117.07 v2(14.84,117.33)
  BOTTOM w0.102: U10.10 10.78,118.6 11.31,118.07 12.65,118.07 13.04,117.68 14.5,117.68 v2(14.84,117.33) ; v2(131.06,67.56) 130.37,66.88 v1(129.85,66.88) 129.3,66.88 126.42,64 110.61,64 106.11,68.5 64.68,68.5 64.45,68.27 35.65,68.27 32.11,71.81 32.11,85.59 31.02,86.69 30.79,86.69 v2(30.57,86.46)
