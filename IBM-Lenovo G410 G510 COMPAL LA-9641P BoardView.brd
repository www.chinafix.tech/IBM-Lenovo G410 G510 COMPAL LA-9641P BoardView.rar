# Allegro board IBM-Lenovo G410 G510 COMPAL LA-9641P BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 239.5
  TOP w0.127: v2(146.16,56.69) v3(146.82,57.35)
  TOP w0.254: v2(24.24,54.42) v3(26.44,56.62) 29.51,59.69 CA42.2
  TOP w0.508: CA4.2 151.78,47.7 v2(151.94,47.86) ; CA3.1 148.53,47.42 v2(149.17,46.78) 148.52,46.14 CA18.2 ; CA1.2 v2(149.84,42.82) ; v2(148.59,45.04) 149,44.63 150.43,44.63 151.24,45.44 CA20.2 ; v2(146.16,56.69) 145.73,56.26 CA65.2 ; CA44.2 154.7,41.46 v3(157.02,41.46) v2(157.47,41.91) CA66.2 ; CA2.2 v2(152.24,42.97) ; CA42.2 28.89,66.24 28.29,65.64 23.92,65.64 22.55,67.02 22.55,68.9 MIC1.2 ; CA64.2 v2(148.95,56.63)
  IN2 w0.254: v2(148.59,45.04) 146.57,47.06 146.57,53.68 145.26,54.99 134.59,54.99 132.95,53.35 132.95,46.59 131.88,45.52 126.11,45.52 124.63,44.05 124.63,29.43 115.53,20.33 48.27,20.33 47.5,19.56 42.33,19.56 41.63,18.86 41.63,17.92 40.27,16.57 26.51,16.57 23.4,19.67 23.4,32.76 24.72,34.08 24.72,53.93 v2(24.24,54.42)
V1N_CPU: length 21.8
  TOP w0.254: v2(37.53,120.06) 37.55,120.04 37.55,117.51 33.45,113.42 v1(30.68,113.42) 30.24,113.42 29.17,112.34 27.09,112.34 PR939.2
  BOTTOM w0.254: PL902.3 40.28,121.71 38.91,120.34 37.81,120.34 v2(37.53,120.06)
V1N_VGA: length 24.7
  TOP w0.102: v2(182.53,146.21) v1(182.53,146.77)
  IN2 w0.254: v2(163.37,147.88) 165.22,147.88 166.45,149.11 181.24,149.11 182.53,147.82 v2(182.53,146.21)
  BOTTOM w0.254: PR858.1 v2(182.53,146.21) ; PL803.3 v2(163.37,147.88)
V2N_CPU: length 31.2
  TOP w0.254: PR941.2 v2(23.22,111.9)
  IN2 w0.254: v2(37.05,118.55) 38.34,117.26 v2(38.34,110.4)
  BOTTOM w0.254: v2(37.05,118.55) 37.7,117.9 37.7,116.54 33.66,112.49 27.89,112.49 26.49,111.1 24.56,111.1 23.76,111.9 v2(23.22,111.9) ; v2(38.34,110.4) 38.34,112.76 PL903.3
V2N_VGA: length 28.4
  IN1 w0.254: v2(163.25,135.51) 163.25,141.73 164.45,142.93 180.01,142.93 180.7,143.62 v2(181.13,143.62)
  BOTTOM w0.254: PL802.3 v2(163.25,135.51) ; v2(181.13,143.62) 181.13,144.03 181.34,144.23 v1(181.6,144.23) 182.32,144.23 PR829.1
V3N_CPU: length 11.4
  BOTTOM w0.254: PR944.2 21.7,113.79 21.7,112.65 24.54,109.8 24.54,108.84 25.32,108.06 PL904.3
VCC_VCORE2:
  vias: v1(28.62,90.18)
VCCSENSE: length 103.9
  TOP w0.406: v2(55.51,114.57) 55.42,114.66 55.42,118.68 R79.2
  IN2 w0.203: v2(17.33,124.7) 17.72,124.31 17.72,123.32 15.76,121.35 15.76,119.21 17.09,117.88 17.09,113.45 16.17,112.53 16.17,106.01 15.82,105.65 15.82,97.45 22.49,90.78 34.94,90.78 38.59,94.43 42.49,94.43 44.73,96.67 45.5,96.67 46.41,97.58 46.41,113.49 47.88,114.96 49.99,114.96 51.51,113.43 54.72,113.43 55.51,114.22 v2(55.51,114.57)
  BOTTOM w0.102: v2(17.33,124.7) 17.33,125.53 v1(16.86,126.01)
  BOTTOM w0.203: PC903.2 19.06,123.03 19.56,122.52 PU901.35
  BOTTOM w0.406: v2(17.33,124.7) 17.33,123.98 17.6,123.72 18.21,123.72 18.58,123.35 PC903.2 ; JCPU1.AL35 v2(55.51,114.57)
VCCSENSE_VGA: length 60.4
  TOP w0.102: v2(189.97,144.89) 190.43,144.89 v1(190.62,145.08)
  IN1 w0.254: v2(189.97,144.89) 189.23,145.64 186.73,145.64 186.35,146.02 184.41,146.02 183.8,145.42 181.41,145.42 181.37,145.37 181.36,145.37 179.76,143.77 164.42,143.77 164.41,143.77 162.79,143.77 161.86,142.83 161.86,138.43 158.14,134.71 153.73,134.71 153.12,135.33 150.46,135.33 150.04,134.9 147.7,134.9 147.4,135.2 143.76,135.2 143.22,134.65 140.95,134.65 v2(140.44,134.14)
  BOTTOM w0.203: v2(140.44,134.14) 140.85,134.55 UV1.AF28
  BOTTOM w0.254: v2(189.97,144.89) 189.52,144.89 PR854.1
VDD_VGA: length 12.1
  TOP w0.102: v1(179.78,139.41) 180.23,138.96 v2(180.48,138.96)
  TOP w0.203: PU801.16 187.02,141.92 v2(187.05,141.94)
  IN1 w0.254: v2(180.48,138.96) 180.48,139.77 181.9,141.18 186.4,141.18 187.05,141.83 v2(187.05,141.94)
  BOTTOM w0.254: PR848.1 v2(180.48,138.96) ; PC876.1 187.05,141.42 v2(187.05,141.94)
VIN: length 136.4
  TOP w0.508: PR322.2 PR325.2 161.97,166.26 161.57,165.87 161.57,164.24 v3(163.24,162.57) v2(164.81,161) ; v2(193.1,134.93) 194.05,135.89 194.05,137.86 195.37,139.18 195.37,143.96 v3(194.4,144.94) 193.3,146.03 189.82,146.03 188.68,147.17 v4(188.68,147.22) ; PR110.1 193.55,84.66 189.42,84.66 188.88,85.19 188.88,90.37 193.53,95.02 193.53,96.67 192.96,97.24 v2(186.9,97.24) ; PR309.1 191.44,164.59 191.44,163.85 190.71,163.12 v2(190.71,162.81) 191.44,162.08 191.44,155.36
  IN1 w0.508: v2(193.1,134.93) 193.1,130.86 190.79,128.55 190.79,122.05 191.6,121.24 191.6,117.05 186.9,112.35 v2(186.9,97.24) ; v2(190.71,162.81) 182.12,162.81 v2(181.6,162.3)
  IN2 w0.254: v4(184.1,152.38) 185.29,152.38 186.57,151.09 v4(186.57,150.81)
  IN2 w0.508: v2(181.6,162.3) 180.31,161 v2(164.81,161)
  BOTTOM w0.254: v4(184.1,152.38) 184.01,152.29 PR302.1
  vias: v3(186.19,152.82) v4(184.97,148.02) v4(186.81,147.63) v4(186.82,146.97) v4(186.9,149.65) v4(186.89,148.97) v4(186.93,148.28) v4(187.45,147.16) v4(187.51,147.86) v4(188.06,148.26) v4(188.08,147.56) v4(188.07,146.89) v4(188.7,148.55) v4(188.72,147.86)
VIN_VGA: length 9.5
  TOP w0.102: v2(181.2,141.43) 181.2,141.32 v1(180.79,140.92)
  TOP w0.203: v2(186.47,141.97) 186.55,141.88 186.55,140.8 PU801.17
  IN1 w0.254: v2(186.47,141.97) 186.25,142.19 184.44,142.19 184.43,142.2 184.01,142.2 184,142.19 181.96,142.19 v2(181.2,141.43)
  BOTTOM w0.254: v2(186.47,141.97) 186.47,141.63 PC877.1 ; PR845.1 181.4,141.23 v2(181.2,141.43)
VSSSENSE: length 100.2
  TOP w0.406: R84.1 56.35,118.66 56.35,114.75 v2(56.51,114.58)
  IN2 w0.203: v2(56.51,114.58) 55.91,113.98 55.68,113.98 54.85,113.14 51.39,113.14 49.91,114.63 48.01,114.63 46.74,113.36 46.74,97.44 45.64,96.34 44.86,96.34 42.63,94.1 38.73,94.1 35.07,90.45 22.35,90.45 15.49,97.31 15.49,105.79 15.84,106.15 15.84,112.67 16.76,113.59 16.76,117.74 15.43,119.07 15.43,121.49 17.03,123.09 v2(17.03,123.37)
  BOTTOM w0.102: v1(16.5,123.22) 16.64,123.37 v2(17.03,123.37)
  BOTTOM w0.406: v2(17.03,123.37) 17.36,123.03 PC903.1 PR909.1 17.67,121.23 PC906.1 ; JCPU1.AK35 v2(56.51,114.58)
VSSSENSE_VGA: length 60.2
  TOP w0.102: v2(188.65,145.08) v1(189.28,145.08)
  TOP w0.254: PR860.1 188.26,144.69 v2(188.65,145.08)
  IN1 w0.254: v2(141.63,134.12) 144.76,134.12 144.91,133.97 150.77,133.97 151.75,134.94 152.96,134.94 153.57,134.33 158.3,134.33 162.24,138.27 162.24,142.67 162.95,143.39 179.92,143.39 181.57,145.04 183.96,145.04 184.57,145.64 186.19,145.64 186.57,145.26 188.47,145.26 v2(188.65,145.08)
  BOTTOM w0.203: UV1.AH29 142.62,134.3 142.07,134.3 141.89,134.12 v2(141.63,134.12)
  BOTTOM w0.254: v2(188.65,145.08) PC849.2 PR847.1
24737_SN: length 0.9
  BOTTOM w0.102: 167.96,153.83 v1(167.96,152.91)
81103_PWM: length 47.8
  TOP w0.102: v2(28.25,92.68) 27.2,93.72 v1(26.65,93.72)
  TOP w0.254: v2(28.25,92.68) 28.47,92.45 PU902.2
  IN1 w0.254: v2(25.28,117.37) 25.28,115.77 24.52,115.01 24.52,113.23 23.73,112.45 19.6,112.45 18.98,113.07 17.73,113.07 16.79,112.14 16.79,95.86 18.73,93.92 27.01,93.92 v2(28.25,92.68)
  BOTTOM w0.203: PU901.20 24.69,118.34 25.28,117.75 v2(25.28,117.37)
  BOTTOM w0.254: PR922.1 25.28,117.35 v2(25.28,117.37)
+1.1_AVDDL: length 17.1
  TOP w0.203: CL18.1 32.89,31.48 UL1.13 ; CL17.1 29.36,30.84 29.68,30.52 30.18,30.52 30.49,30.21 UL1.19 ; UL1.6 35.89,27.26 36.37,27.73 36.68,27.73
  TOP w0.508: v2(28.47,31.05) 28.47,31.38 28.77,31.68 CL17.1 ; CL18.1 33.55,32.87 v2(33.38,33.04)
  BOTTOM w0.508: v2(36.81,28.31) 36.81,30.15 35.04,31.92 34.5,31.92 v2(33.38,33.04)
  vias: v1(28.34,17.69) v2(28,21.8) v2(28,21.19)
+1.1_AVDDL_L: length 2.3
  TOP w0.203: UL1.34 31.29,23.82 31.14,23.68 31.14,22.71 CL5.1
  vias: v1(30.58,18.48)
+1.1_DVDDL: length 4.7
  TOP w0.203: 32.82,22.98 32.71,23.09 32.71,23.82 32.49,24.04 UL1.37
  TOP w0.508: CL25.1 CL26.1 32.82,21.87 32.82,22.98
  vias: v1(33.79,18.79)
+1.7_VDDCT: length 5.7
  TOP w0.203: RL10.1 39.55,27.06 37.15,27.06 36.92,27.29 36.39,27.29 v1(35.96,26.86) UL1.5
+2.7_AVDDH: length 18.7
  TOP w0.102: v2(27.38,30.11) v1(27.38,30.92)
  TOP w0.203: CL22.1 27.38,28.46 UL1.22 ; UL1.9 34.9,28.46 35.44,28.99 35.44,30.28 36.01,30.86 CL23.1
  TOP w0.508: v2(27.38,30.11) CL22.1
  IN2 w0.508: v2(27.38,30.11) 28.47,30.11 29.32,29.27 34.05,29.27 36.3,31.52 v2(36.49,31.52)
+CHGRTC: length 1.5
  TOP w0.102: PR101.1 v3(194.05,27.29)
+CHGRTC_R: length 19.1
  TOP w0.102: PR102.2 v1(201.06,27.02)
  TOP w0.508: v2(199.78,26.21) PR102.2
  IN1 w0.508: v2(199.78,26.21) 207.81,26.21 210.12,23.9 210.12,20.57 v2(209.46,19.91)
  BOTTOM w0.508: JRTC1.1 209.01,20.35 v2(209.46,19.91)
+CPU_CORE: length 0.7
  TOP w0.508: R79.1 v2(54.51,119.42)
  vias: v2(57.04,106.41) v2(57.04,105.41) v2(57.04,104.41) v2(57.04,103.41) v2(57.02,102.63) v2(57.03,101.13) v2(57.07,113.45) v2(57.07,112.45) v2(57.07,111.45) v2(57.07,110.45) v2(57.07,109.45) v2(57.07,108.45) v2(57.06,101.9) v2(57.91,105.5) v2(58.04,114.41) v2(58.04,113.41) v2(58.04,112.41) v2(58.04,111.41) v2(58.04,110.41) v2(58.04,109.41) v2(58.04,108.41) v2(58.04,107.41) v2(58.04,106.41) v2(58.04,104.41) v2(58.04,103.41) v2(58.06,102.64) v2(58.06,101.9) v2(58.07,101.13) v2(58.33,99.1) v2(58.53,95.17) v2(59.04,113.41) v2(59.04,111.41) v2(59.04,109.41) v2(59.04,107.41) v2(59.04,105.41) v2(59.04,103.41) v2(59.05,102.63) v2(59.04,99.11) v2(59.06,101.9) v2(59.06,101.13) v2(59.24,95.18) v2(60.04,114.41) v2(60.04,113.41) v2(60.04,112.41) v2(60.04,111.41) v2(60.04,110.41) v2(60.04,109.41) v2(60.04,108.41) v2(60.04,107.41) v2(60.04,106.41) v2(60.04,105.41) v2(60.04,104.41) v2(60.04,103.41) v2(60.04,102.65) v2(60.05,101.9) v2(60.05,101.14) v2(60.56,99.09) v2(60.61,95.17) v2(61.04,113.41) v2(61.04,111.41) v2(61.04,109.41) v2(61.04,107.41) v2(61.04,105.41) v2(61.09,103.36) v2(61.06,102.58) v2(61.1,101.85) v2(61.08,101.07) v2(61.27,99.1) v2(61.32,95.18) v2(62.04,114.41) v2(62.04,113.41) v2(62.04,112.41) v2(62.04,111.41) v2(62.04,110.41) v2(62.04,109.41) v2(62.04,108.41) v2(62.04,107.41) v2(62.04,106.41) v2(62.04,105.41) v2(62.04,104.41) v2(62.09,103.36) v2(62.1,102.59) v2(62.1,101.85) v2(62.12,101.08) v2(62.7,95.17) v2(62.84,99.06) v2(63.04,113.41) v2(63.04,111.41) v2(63.04,109.41) v2(63.04,107.41) v2(63.04,105.41) v2(63.09,103.36) v2(63.1,102.58) v2(63.1,101.85) v2(63.11,101.07) v2(63.41,95.18) v2(63.55,99.07) v2(64.04,114.41) v2(64.04,113.41) v2(64.04,112.41) v2(64.04,111.41) v2(64.04,110.41) v2(64.04,109.41) v2(64.04,108.41) v2(64.04,107.41) v2(64.04,106.41) v2(64.04,105.41) v2(64.04,104.41) v2(64.09,103.36) v2(64.09,102.59) v2(64.1,101.85) v2(64.1,101.09) v2(64.93,95.24) v2(65.04,113.41) v2(65.04,111.41) v2(65.04,109.41) v2(65.04,107.41) v2(65.04,105.41) v2(65,99.04) v2(65.64,95.24) v2(65.7,99.04) v2(66.04,114.41) v2(66.04,113.41) v2(66.04,112.41) v2(66.04,111.41) v2(66.04,110.41) v2(66.04,109.41) v2(66.04,108.41) v2(66.04,107.41) v2(66.04,106.41) v2(66.04,105.41) v2(66.04,104.41) v2(67.04,110.41) v2(67.04,109.41) v2(67.04,108.41) v2(67.04,107.41) v2(67.04,106.41) v2(67.04,105.41) v2(67.23,99.02) v2(67.18,95.21) v2(67.94,99.03) v2(67.89,95.22) v2(68.04,105.41) v2(68.04,104.41) v2(67.98,103.34) v2(67.95,102.56) v2(67.99,101.83) v2(67.97,101.05) v2(68.9,104.42) v2(68.98,103.34) v2(68.99,102.57) v2(68.99,101.83) v2(69.01,101.06) v2(69.72,99.06) v2(69.69,95.24) v2(70.04,104.41) v2(69.98,103.34) v2(69.99,102.56) v2(69.99,101.83) v2(70,101.05) v2(70.43,99.07) v2(70.4,95.24) v2(71.04,104.41) v2(70.98,103.34) v2(70.98,102.57) v2(70.99,101.83) v2(70.99,101.07) v2(72.04,104.41) v2(72.16,99.07) v2(72.87,99.08) v2(73.03,104.4) v2(74.03,104.38) v2(74.64,99.06) v2(75.03,104.38) v2(75.15,102.93) v2(75.18,102.33) v2(75.18,101.75) v2(75.18,100.99) v2(75.34,99.07) v2(75.99,104.37) v2(75.99,102.93) v2(76.02,102.33) v2(76.92,99.08) v2(77.55,99.08) v3(46.35,121.14) v4(39.75,110.1) v4(39.77,110.82) v4(40.53,110.07) v4(40.55,110.79) v4(40.88,111.79) v4(41.28,110.82) v4(41.25,110.1) v4(41.65,118.75) v4(41.64,118.08) v4(41.66,117.38) v4(41.66,111.76) v4(42.03,110.07) v4(42.06,110.79) v4(42.36,118.76) v4(42.36,118.09) v4(42.37,117.4) v4(42.35,111.78) v4(42.73,110.08) v4(42.75,110.8) v4(42.95,116.04) v4(42.97,115.35) v4(43.15,118.08) v4(43.12,113.88) v4(43.12,113.19) v4(43.13,112.51) v4(43.15,118.75) v4(43.16,117.38) v4(43.16,114.6) v4(43.16,111.81) v4(43.53,110.77) v4(43.5,110.05) v4(43.68,116.06) v4(43.7,115.36) v4(43.8,114.6) v4(43.8,113.84) v4(43.8,113.21) v4(43.8,112.57) v4(43.9,118.75) v4(43.89,118.08) v4(43.91,117.38) v4(44.62,118.09) v4(44.64,117.4) v4(49.13,124.84) v4(49.55,125.45) v4(49.99,124.81) v4(53.48,124.97) v4(53.92,125.51) v4(54.36,124.94) v4(57.18,124.9) v4(57.2,123.71) v4(57.21,122.46) v4(57.28,121.09) v4(58.15,122.81) v4(58.06,120.43) v4(58.21,121.6) v4(58.38,124.03) v4(58.97,119.72) v4(59.18,122.04) v4(59.15,120.89) v4(59.32,123.29) v4(59.88,118.83) v4(60.22,121.26) v4(60.17,120.08) v4(60.33,122.51) v4(60.81,117.97) v4(61.15,119.16) v4(61.23,120.33) v4(61.39,121.64) v4(62,118.18) v4(62.34,119.36) v4(62.4,120.53) v4(63.33,119.68) v4(63.28,118.4) v4(63.61,120.76) v4(64.28,118.78)
+DP_V33: length 1.8
  TOP w0.254: UT2.3 81.51,130.98
  vias: v1(81.83,127.81) v2(81.07,128.5) v2(81.07,127.91)
+DP_VDDR: length 4.4
  TOP w0.102: 147.53,131.01 147.43,130.91 v1(147.43,130.27)
  IN2 w0.508: v2(145.66,131.86) 145.66,131.16 v2(144.01,129.51)
  BOTTOM w0.254: UV1.AM32 146.05,131.47 v2(145.66,131.86)
  vias: v2(143.3,129.51)
+EC_VCCA: length 65.1
  TOP w0.254: 158.88,89.42 158.88,88.73 159.46,88.16 U31.67
  TOP w0.508: PR226.1 v2(182.07,60.55)
  IN2 w0.508: v2(188.06,87.08) 186.74,87.08 186.12,87.7 181.96,87.7 181.71,87.94 179.6,87.94 178.86,87.21 176.65,87.21 176.17,87.69 173.41,87.69 173,87.28 171.32,87.28 170.02,88.58 160.23,88.58 v2(158.86,89.95)
  BOTTOM w0.508: v2(182.07,60.55) 182.67,61.15 v1(182.67,67.27) 182.67,68.87 182.15,69.39 182.15,74.08 183.5,75.43 184.97,75.43 188.06,78.52 v2(188.06,87.08)
+LCDVDD_CONN:
  vias: v1(91.28,146.73) v2(91.61,144.9) v2(91.9,145.49) v2(92.19,144.9)
+LDO_1.8V: length 2.1
  TOP w0.203: 160.84,47.8 160.76,47.72 159.86,47.72 159.58,48 159.45,48 159.38,48.07 UA1.3
+LDO_OUT_3.3V: length 2
  TOP w0.203: 151.98,48.47 151.98,48.47 v1(152.62,48.47) UA1.27
+LEDVDD:
  vias: v1(99.41,153.07) v2(99.68,153.64) v2(100.18,153.31) v2(100.64,152.96)
+LX:
  vias: v1(35.29,23.42)
+MICBIASB: length 15.8
  TOP w0.203: v2(155.86,45.65) 155.85,45.67 UA1.34
  TOP w0.254: RA20.1 RA19.1 146.48,51.31 v1(146.48,48.18) v2(147.05,47.61)
  IN2 w0.254: v2(155.86,45.65) 151.16,45.65 149.21,47.61 v2(147.05,47.61)
+MICBIASC: length 3.1
  TOP w0.203: RA23.1 156.82,45.15 156.32,45.65 156.32,45.94 156.25,46.01 UA1.35
+MPV18: length 3.3
  TOP w0.508: LV4.2 132.42,149.03 130.35,149.03
  BOTTOM w0.254: UV1.H8 126.82,150.7 126.84,150.7 v2(126.86,150.68) ; v2(126.09,151.47) 126.45,151.84 UV1.H7
  vias: v1(129.23,149.07)
+PCH_DCPRTC: length 3.9
  TOP w0.254: U4.P16 129.77,87.8 129.41,88.16 v2(129.41,88.22) 129.78,88.6 U4.P14
  BOTTOM w0.089: v2(129.41,88.22) 130.07,88.22 130.16,88.14 131.15,88.14 v1(131.26,88.02)
  BOTTOM w0.457: C163.1 128.99,88.78 129.41,88.36 v2(129.41,88.22)
+PCH_USB_DCPSUS1: length 0.6
  TOP w0.254: v2(127.78,89.48) 127.5,89.21 U4.Y12
  vias: v1(127.82,88.73)
+PCH_USB_DCPSUS2: length 0.7
  TOP w0.254: v2(127.83,80.19) 127.65,80.19 127.29,79.83 U4.Y35
  vias: v1(128.43,80.02)
+PCH_USB_DCPSUS3: length 3.5
  TOP w0.254: U4.AJ28 123.84,83.01 v2(124.16,83.33) 123.84,83.66 U4.AJ26
  BOTTOM w0.089: v1(123.93,85.37) 123.93,84.88 123.68,84.63 123.68,83.68 124.02,83.33 v2(124.16,83.33)
+PCH_VCC: length 0.7
  TOP w0.102: 116.92,69.06 116.92,68.41 v1(116.9,68.39)
+PCH_VCCCFUSE: length 20.5
  TOP w0.254: U4.P18 U4.P20 129.78,86.15 v2(129.39,85.76)
  IN1 w0.254: v2(137.97,72.8) 137.21,72.8 136.21,73.79 136.21,75.38 135.5,76.09 135.5,82.32 134.26,83.57 132.97,83.57 132.05,84.5 130.58,84.5 129.39,85.68 v2(129.39,85.76)
  BOTTOM w0.102: v2(137.97,72.8) v1(137.97,72.21)
+PCH_VCCCLK: length 1.3
  BOTTOM w0.102: v1(124.8,73.05) 125.55,73.8 125.55,73.99
  vias: v2(125.3,80.74) v2(125.31,80.12)
+PCH_VCCCLK3_3: length 1.1
  TOP w0.254: U4.V32 127.8,81.39 v2(128.12,81.71) 128.46,81.37 U4.U32
  vias: v1(133.24,81.38) v2(130.58,82.01) v2(131.17,82.03)
+PCH_VCCDSW: length 19.4
  TOP w0.254: U4.U14 128.46,88.53 v2(128.81,88.19)
  TOP w0.508: v2(134.07,96.67) 134.16,96.58 134.73,96.58 135.31,97.16 R290.2
  IN2 w0.508: v2(134.07,96.67) 134.22,96.52 134.22,96.06 132.99,94.83 132.38,94.83 131.21,93.66 127.68,93.66 126.21,92.19 126.21,89.27 126.61,88.87 127.25,88.87 127.93,88.19 v2(128.81,88.19)
  BOTTOM w0.102: v1(134.86,96.86) 134.67,96.67 v2(134.07,96.67)
+PCH_VCCDSW3_3: length 3
  TOP w0.254: v2(136.88,87.96) 136.88,87.92 136.47,87.51 135.86,87.51 135.71,87.66 U4.A16
  BOTTOM w0.089: R307.1 135.6,87.12 v1(135.22,87.5)
+PCH_VCCDSW_R: length 2
  TOP w0.102: v1(136.33,99.32) 136.1,99.09 C149.1
  TOP w0.508: C149.1 135.31,98.26 R290.1
+PCH_VCCSST: length 2.4
  TOP w0.254: U4.AA14 126.48,88.69 126.83,89.04 126.83,89.57 v2(126.83,89.57)
  BOTTOM w0.089: v1(127.26,89.94) 126.89,89.57 v2(126.83,89.57)
  BOTTOM w0.508: C156.1 126.82,89.55 v2(126.83,89.57)
+PCH_VPROC: length 27.1
  TOP w0.254: v2(124.21,88.22) 123.84,88.59 U4.AJ14 123.74,88.72 U4.AJ12
  TOP w0.508: R297.1 122.41,67.15 C171.1 122.41,68.37 v2(122.58,68.54)
  IN1 w0.508: v2(122.58,68.54) 122.26,68.54 121.88,68.92 121.88,70.13 124.99,73.24 124.99,75.05 126.6,76.67 126.6,77.67 126.11,78.17 126.11,82.26 125.45,82.92 125.45,86.2 124.21,87.44 v2(124.21,88.22)
  BOTTOM w0.102: v2(122.58,68.54) v1(121.86,68.54)
+PCIE_VDDR: length 1.1
  BOTTOM w0.254: v2(138.4,127.39) 138.4,127.56 137.85,128.11 UV1.AB37
  vias: v1(138.16,127.92)
+RTCBATT: length 122.7
  TOP w0.102: v2(197.71,30.36) v3(197.71,31.14)
  TOP w0.508: PD101.1 v2(197.71,30.36)
  IN2 w0.508: v2(188.06,87.74) 187.19,87.74 186.51,88.42 182.39,88.42 181.97,88.85 175.39,88.85 174.9,88.35 173.02,88.35 172.61,88.76 171.18,88.76 170.47,89.47 160.95,89.47 159.51,90.92 146.6,90.92 145.76,91.75 v2(143.01,91.75)
  BOTTOM w0.508: v2(143.01,91.75) 142.05,90.79 R94.2 ; v2(188.06,87.74) 188.32,87.74 188.69,87.37 188.69,76.86 186.63,74.8 183.76,74.8 183.3,74.33 183.3,71.62 184.1,70.81 184.1,66.75 183.43,66.08 183.43,62.96 184.82,61.58 184.82,58.05 181.08,54.32 181.08,48.87 185.75,44.21 185.75,42.33 v2(197.71,30.36)
+RTCVCC: length 45.3
  TOP w0.102: v2(156.78,91.55) 156.08,91.55 v3(155.99,91.46)
  TOP w0.254: U4.A6 v2(135.96,91.65)
  TOP w0.508: R134.1 138.23,93.4 136.47,91.65 v2(135.96,91.65) ; v2(156.06,74.15) 156.06,73.72 156.51,73.27 R652.2 ; R98.1 140.25,94.07 140.25,91.77 v2(140.13,91.65) 140.13,91.65 R96.1
  IN2 w0.508: v2(140.13,91.65) 140.97,92.49 145.93,92.49 146.86,91.55 v2(156.78,91.55)
  BOTTOM w0.508: v2(156.06,74.15) 156.06,74.34 157.18,75.45 157.18,80.83 156.43,81.58 156.43,85.29 156.85,85.71 156.85,91.48 v2(156.78,91.55)
+SPLL_VDDC:
  vias: v1(152.36,152.04)
+SPV18: length 1.2
  TOP w0.102: 149.05,148.89 v1(149.05,148.27)
  BOTTOM w0.254: v2(146.45,149.07) 146.43,149.07 146.05,149.45 UV1.AM10
+SWR_LX: length 2.6
  TOP w0.254: 85.38,125.19 85.37,125.2 v1(85.37,126.2) 85.5,126.33 UT2.12
+SWR_V12: length 21.5
  TOP w0.254: v2(82.21,128.98) UT2.7 ; UT2.27 86.5,133.81 86.69,134 CT11.1 ; 83.45,126.01 84.44,126.01 85,126.58 UT2.11
  TOP w0.508: CT11.1 v2(87.54,135.13)
  IN1 w0.508: v2(87.54,135.13) 84.01,135.13 82.99,134.11 82.99,129.75 v2(82.21,128.98) 82.21,126.04 v2(82.28,125.97)
  BOTTOM w0.102: v2(87.54,135.13) v1(88.23,135.13)
+SWR_VDD: length 5.3
  TOP w0.254: v2(86.15,126.67) 86,126.82 UT2.13 ; UT2.18 v2(89.3,128.98)
  BOTTOM w0.508: CT8.1 89.3,128.99 v2(89.3,128.98) 88.68,128.98 88.55,128.85 88.55,127.32
  vias: v1(85.52,126.84) v2(86.15,126.06) v2(86.74,126.04)
+TSVDD: length 1.3
  TOP w0.102: 146.86,128.14 v1(146.86,127.48)
  BOTTOM w0.381: v2(143.91,131.04) 143.48,131.47 UV1.AJ32
+USB3_VCCA:
  vias: v2(18.65,35.97) v2(18.66,35.36) v2(19.24,35.37) v2(19.3,35.98) v3(20.23,49.6)
+USB_VCCB: length 13.3
  IN1 w2.032: 197.36,149.64 196.11,148.39 196.11,136.94 196.02,136.85
  vias: v2(197.06,132.44) v2(197.05,131.79) v2(197.64,131.79) v2(197.65,132.44) v2(200.24,120.38) v2(200.24,119.79) v2(202.28,150.64) v2(202.27,149.99) v2(202.87,150.64) v2(202.86,149.99) v3(198.56,133.44)
+VCOMP_OUT: length 6.2
  TOP w0.254: R60.1 76.35,101.6 R1.1 v1(78.68,100.73) 80.34,100.73 v2(81.07,101.46)
  BOTTOM w0.254: JCPU1.F22 81.03,101.46 v2(81.07,101.46)
+VGA_B+: length 1.8
  BOTTOM w0.254: PR845.2 178.87,140.65 v4(178.74,140.52)
  vias: v3(173.6,143.18) v4(178.16,140.86) v4(178.15,140.18) v4(178.73,139.88) v4(179.57,147.53) v4(179.55,146.85) v4(180.23,147.51) v4(180.22,146.82)
+VGA_CORE: length 135.9
  IN1 w0.254: v4(159.02,146.92) 159.02,148.87 159.62,149.46 159.62,152 160.57,152.96 164.83,152.96 165.38,152.41 165.95,152.41 166.24,152.7 179.14,152.7 181.77,150.07 185.1,150.07 185.94,150.9 185.94,151.08 186.31,151.44 187.51,151.44 189.28,149.68 189.28,147.09 191.55,144.82 v2(191.55,144.72)
  BOTTOM w0.254: v2(191.55,144.72) 190.99,144.72 PR850.1
  BOTTOM w0.381: UV1.AG18 141.81,142.67 v2(141.32,142.19) 140.85,141.72 UV1.AF20 140.44,142.08 v2(140.44,142.16) 140.37,142.16 UV1.AD18 139.35,142.17 v2(139.33,142.17) 139.33,142.15 UV1.AC20 138.43,142.09 v2(138.43,142.17) 138.35,142.17 UV1.AB18 137.35,142.17 v2(137.28,142.17) 137.28,142.1 UV1.AA20 v2(136.35,142.17) UV1.Y18 135.42,142.24 135.29,142.24 v2(135.22,142.17) 135.22,142.04 UV1.V20 134.42,142.11 v2(134.42,142.17) 134.35,142.17 UV1.U18 133.35,142.17 v2(133.29,142.17) 133.29,142.11 UV1.T20 v2(132.35,142.17) UV1.R18 131.77,142.67 v2(131.25,142.15) 130.85,141.76 UV1.N20 UV1.M18 129.85,142.76 v2(130.38,143.29) 130.76,143.67 UV1.N17 130.85,143.76 v2(131.25,144.15) 131.77,144.67 UV1.R16 v2(132.35,144.17) UV1.T17 132.85,143.72 v2(133.29,144.16) 133.8,144.67 UV1.U16 133.92,144.67 v2(134.42,144.17) 134.42,144.11 UV1.V17 134.85,143.77 v2(135.26,144.18) 135.75,144.67 UV1.Y16 v2(136.35,144.17) UV1.AA17 136.85,143.71 v2(137.28,144.13) 137.81,144.67 UV1.AB16 UV1.AC17 138.85,143.79 v2(139.23,144.16) 139.74,144.67 UV1.AD16 140.01,144.67 v2(140.51,144.17) 140.51,144.02 UV1.AF17 141.21,144.03 v2(141.21,144.17) 141.72,144.67 UV1.AG16 ; UV1.M26 129.9,136.67 v2(130.29,136.27) ; UV1.AC27 138.85,135.66 138.36,135.17 ; UV1.AC27 138.87,135.67 139.4,136.21 139.4,136.22 139.85,136.67 UV1.AD26 ; UV1.AC27 138.36,136.16 v2(138.36,136.19) 137.88,136.67 UV1.AB26 137.85,136.67 v2(137.37,136.18) 136.86,135.67 UV1.AA27 136.78,135.67 136.42,136.04 v2(136.42,136.14) 136.32,136.14 135.85,136.6 UV1.Y26 135.81,136.67 135.32,136.18 v2(135.24,136.18) 135.24,136.11 134.85,135.72 UV1.V27 ; UV1.AA13 136.73,146.67 v2(136.25,146.2) ; UV1.AH22 142.85,139.68 v2(142.39,140.14) ; UV1.AB28 137.86,134.67 138.36,135.17 ; v2(136.25,146.2) 136.78,145.67 UV1.AA15 136.97,145.67 v2(137.48,146.18) 137.48,146.3 UV1.AB13 138.23,146.3 v2(138.23,146.21) 138.76,145.67 UV1.AC15 139.03,145.67 v2(139.52,146.16) 139.85,146.49 UV1.AD13 139.84,146.67 139.48,147.03 139.48,147.22 139.02,147.67 UV1.AC12 ; v2(136.25,146.2) 135.85,146.6 UV1.Y13 135.78,146.67 v2(135.28,146.17) 134.85,145.75 UV1.V15 ; 138.36,135.17 v2(138.44,135.17) ; UV1.U26 133.85,136.64 134.32,136.18 v2(134.42,136.18) 134.42,136.07 134.83,135.67 UV1.V27 ; UV1.V27 134.85,135.55 135.22,135.18 135.33,135.18 135.84,134.67 UV1.Y28 ; UV1.R26 v2(132.35,136.17) ; UV1.AH28 UV1.AH27 142.85,135.73 v2(142.39,136.19) ; UV1.M23 UV1.N24 130.86,137.67 v2(131.33,138.15) 131.85,138.67 UV1.R23 v2(132.35,138.17) UV1.T24 133.23,138.05 v2(133.23,138.17) 133.35,138.17 UV1.U23 134.35,138.17 v2(134.45,138.17) 134.45,138.08 UV1.V24 135.2,138.02 v2(135.2,138.17) 135.35,138.17 UV1.Y23 136.35,138.17 v2(136.42,138.17) 136.42,138.11 UV1.AA24 137.28,138.1 v2(137.28,138.15) 137.29,138.15 137.32,138.17 137.35,138.17 UV1.AB23 138.35,138.17 v2(138.51,138.17) 138.51,138.01 UV1.AC24 v2(139.35,138.17) UV1.AD23 UV1.AF22 140.49,140.03 v2(140.49,140.19) 140.33,140.19 UV1.AD21 139.35,140.17 v2(139.28,140.17) 139.28,140.09 UV1.AC22 138.5,140.02 v2(138.5,140.17) 138.35,140.17 UV1.AB21 137.35,140.17 v2(137.28,140.17) 137.28,140.1 UV1.AA22 136.39,140.13 v2(136.39,140.17) 136.35,140.17 UV1.Y21 135.36,140.18 v2(135.17,140.18) 135.17,139.99 UV1.V22 134.45,140.08 v2(134.45,140.16) 134.37,140.16 UV1.U21 133.35,140.17 v2(133.23,140.17) 133.23,140.05 UV1.T22 132.4,140.12 v2(132.4,140.12) UV1.R21 131.35,140.17 v2(131.19,140.17) 131.19,140.01 UV1.N22
  vias: v2(130.32,146.17) v2(130.33,145.16) v2(131.34,146.28) v2(132.34,146.11) v2(134.34,147.15) v2(159.74,138.47) v3(155.38,142.54) v4(151.48,141.36) v4(151.49,140.37) v4(151.73,142.22) v4(151.77,143.01) v4(152.03,139.69) v4(152.08,140.9) v4(152.29,141.63) v4(152.43,142.53) v4(152.69,140.23) v4(152.69,139.11) v4(152.89,141.02) v4(153.17,141.92) v4(153.32,142.75) v4(153.39,139.47) v4(153.54,140.31) v4(153.83,141.28) v4(154.03,142.2) v4(154.02,138.9) v4(154.19,139.72) v4(154.4,140.7) v4(157.68,141.55) v4(157.72,140.28) v4(157.7,139.07) v4(157.84,145.92) v4(157.79,144.96) v4(157.77,143.85) v4(157.78,142.78) v4(157.77,137.73) v4(158.34,144.33) v4(158.33,142.15) v4(158.33,140.95) v4(158.31,139.71) v4(158.34,138.52) v4(158.36,146.54) v4(158.38,145.34) v4(158.36,143.25) v4(158.95,140.18) v4(158.91,139.11) v4(158.94,137.8) v4(159,146.06) v4(159,144.92) v4(158.99,143.9) v4(158.97,142.78) v4(158.96,141.51) v4(160.13,142.67) v4(160.13,141.86) v4(161.21,142.67) v4(161.16,141.84) v4(163.37,145.27) v4(163.37,144.57) v4(164,145.67) v4(164,144.93)
+VREF_1V65: length 2.2
  TOP w0.203: UA1.29 153.09,47.67 152.33,46.91 152.33,46.64
  vias: v1(152.37,46.17)
+VREF_CA: length 16.6
  TOP w0.508: v2(74.59,47.58) 74.62,47.61 C67.1 C68.1 76.59,48.28 77.2,47.67 v1(77.2,45.49) 77.2,44.36 78.1,43.46 78.1,39.89 77.15,38.95
  BOTTOM w0.356: JDIMM1.126 74.42,47.76 v2(74.59,47.58) ; JDIMM2.126 74.42,37.32 v2(74.99,37.89)
+VREF_CA_R: length 133.5
  TOP w0.508: C37.1 73.95,36.29 R47.1 73.95,37.85 v2(73.87,37.93)
  IN1 w0.508: v2(73.87,37.93) 72.56,36.63 29.86,36.63 27.41,39.08 27.41,56.96 28.23,57.77 28.23,85.18 28.51,85.46 28.51,87.69 31.4,90.59 34.01,90.59 34.36,90.23 v2(34.36,89.99)
  BOTTOM w0.305: JCPU1.AM3 54.51,81.92 v2(54.06,81.47)
  BOTTOM w0.508: v2(51.17,78.18) 50.51,78.18 49.16,79.52 49.16,87.34 46.1,90.39 36.2,90.39 35.8,89.99 v2(34.36,89.99)
  vias: v1(53.47,78.43)
+VREF_DQ_DIMMA: length 3.1
  TOP w0.102: v1(33,55.25) 33.54,55.79 v2(33.54,55.91)
  BOTTOM w0.356: v2(33.54,55.91) 33.83,55.91 34.52,56.59
  BOTTOM w0.381: JDIMM1.1 34.52,56.59
+VREF_DQ_DIMMA_R: length 196.5
  TOP w0.508: 86.71,95.15 87.42,95.86 94.01,95.86 94.64,95.23 v2(94.64,95.22) ; v2(24.94,29.2) 24.94,31.58 30.11,36.75 v1(30.11,49.48) 30.11,57.3 30.62,57.81 C39.1 31.66,57.81 R48.1
  IN1 w0.508: v2(95.84,27.32) 96.2,27.32 100.13,31.25 100.13,38.48 100.47,38.82 101.45,39.8 101.45,43.87 102.98,45.4 102.98,50.29 111.4,58.71 111.4,63.84 106.74,68.5 106.74,85.15 97.76,94.13 95.73,94.13 v2(94.64,95.22)
  IN2 w0.508: v2(24.94,29.2) 25.56,28.59 26.36,28.59 28.41,26.54 34.86,26.54 35.81,27.49 37.32,27.49 37.78,27.04 44.02,27.04 44.3,27.32 v2(95.84,27.32)
  BOTTOM w0.254: 80.52,94.94 80.54,94.94 v2(80.96,95.36)
  BOTTOM w0.356: JCPU1.F16 80.52,94.94
+VREF_DQ_DIMMB: length 22.7
  TOP w0.102: 33.41,46.09 v1(32.96,46.09)
  TOP w0.508: v2(28.23,45.39) 28.98,46.14 28.98,57.26 30.39,58.67 30.61,58.67
  BOTTOM w0.356: v2(33.85,46) 34.31,46 34.52,45.79 JDIMM2.1
  BOTTOM w0.508: v2(33.85,46) 28.84,46 v2(28.23,45.39)
+VREF_DQ_DIMMB_R: length 179.3
  TOP w0.508: 86.84,93.89 87.97,95.02 v2(92.84,95.02) ; v2(25.7,29.8) 25.7,31.26 30.87,36.43 v1(30.87,37.32) 30.87,44.68 31.26,45.07 C40.1 31.84,45.07 R49.1
  IN1 w0.508: v2(95.89,28.09) 99.37,31.57 99.37,38.8 100.69,40.11 100.69,44.18 102.22,45.71 102.22,50.61 107.82,56.2 107.82,63.27 105.98,65.11 105.98,84.84 97.45,93.37 94.49,93.37 v2(92.84,95.02)
  IN2 w0.508: v2(95.89,28.09) 43.96,28.09 43.67,27.8 38.46,27.8 37.24,29.02 36.62,29.02 35.86,28.25 35.49,28.25 34.59,27.35 29.65,27.35 27.65,29.35 26.15,29.35 v2(25.7,29.8)
  BOTTOM w0.254: JCPU1.F13 79.77,92.68 v2(79.77,93.09)
+VREFC_A0: length 22.5
  TOP w0.102: CV103.1 103.15,135.63 v1(101.42,135.63)
  TOP w0.152: v2(104.92,135.43) 105.93,135.43 106.11,135.25 106.83,135.25 UV5.M8
  TOP w0.254: v2(113.24,132.09) 113.25,132.09 112.83,131.66 UV5.H1
  TOP w0.381: v2(104.92,135.43) 104.71,135.21 103.7,135.21 CV103.1 103.64,134.24 RV64.1 RV62.2
  IN1 w0.127: 110.56,130.85 110.29,130.58 110.29,130.02 110.48,129.83 110.98,129.83 111.2,130.05 111.83,130.05 112.02,130.24 112.02,130.85
  IN1 w0.254: 108.92,132.36 108.92,131.79 109.13,131.58 109.31,131.58 109.32,131.57 110.08,131.57 110.37,131.28 110.37,131.04 110.56,130.85 ; v2(113.24,132.09) 113.24,132.06 112.02,130.85
  IN1 w0.381: v2(104.92,135.43) 106.61,135.43 107.41,134.62 107.41,133.87 108.92,132.36
+VREFC_A1: length 30.2
  IN1 w0.381: v2(104.59,141.26) 104.59,140.1 103.94,139.45 103.94,134.02 105.59,132.38 v2(105.59,132.08)
  BOTTOM w0.152: UV6.M8 112.43,135.25 112.43,138.45
  BOTTOM w0.254: 107.23,140.64 108.48,140.64 108.84,141 108.84,141.07 109.3,141.53 111.32,141.53 111.58,141.27 111.58,141.01 112.43,140.16 112.43,138.45 ; UV6.H1 106.41,131.65 105.98,132.08 v2(105.59,132.08)
  BOTTOM w0.381: 107.23,140.64 106.23,141.64 v1(105.85,141.64) 104.98,141.64 v2(104.59,141.26) ; 104.31,131.58 105.09,131.58 v2(105.59,132.08)
  BOTTOM w0.508: RV63.2 RV65.1 103.61,130.66 CV104.1 104.31,131.58
+VREFC_A2: length 33.1
  TOP w0.102: v1(103.56,155.91) 103.06,155.4 103.06,154.3 RV68.2
  TOP w0.152: 113.33,149.12 113.32,149.13 112.58,149.13 112.19,149.52 UV7.M8
  TOP w0.254: 113.33,149.12 113.33,149.1 v2(114.19,148.24) ; v2(106,152.35) 106.38,152.72 UV7.H1
  TOP w0.381: v2(106,152.35) 105.53,151.87 103.6,151.87 CV127.1 RV71.1 103.59,153.76 RV68.2
  IN2 w0.127: 110.03,144.76 110.85,145.59 110.81,145.63 107.98,145.63 107.92,145.56 108.72,144.76 110.03,144.76
  IN2 w0.254: 107.92,145.56 107.64,145.56 107.3,145.91 107.3,147.72 106.05,148.97 104.46,148.97 103.96,149.48 103.96,151.03 104.53,151.6 105.25,151.6 v2(106,152.35) ; 110.85,145.59 110.98,145.72 110.98,147.11 111.93,148.07 112.69,148.07 112.88,147.88 113.46,147.88 113.82,148.24 v2(114.19,148.24)
+VREFC_A3: length 33.4
  BOTTOM w0.178: UV8.M8 106.76,149.95 106.03,149.95
  BOTTOM w0.254: UV8.H1 113.35,152.15 113.35,150.64 113.86,150.14 113.86,149.15 113.7,148.99 113.7,146.73 113.9,146.53 113.9,145.91 113.48,145.49 112.81,145.49 112.29,144.97 112.29,143.52 112.12,143.35 111.54,143.35 110.76,142.58 110.6,142.58 109.91,141.89 107.39,141.89
  BOTTOM w0.381: 107.39,141.89 106.87,141.89 105.54,143.22 102.52,143.22 101.88,143.86 v1(101.88,145.44) 101.88,146.58 102.71,147.4 RV67.2 103.55,148.21 RV70.1 CV126.1 105.25,149.17 106.03,149.95
+VREFC_B0: length 41
  TOP w0.152: UV9.M8 131.37,171.17 131.37,172.94
  TOP w0.254: UV9.H1 127.84,165.17 v2(128.2,164.81) ; v2(130.65,174.18) 130.65,173.65 131.37,172.94
  TOP w0.381: RV74.2 128.88,174.85 RV76.1 129.73,174.86 CV149.1 130.65,174.84 v2(130.65,174.18)
  IN1 w0.508: v2(130.65,174.18) 130.65,174.85 131.25,175.45 137.99,175.45 v2(138.82,174.62)
  BOTTOM w0.254: v2(128.2,164.81) 129.85,163.15 129.85,162.58 131.37,161.06 134.94,161.06 135.66,161.77 135.66,164.22 138.02,166.59 138.02,168.54 139.02,169.54 139.02,169.83 139.38,170.19 139.38,170.62
  BOTTOM w0.508: v2(138.82,174.62) v1(138.82,173.63) 138.82,172.87 138.43,172.48 138.43,172.11 139.38,171.16 139.38,170.62
+VREFC_B1: length 35
  BOTTOM w0.152: 134.97,165.57 131.37,165.57 UV10.M8
  BOTTOM w0.254: UV10.H1 127.77,171.59 127.86,171.68 v2(127.86,172.63) ; 134.97,165.57 136.34,165.57 137.6,166.82 137.6,168.98 136.71,169.87
  BOTTOM w0.508: 136.71,169.87 136.71,171.73 138.07,173.09 v1(138.07,175.44) 137.19,176.31 128.1,176.31 127.53,175.74 127.53,175.3 127.12,174.89 CV150.1 ; v2(127.86,172.63) 127.49,172.63 126.87,173.25 CV150.1 ; CV150.1 RV77.1 RV75.2
+VREFC_B2: length 34.4
  BOTTOM w0.178: UV11.M8 147.12,171.19 147.12,171.88
  BOTTOM w0.254: 147.12,171.88 146.37,172.63 144.84,172.63 144.56,172.91 143.3,172.91 143.13,172.74 142.59,172.74 139.64,169.79 139.64,168.56 139.64,168.55 139.64,168.53 139.76,168.41 139.76,167.59 139.36,167.19 v1(139.36,165.22) 140.08,164.51 140.08,163.59 141.78,161.88 RV80.2 144.98,162.43 145.32,162.77 146.96,162.77 147.29,162.44 RV83.1 148.14,162.72 149.82,162.72 CV173.1 150.67,163.03 149.65,164.04 149.65,164.91 UV11.H1
+VREFC_B3: length 31.3
  TOP w0.254: UV12.H1 149.9,171.57 v2(149.53,171.95) ; v2(146.31,165.57) 146.7,165.96 UV12.M8
  TOP w0.381: 149.58,173.81 149.53,173.77 v2(149.53,171.95)
  TOP w0.508: 149.58,173.81 149.59,173.83 CV172.1 148.68,174.87 RV82.1 148.67,174.86 RV78.2
  IN2 w0.508: v2(149.53,171.95) 149.53,172.74 148.31,173.96 145.46,173.96 144.3,172.8 v2(144.3,172.42)
  BOTTOM w0.152: v2(146.31,165.57) 146.3,165.56 146.3,164.72
  BOTTOM w0.254: v2(144.3,172.42) 144.26,172.46 143.52,172.46 143.18,172.12 142.59,172.12 v1(140.72,170.25) 140,169.53 140,168.7 140.11,168.59 140.11,167.05 140.44,166.72 140.67,166.72 141.35,166.05 141.35,164.21 141.87,163.68 145.27,163.68 146.3,164.72
+VREFG_GPU: length 14.9
  IN2 w0.508: v2(150.89,147.02) 150.53,146.66 148.41,146.66 147.82,146.06 142.52,146.06 v2(142.39,146.2)
  BOTTOM w0.254: UV1.AH13 142.85,146.67 v2(142.39,146.2)
  BOTTOM w0.508: v2(150.89,147.02) 150.89,146.86 v1(151.87,145.89) 152.85,144.91 CV23.1 154.24,144.91 RV14.1 155.18,144.9 RV13.1
+VSB: length 251.9
  TOP w0.102: v2(136.2,107.82) 136.13,107.74 RV41.2 ; v2(123.6,18.34) v3(123.6,45.23) 123.6,47.81 v2(128.25,52.46) ; 190.64,59.85 189.96,59.85 189.64,60.16 v2(189.64,64.78) ; v2(146.36,82.97) 146.45,82.88 146.45,77.68 146.87,77.26 147.95,77.26 148.6,76.62 152.12,76.62 154.16,74.57 154.16,70.55 153.56,69.95 v2(153.56,63.07) ; R647.1 v2(75.59,18.39)
  IN1 w0.102: v2(149.67,107.84) 149.64,107.82 v2(136.2,107.82)
  IN2 w0.102: v2(123.6,18.34) 123.6,18.33 75.65,18.33 v2(75.59,18.39) ; v2(189.64,64.78) 188.88,64.02 174.11,64.02 172.56,62.47 164.09,62.47 163.98,62.58 154.87,62.58 154.86,62.6 154.03,62.6 v2(153.56,63.07) 152.93,62.43 138.31,62.43 137.93,62.81 132.47,62.81 132.37,62.71 132.37,56.58 v2(128.25,52.46)
  BOTTOM w0.102: R646.1 133.09,2.57 132.13,1.61 129.23,1.61 128.06,2.78 128.06,13.88 v2(123.6,18.34) ; v2(149.67,107.84) 149.67,102.16 147.77,100.27 147.77,94.94 147.1,94.27 147.1,85.56 146.36,84.82 v2(146.36,82.97)
+VTT_REFP: length 3
  TOP w0.102: v1(33.23,10.74) 33.23,10.93 32.91,11.25 PC506.1
  TOP w0.203: PC506.1 32.35,11.24 PU501.4
A_BA0: length 53.7
  TOP w0.102: v2(109.05,148.44) 109.05,148.36 108.94,148.25 108.76,148.25 108.57,148.43 108.57,148.56 108.77,148.76 108.77,148.97 108.67,149.07 108.53,149.07 108.43,148.97 108.25,148.97 108.14,149.08 107.7,149.08 107.59,149.2 107.59,149.81 107.47,149.92 107.17,149.92 107.07,149.82 107.07,149.63 UV7.M2 ; UV5.M2 111.63,135.24 111.09,135.24 110.78,135.55 110,135.55 109.6,135.96 v2(109.45,135.96)
  IN1 w0.127: v2(109.05,148.44) 109.13,148.44 109.55,148.02 109.94,148.02 110.17,147.79 110.17,147.29 110.38,147.08 110.38,146.75 113.28,143.85 113.28,143.61 113.74,143.15 v2(113.74,142.96) 113.81,142.88 113.81,141.56 112.68,140.43 112.68,140 112.02,139.34 112.02,138.88 111.34,138.19 111.34,137.96 110.83,137.45 110.83,136.65 110.51,136.33 109.82,136.33 v2(109.45,135.96)
  IN2 w0.102: v2(126.97,143.04) 126.97,143.36 127.14,143.53 127.96,143.53 128.06,143.43 128.06,143.17 128.18,143.05 128.35,143.05 128.47,143.17 128.47,143.57 128.6,143.7 128.85,143.7 128.98,143.57 128.98,142.81 128.82,142.65 125.31,142.65 124.57,143.4 123.47,143.4 123.18,143.69 121.46,143.69 121.23,143.93 121.23,144.04 120.89,144.38 120.81,144.38
  IN2 w0.249: v2(113.74,142.96) 113.96,142.73 115.17,142.73 116.2,143.76 116.2,144.09 116.91,144.81 120.01,144.81 120.44,144.38 120.81,144.38
  BOTTOM w0.102: v2(109.45,135.96) 109,135.96 108.3,135.26 107.35,135.26 107.23,135.13 UV6.M2 ; UV8.M2 112.32,149.52 112.44,149.4 112.44,149.23 112.32,149.11 110.46,149.11 110.15,148.8 109.52,148.8 109.15,148.44 v2(109.05,148.44) ; v2(126.97,143.04) 127.25,143.33 UV1.J17
A_BA1: length 61.6
  TOP w0.102: UV5.N8 107.6,135.27 107.6,134.66 107.81,134.45 109.36,134.45 v2(109.45,134.36) ; v2(109.76,150) 109.76,149.7 109.89,149.57 110.08,149.57 110.21,149.7 110.21,149.72 110.38,149.9 111.39,149.9 111.56,149.72 111.56,149.27 111.72,149.12 112.16,149.12 112.29,148.99 112.29,148.83 112.18,148.72 UV7.N8
  IN1 w0.127: v2(109.45,134.36) 109.45,134.07 109.32,133.94 108.35,133.94 108.22,134.07 108.22,134.63 108.35,134.75 110.68,134.75 111.33,135.41 111.33,135.83 112.72,137.21 112.72,137.68 113.08,138.04 113.61,138.04 113.83,138.26 113.83,138.87 114.17,139.2 114.17,140.05 114.42,140.31 114.62,140.31 115.61,141.29 115.61,141.51 115.39,141.73 115.39,143.64 v2(115.61,143.86) 115.77,143.7 115.77,141.89 115.9,141.77 116.09,141.77 116.21,141.89 116.21,144.24 115.98,144.47 115.58,144.47 115.45,144.6 115.45,144.82 115.32,144.94 115.07,144.94 114.94,145.07 114.94,145.39 114.82,145.51 114.24,145.51 113.7,146.05 113.7,146.81 113.32,147.18 112.86,147.18 112.65,146.97 112.42,146.97 112,147.4 112,148.34 111.77,148.56 111.46,148.56 111.18,148.84 111.18,149.15 111.02,149.31 110.74,149.31 110.49,149.56 110.49,149.85 110.17,150.16 109.93,150.16 v2(109.76,150)
  IN2 w0.102: 120.81,144.83 120.88,144.83 121.11,145.07 121.33,145.07 121.43,144.97 121.43,144.83 121.32,144.71 121.32,144.58 121.44,144.45 122.18,144.45 122.31,144.58 122.31,144.65 122.37,144.71 123.02,144.71 123.25,144.49 123.25,143.98 123.59,143.63 124.62,143.63 124.81,143.44 125.06,143.44 125.25,143.63 125.41,143.63 125.81,143.23 125.81,143.04 125.94,142.92 126.23,142.92 126.36,143.04 v2(126.36,143.11)
  IN2 w0.249: v2(115.61,143.86) 115.61,144.15 116.13,144.67 116.13,145.14 116.26,145.26 120.19,145.26 120.63,144.83 120.81,144.83
  BOTTOM w0.102: UV1.H17 126.45,143.2 v2(126.36,143.11) ; UV6.N8 111.64,135.26 111.64,134.72 111.39,134.46 110.6,134.46 110.34,134.73 109.98,134.73 109.61,134.36 v2(109.45,134.36) ; v2(109.76,150) 109.58,150 109.2,149.62 108.5,149.62 108.24,149.88 107.74,149.88 107.56,149.7 107.56,149.37 107.18,148.99 UV8.N8
A_BA2: length 49.2
  TOP w0.102: v2(109.45,135.16) 109.45,134.9 109.59,134.76 110.5,134.76 110.58,134.84 110.58,135.03 110.65,135.1 110.79,135.1 111.04,134.85 UV5.M3 ; v2(109.05,149.24) 109.3,149.24 109.4,149.35 109.4,149.52 109.27,149.65 108.68,149.65 108.54,149.51 108.54,149.37 108.41,149.25 108.26,149.25 UV7.M3
  IN1 w0.102: 110.76,135.89 110.42,135.54 109.83,135.54 v2(109.45,135.16)
  IN1 w0.127: v2(109.05,149.24) 108.95,149.34 108.22,149.34 108.07,149.2 108.07,148.96 108.21,148.82 110.09,148.82 111.06,147.85 111.06,146.89 112.74,145.2 112.92,145.2 113.37,144.75 113.55,144.75 114.61,143.69 v2(114.61,143.41) 114.65,143.37 114.65,141.47 113.34,140.16 113.34,139.59 111.77,138.01 111.77,137.78 111.26,137.27 111.26,136.39 110.76,135.89
  IN2 w0.102: 120.81,145.28 121.67,145.28 122.04,144.92 123.68,144.92 124.09,144.51 124.09,143.96 124.21,143.84 125.97,143.84 126.09,143.96 126.09,144.2 125.97,144.32 v2(125.86,144.32)
  IN2 w0.249: 120.81,145.28 120.38,145.71 116.22,145.71 115.57,146.36 115.2,146.36 114.92,146.08 114.92,145.65 115.29,145.28 115.29,144.47 115.13,144.31 115.13,143.48 115,143.35 114.67,143.35 v2(114.61,143.41)
  BOTTOM w0.102: v2(109.05,149.24) 109.16,149.24 109.53,149.6 110.04,149.6 110.12,149.52 UV8.M3 ; UV6.M3 108.03,134.95 108.12,135.04 108.52,135.04 108.57,134.99 108.57,134.87 108.7,134.74 108.88,134.74 109.01,134.87 109.01,135.47 109.14,135.6 109.32,135.6 109.45,135.47 v2(109.45,135.16) ; v2(125.86,144.32) 126.41,144.87 UV1.H16
AC_PRESENT_R: length 15.9
  TOP w0.102: D1.2 141.65,87.47 R173.2 v2(141.65,86.15) ; v2(133.43,89.51) 133.67,89.74 133.67,91.45 U4.E6
  IN1 w0.089: v2(133.43,89.51) 133.43,89.57 135.15,91.28 136.38,91.28 136.56,91.46 136.76,91.46
  IN1 w0.127: 136.76,91.46 137.11,91.46 141.65,86.92 v2(141.65,86.15)
ACIN: length 190.4
  TOP w0.102: v2(142.86,89.89) 142.5,90.25 142.12,90.25 D1.1 ; DV1.1 153.04,126.59 v2(153.04,123.09) ; v2(167.86,85.82) 168.13,85.56 168.13,78.67 167.59,78.13 U31.110 167.59,72.74 C664.1 R522.1
  TOP w0.254: PU101.6 v3(188.45,120.9) 188.45,122.12 v2(187.22,123.35) ; v2(195.01,164.01) 195.36,164.01 195.86,164.51 PR314.2
  IN1 w0.127: v2(145.03,117.52) 148.33,117.52 149.07,118.26 160.78,118.26 161.2,118.68 161.2,121.9 ; 161.2,121.9 160.01,123.09 v2(153.04,123.09) ; 161.2,121.9 161.55,122.26 181.04,122.26 184.16,125.39 185.27,125.39 187.22,123.44 v2(187.22,123.35) ; v2(142.86,89.89) 145.37,87.38 157.05,87.38 157.96,88.29 165.4,88.29 v2(167.86,85.82)
  IN2 w0.254: v2(195.01,164.01) 192.41,164.01 192.21,163.81 192.21,151.52 194.96,148.77 194.96,136.84 194.72,136.6 194.72,133.32 188.36,126.95 188.36,124.49 v2(187.22,123.35)
  BOTTOM w0.102: v2(142.86,89.89) 142.95,89.8 143.5,89.8 144.39,90.69 144.39,92.12 143.8,92.72 143.8,96.05 144.3,96.56 144.3,116.8 v2(145.03,117.52)
ACN: length 13.6
  TOP w0.254: PR301.3 181.75,159.48 v2(182.07,159.8) ; v4(186.93,164) 187.11,164.18 PU301.1
  IN2 w0.254: v2(182.07,159.8) 182.21,159.66 183.82,159.66 187.35,163.18 187.35,163.58 v4(186.93,164)
  BOTTOM w0.102: v1(187.61,163.54) 187.79,163.72 PC308.1
  BOTTOM w0.254: v4(186.93,164) 186.92,164.01 PC311.2 187.73,164.83 PC308.1
ACOFF: length 105.1
  TOP w0.102: U31.27 175.57,86.96 175.23,86.61 174.65,86.61 v2(174.25,87.02) ; v3(177.68,154.51) 178.04,154.86 v2(178.37,154.86)
  IN2 w0.127: v2(171.04,110.58) 171.44,110.98 183.38,110.98 186.25,113.85 186.25,120.74 185.53,121.46 185.53,123.88 186.35,124.7 186.61,124.7 187.51,125.6 187.51,127.27 193.9,133.66 193.9,136.95 194.13,137.18 194.13,148.43 189.32,153.24 180.9,153.24 179.28,154.86 v2(178.37,154.86)
  BOTTOM w0.102: v2(171.04,110.58) 171.04,109.74 173.51,107.26 173.51,102.69 176.6,99.6 176.6,93.51 175.72,92.63 175.72,91.01 175.12,90.4 175.12,88.44 174.25,87.56 v2(174.25,87.02)
  BOTTOM w0.254: PR311.1 178.19,155.04 v2(178.37,154.86)
ACOFF-1: length 45.9
  TOP w0.254: v2(158.55,153.59) 158.55,159.15 160.88,161.48 v3(160.88,163.28) 160.19,163.97 160.19,172.89 PD302.2
  IN1 w0.254: v2(158.55,153.59) 158.68,153.46 177.54,153.46 v2(178.32,154.24)
  BOTTOM w0.254: PR311.2 177.21,156.11 PQ314.1 177.85,154.24 v2(178.32,154.24) 178.84,154.24 179.34,154.74 PQ305.2
ACP: length 14.8
  TOP w0.254: PR301.2 182.44,159.48 v2(182.05,159.09) ; v4(188.25,163.99) 187.84,163.99 187.61,164.22 PU301.2
  IN2 w0.254: v4(188.25,163.99) 187.73,163.46 187.73,163.03 183.98,159.28 182.23,159.28 v2(182.05,159.09)
  BOTTOM w0.254: v4(188.25,163.99) 188.55,163.69 v1(188.88,163.69) 189.49,163.69 189.58,163.78 PC307.2 189.58,164.89 PC308.2
ACPRN: length 10.5
  TOP w0.254: PU301.5 189.11,164.13 189.47,163.78 v3(190.2,163.78) 190.56,163.78 190.91,164.13 v4(190.91,165.19) ; v2(195.16,167.24) 195.38,167.45 PQ308.2
  BOTTOM w0.254: v2(195.16,167.24) 194.94,167.01 PR307.2 194.39,165.69 191.68,165.69 191.17,165.19 v4(190.91,165.19)
ADP_65: length 20.3
  TOP w0.102: U31.21 175.4,84.56 175.14,84.82 174.28,84.82 174.09,84.63 174.09,84.01 174.56,83.54 174.56,82.43 174.17,82.04 174.17,80.76 174.5,80.43 v2(174.87,80.43)
  TOP w0.254: v2(184.03,79.64) 185.08,78.59 PQ206.2
  IN2 w0.127: v2(184.03,79.64) 182.38,81.29 179.79,81.29 179.64,81.44 176.39,81.44 175.38,80.43 v2(174.87,80.43)
  BOTTOM w0.102: v2(184.03,79.64) v1(184.03,80.31)
ADP_90: length 41.8
  TOP w0.102: U31.68 161.96,87.76 162.25,87.46 163.94,87.46 165.67,85.73 166.88,85.73 167.44,85.17 167.44,80.55 166.52,79.63 166.52,77.44 v2(166.44,77.37) ; v1(188.15,80.01) 188.46,79.69 PQ208.2
  TOP w0.254: v2(188.04,77.61) 188.46,78.02 PQ208.2
  IN2 w0.127: v2(188.04,77.61) 186.74,76.3 176.17,76.3 175.55,76.92 172.22,76.92 171.86,77.28 170.11,77.28 169.41,77.98 168.48,77.98 168.13,77.62 166.69,77.62 v2(166.44,77.37)
ADP_135: length 35.6
  TOP w0.102: v2(165.18,77.68) 165.18,78.1 163.18,80.1 162.49,80.1 161.63,80.96 U31.85
  TOP w0.254: PQ207.2 191.45,79.44 191.02,79.88 v1(190.63,79.88) 190.24,79.88 v2(189.85,79.49)
  IN2 w0.127: v2(165.18,77.68) 165.89,77.68 166.09,77.87 168.02,77.87 168.38,78.23 169.51,78.23 170.21,77.53 172.38,77.53 172.83,77.98 176.73,77.98 177.53,77.18 181.19,77.18 182.18,78.16 184.94,78.16 186.27,79.49 v2(189.85,79.49)
ADP_I: length 152.4
  TOP w0.102: v2(170.01,79.37) 168.76,80.62 168.76,86.01 167.19,87.59 166.44,87.59 165.91,88.12 162.48,88.12 161.64,88.96 U31.65 159.78,88.96 159.47,89.27 v3(159.47,89.9)
  TOP w0.254: v4(190.73,166.29) 190.68,166.24 189.85,166.24 PU301.7 ; v2(185.26,80.58) 184.88,80.2 PR227.2
  IN2 w0.127: v4(190.73,166.29) 191.64,165.39 191.64,151.28 194.39,148.54 194.39,137.07 194.15,136.84 194.15,133.55 187.76,127.16 187.76,124.88 186.5,123.62 186.5,113.74 183.42,110.67 172.17,110.67 v2(171.44,109.94) ; v2(170.01,79.37) 170.64,78.74 176.16,78.74 176.59,79.17 180.49,79.17 180.74,78.92 184.48,78.92 185.26,79.7 v2(185.26,80.58)
  BOTTOM w0.102: v2(170.01,79.37) 169.5,79.88 169.5,87.33 169.1,87.74 169.1,91.81 169.32,92.04 169.32,94.9 169.15,95.08 169.15,96.36 167.67,97.84 167.67,98.97 165.98,100.66 165.98,108.06 165.78,108.26 165.78,110.11 167.28,111.6 170.95,111.6 171.44,111.11 v2(171.44,109.94)
  BOTTOM w0.254: PC304.2 190.55,166.29 v4(190.73,166.29)
ADP_ID: length 132.8
  TOP w0.102: JDCIN1.5 v3(196.3,161.55) ; U31.66 161.64,88.56 162.3,87.89 164.29,87.89 v2(164.54,87.65)
  TOP w0.254: 196.51,79.28 196.88,79.28 198.05,80.45 198.05,85.1 197.33,85.82 v2(189.8,85.82)
  IN1 w0.254: JDCIN1.5 193.36,161.55 194.88,160.03 194.88,151.31 194.2,150.63 194.2,139.41 193.8,139 193.8,136.59 191.96,134.74 191.96,131.09 190.28,129.41 190.28,121.84 191.09,121.03 191.09,117.26 186.39,112.56 186.39,88.72 186.79,88.33 188.69,88.33 189.8,87.22 v2(189.8,85.82)
  IN2 w0.127: v2(189.8,85.82) 187.36,85.82 185.94,87.25 183.68,87.25 182.04,85.61 178.39,85.61 177.92,86.08 175.57,86.08 175.32,86.33 171.38,86.33 170.11,87.6 164.59,87.6 v2(164.54,87.65)
ADP_ID_CLOSE: length 22.6
  TOP w0.102: 194.93,80.31 195.31,80.69 195.31,81.01 193.28,83.04 182.4,83.04 v1(181.48,83.96) 179.69,85.76 178.2,85.76 178.01,85.95 177.53,85.95 177.32,86.16 U31.25
  TOP w0.254: PQ102.5 194.93,80.31
ADP_OCP_1: length 5.7
  TOP w0.102: v1(178.86,61.9) 179.15,61.6 PR215.1
  TOP w0.254: PQ201.2 179.39,58.2 179.15,58.44 PR215.1 180,60.59 PR216.2
APDIN: length 9.1
  TOP w0.102: v3(193.71,151.37) 193.33,151.75 JDCIN1.1 193.93,154.15 v3(196.44,154.15) ; JDCIN1.2 195.35,155.55 v3(196.35,156.55)
APDIN1:
  vias: v3(190.05,147.32) v4(190.13,151.13) v4(190.11,150.46) v4(190.75,150.39) v4(190.77,149.64) v4(190.8,148.89) v4(190.84,148.19) v4(190.85,147.51) v4(190.85,146.84) v4(191.54,147.48) v4(191.53,146.83) v4(191.55,148.19) v4(192.21,148.19) v4(192.2,147.48) v4(192.23,146.8)
APPLE_MIC: length 2.8
  TOP w0.254: RA16.1 153.27,46.97 153.57,47.27 UA1.30
B+: length 36
  TOP w0.508: 191.97,61.77 v2(195.27,61.77) ; PR402.1 v2(110.06,2.18)
  TOP w1.524: 92.72,3.36 93.82,4.46 93.82,8.54 111.4,26.12 111.4,27.22
  vias: v2(95.91,152.45) v2(96.22,152.95) v2(96.54,152.47) v2(197.86,43.94) v2(197.86,43.32) v2(198.47,43.94) v2(198.47,43.32) v2(199.09,43.93) v2(199.09,43.3) v2(200.01,79.32) v2(200.01,78.73) v2(200,78.13) v2(200.64,79.32) v2(200.64,78.73) v2(200.62,78.13) v3(157.42,177.28) v4(59.45,2.63) v4(59.45,1.97) v4(60.12,2.62) v4(60.13,1.93) v4(76.86,137.79) v4(77.31,138.26) v4(77.29,137.32) v4(77.74,137.79) v4(77.74,136.86) v4(78.19,137.33) v4(78.22,136.4) v4(78.67,136.87) v4(92.21,2.28) v4(92.21,1.63) v4(92.92,2.27) v4(92.92,1.62) v4(109.04,176.86) v4(109.01,176.17) v4(109.06,177.5) v4(165.84,175.81) v4(165.84,175.12) v4(165.9,177.15) v4(165.86,176.51) v4(166.54,175.82) v4(166.55,175.12) v4(166.61,177.15) v4(166.56,176.51) v4(176.61,135.83) v4(176.61,135.18) v4(176.64,134.45) v4(176.64,133.8) v4(177.04,159.68) v4(177.06,160.33) v4(177.07,159.03) v4(177.07,158.35) v4(177.06,157.7) v4(177.08,157.04) v4(177.28,135.82) v4(177.27,135.18) v4(177.3,134.44) v4(177.3,133.8) v4(177.7,160.36) v4(177.69,159.71) v4(177.71,159.05) v4(177.71,158.37) v4(177.7,157.73) v4(177.73,157.07) v4(190.43,7.92) v4(190.47,8.58) v4(191.12,7.91) v4(191.17,8.57)
B+_0.95V:
  vias: v1(177.19,127.31)
B+_1.5V:
  vias: v1(194.11,8.94)
B_BA0: length 52.8
  TOP w0.102: UV9.M2 131.35,166.35 131.35,166.9 132.06,167.61 v2(132.06,167.83) ; v2(145.62,168.9) 145.62,169.13 146.3,169.81 146.3,170.36 UV12.M2
  IN1 w0.127: v2(132.06,167.83) 132.06,168.09 131.99,168.16 131.75,168.16 131.66,168.07 131.66,167.53 131.96,167.23 132.7,167.23 133.18,166.76 134.29,166.76 135.62,165.43 136.91,165.43 v2(137.93,164.41) 138.14,164.41 138.75,165.02 141.12,165.02 142.93,166.83 143.53,166.83 144.48,167.78 144.97,167.78 145.2,168.01 145.2,168.4 145.62,168.82 v2(145.62,168.9)
  IN2 w0.102: 138.03,157.31 138.03,157.25 137.8,157.02 137.8,156.84 137.88,156.77 138.45,156.77 138.53,156.69 138.53,156.45 138.44,156.36 137.92,156.36 137.82,156.26 137.82,156.05 137.92,155.95 138.44,155.95 138.53,155.86 138.53,155.64 138.44,155.55 137.92,155.55 137.82,155.45 137.82,155.24 137.92,155.14 138.26,155.14 138.36,155.04 138.36,154.84 138.26,154.73 137.92,154.73 137.82,154.63 137.82,154.42 137.93,154.3 138.12,154.3 138.19,154.23 138.19,154.15 137.82,153.78 137.65,153.78 137.56,153.87 137.56,154.11 137.46,154.21 137.23,154.21 137.14,154.12 137.14,153.44 137.28,153.3 137.28,151.53 137.15,151.4 v2(136.9,151.4)
  IN2 w0.249: v2(137.93,164.41) 137.69,164.41 137.55,164.27 137.55,163.75 137.75,163.55 138.09,163.55 138.23,163.41 138.23,162.8 138.08,162.65 137.78,162.65 137.57,162.44 137.57,162.03 138.03,161.58 138.03,160.94 138.17,160.81 138.55,160.81 138.72,160.64 138.72,160 138.53,159.81 138.21,159.81 138.03,159.64 138.03,158.97 138.19,158.82 138.54,158.82 138.72,158.65 138.72,157.99 138.55,157.82 138.19,157.82 138.03,157.67 138.03,157.31
  BOTTOM w0.102: UV1.Y8 136.58,151.4 v2(136.9,151.4) ; UV10.M2 131.38,170.36 131.38,169.69 131.69,169.39 131.69,168.3 132.06,167.94 v2(132.06,167.83) ; UV11.M2 146.29,166.39 146.29,167.5 145.99,167.8 145.99,168.43 145.62,168.8 v2(145.62,168.9)
B_BA1: length 59.8
  TOP w0.102: UV12.N8 145.9,165.64 145.79,165.53 145.6,165.53 145.5,165.63 145.5,166.32 145.57,166.39 147.08,166.39 147.18,166.49 147.18,167.11 147.09,167.21 146.72,167.21 146.63,167.29 146.63,167.54 146.73,167.64 147.08,167.64 147.18,167.74 v2(147.18,168.19) ; v2(138.05,150.77) 138.5,151.22 138.5,152.63 v1(138.81,152.94) 139.17,153.3 139.17,154.12 139.72,154.67 139.72,157.31 ; v2(130.48,168.55) 130.57,168.63 130.57,170.18 130.74,170.36 131.36,170.36 UV9.N8
  TOP w0.203: 139.72,157.31 139.72,157.4 141.38,159.06 141.38,164.51 141.33,164.56 141.33,165.49 141.19,165.63 140.7,165.63 140.53,165.47 140.53,164.28 v2(140.56,164.26)
  IN1 w0.127: v2(147.18,168.19) 147.18,167.96 146.32,167.1 145.5,167.1 144.39,165.99 143.24,165.99 142.42,165.17 142.42,164.71 142.25,164.53 142.25,164.49 142.06,164.31 142.06,164.07 142.01,164.02 141.65,164.02 141.57,164.09 141.57,164.28 141.5,164.36 141.16,164.36 141.08,164.28 141.08,164.18 141.02,164.12 140.7,164.12 v2(140.56,164.26) 140.46,164.16 138.85,164.16 138.35,163.66 137.62,163.66 136.51,164.77 135.35,164.77 134.45,165.66 132.88,165.66 130.88,167.67 130.88,168.15 v2(130.48,168.55)
  BOTTOM w0.102: v2(147.18,168.19) 147.18,168.37 146.8,168.75 146.8,169.05 146.54,169.31 146.54,169.48 146.63,169.57 147,169.57 147.13,169.7 147.13,170.24 147,170.37 145.59,170.37 145.49,170.47 145.49,171.1 145.59,171.21 145.8,171.21 145.9,171.1 UV11.N8 ; UV10.N8 131.37,166.37 130.69,166.37 130.51,166.55 130.51,167.05 130.85,167.39 130.85,168.01 130.48,168.38 v2(130.48,168.55) ; v2(138.05,150.77) 137.55,150.27 UV1.AA9
