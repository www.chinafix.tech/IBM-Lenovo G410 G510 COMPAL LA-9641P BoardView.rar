# Allegro board IBM-Lenovo G410 G510 COMPAL LA-9641P BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EC_SCI#: length 49
  TOP w0.102: U4.G15 132.78,88.33 v2(132.99,88.55) ; v2(174.72,84.39) 174.95,84.16 U31.20
  IN1 w0.089: v2(132.99,88.55) 133.38,88.17 133.73,88.17 134.15,88.58 136.76,88.58
  IN1 w0.127: 136.76,88.58 137.8,88.58 138.23,88.16 138.84,88.16 142.32,84.67 v2(143.61,84.67) 143.8,84.86 158.71,84.86 160.4,86.55 166.4,86.55 168.09,84.86 174.25,84.86 v2(174.72,84.39)
  BOTTOM w0.102: v2(143.61,84.67) 143.78,84.85 R261.2 ; v2(174.72,84.39) 175.16,84.39 v1(175.27,84.27)
EC_SMB_CK1: length 135.7
  TOP w0.102: v2(162.69,84.28) 162.69,84.27 162.52,84.1 161.86,84.1 161.8,84.16 U31.77 ; v2(185.1,172.82) 184.96,172.96 184.3,172.96 PR204.2 ; PU301.9 190.5,167.23 190.62,167.12 191.88,167.12 v2(192.06,167.29)
  IN2 w0.127: v2(160.97,109.12) 160.81,109.27 160.81,109.48 161.04,109.71 163,109.71 163.6,109.12 183.53,109.12 190.76,116.34 190.76,117.55 191.46,118.24 191.46,129.03 195.45,133.02 195.45,136.3 195.68,136.54 195.68,152.72 195.98,153.02 195.98,164.67 195.26,165.39 194.32,165.39 192.55,167.17 192.19,167.17 v2(192.06,167.29)
  BOTTOM w0.102: R600.2 163.08,84.12 162.85,84.12 v2(162.69,84.28) 162.5,84.08 161.86,84.08 161.07,84.87 161.07,92.16 160.08,93.15 160.08,98.12 160.64,98.68 160.64,107.06 160.81,107.23 160.81,108.95 v2(160.97,109.12) ; v2(185.1,172.82) 185.3,173.01 185.53,173.01 186.51,173.99 188.37,173.99 188.95,173.4 188.95,172.85 192.56,169.23 192.56,167.22 192.46,167.12 192.24,167.12 v2(192.06,167.29)
EC_SMB_CK2: length 166
  TOP w0.102: v2(159.13,83.51) 159.13,83.51 159.3,83.33 159.7,83.33 159.72,83.36 U31.79 ; RP17.8 148.84,95.98 148.7,95.84 148.7,95.36 148.41,95.07 146.79,95.07 v2(146.58,94.86) 146.4,95.03 145.86,95.03 144.7,93.88 143.45,93.88 143.33,94 Q130.1 ; U9.8 144.08,71.52 143.87,71.73 143.56,71.73 143.17,72.11 143.17,74.13 143.88,74.84 144.03,74.84 145.34,76.15 145.34,82.79 v2(145.15,82.98) ; UT2.9 84,126.96 v2(83.9,126.87) ; QV3.6 149.44,126.34 148.76,125.66 v2(148.76,124.7)
  IN2 w0.102: 105.46,124.9 105.85,124.9 105.88,124.87
  IN2 w0.127: 105.46,124.9 104.46,124.9 103.83,125.52 83.63,125.52 83.25,125.91 83.25,127.2 83.37,127.32 83.87,127.32 84.01,127.18 84.01,126.97 v2(83.9,126.87) ; 105.88,124.87 109.75,121 136.59,121 137.61,122.02 140.8,122.02 141.34,121.47 146.34,121.47 148.76,123.9 v2(148.76,124.7) ; v2(159.13,83.51) 159.01,83.4 147.11,83.4 146.75,83.75 145.64,83.75 145.28,83.4 145.28,83.11 v2(145.15,82.98)
  BOTTOM w0.102: v2(148.76,124.7) 149,124.94 151.96,124.94 152.31,124.59 152.31,116.79 151.51,115.99 151.51,110.38 149.17,108.04 149.17,102.28 147.33,100.44 147.33,95.33 147.04,95.03 146.76,95.03 v2(146.58,94.86) 146.42,95.02 146.28,95.02 146.04,94.78 146.04,91.05 146.84,90.25 146.84,86.59 144.53,84.27 144.53,82.81 144.77,82.57 145.19,82.57 145.33,82.71 145.33,82.8 v2(145.15,82.98)
EC_SMB_DA1: length 136.4
  TOP w0.102: PR201.2 184.46,173.19 184.89,173.19 v2(185.1,173.4) ; v2(162.69,83.69) 162.51,83.87 161.92,83.87 161.8,83.76 U31.78 ; v2(192.06,166.71) 191.88,166.89 190.66,166.89 190.5,166.73 PU301.8
  IN2 w0.127: v2(192.06,166.71) 192.19,166.84 192.41,166.84 194.19,165.06 195.12,165.06 195.65,164.53 195.65,153.15 195.35,152.85 195.35,136.67 195.12,136.44 195.12,133.15 191.13,129.16 191.13,118.38 190.43,117.68 190.43,116.48 183.4,109.45 163.73,109.45 163.14,110.04 160.91,110.04 160.48,109.62 160.48,109.21 v2(160.39,109.12)
  BOTTOM w0.102: v2(160.39,109.12) 160.58,108.93 160.58,107.32 160.41,107.15 160.41,98.78 159.85,98.22 159.85,93.05 160.84,92.06 160.84,84.78 161.76,83.86 162.53,83.86 v2(162.69,83.69) 162.9,83.89 163.1,83.89 R604.2 ; v2(185.1,173.4) 185.27,173.24 185.44,173.24 186.41,174.22 188.46,174.22 189.18,173.5 189.18,172.94 192.79,169.33 192.79,167.13 192.55,166.89 192.24,166.89 v2(192.06,166.71)
EC_SMB_DA2: length 165.1
  TOP w0.102: RP17.7 148.34,95.98 148.47,95.84 148.47,95.46 148.31,95.3 146.72,95.3 v2(146.58,95.44) 146.4,95.26 145.75,95.26 145.54,95.47 145.54,96.06 145.13,96.48 145.13,97.27 145.01,97.39 144.72,97.39 144.63,97.31 Q130.4 ; v2(151.37,124.51) 150.86,124.51 150.74,124.63 QV3.3 ; v2(145.73,82.98) 145.57,82.81 145.57,76.05 144.13,74.61 143.97,74.61 143.4,74.04 143.4,72.21 143.65,71.96 143.87,71.96 144.08,72.17 U9.7 ; v2(84.51,126.82) 84.5,126.83 UT2.10 ; v2(159.13,82.93) 159.3,83.11 159.57,83.11 159.72,82.96 U31.80
  IN2 w0.127: v2(145.73,82.98) 145.61,83.11 145.61,83.26 145.77,83.42 146.62,83.42 146.97,83.07 158.99,83.07 v2(159.13,82.93) ; v2(84.51,126.82) 84.34,126.99 84.34,127.31 84.01,127.65 83.24,127.65 82.92,127.33 82.92,125.77 83.5,125.19 103.7,125.19 104.32,124.57 105.71,124.57 109.62,120.67 136.73,120.67 137.75,121.69 140.66,121.69 141.21,121.14 146.48,121.14 149.09,123.76 149.09,124.2 149.4,124.51 v2(151.37,124.51)
  BOTTOM w0.102: v2(145.73,82.98) 145.56,82.8 145.56,82.62 145.28,82.34 144.67,82.34 144.3,82.71 144.3,84.37 146.62,86.68 146.62,90.16 145.82,90.96 145.82,94.88 146.18,95.25 146.39,95.25 v2(146.58,95.44) 146.76,95.26 146.94,95.26 147.1,95.42 147.1,100.53 148.94,102.37 148.94,108.14 151.28,110.48 151.28,116.09 152.08,116.89 152.08,124.5 151.91,124.66 151.52,124.66 v2(151.37,124.51)
EC_SMCA: length 30.6
  TOP w0.102: PR204.1 182.71,173.05 182.28,173.05 181.86,173.47 v4(181.86,174.15) 181.86,175.2 JBATT2.3
  IN2 w0.127: JBATT2.3 181.84,175.22 181.84,175.05 181.72,174.94 180.24,174.94 179.45,175.73 179.45,179.95 182.13,182.63 193.94,182.63 194.37,182.21 194.37,181.93 JBATT1.3
EC_SMDA: length 32.3
  TOP w0.102: JBATT2.4 182.09,175.15 182.09,173.56 182.37,173.28 182.7,173.28 PR201.1
  IN2 w0.127: JBATT2.4 182.17,175.23 182.17,174.92 181.86,174.61 180.11,174.61 179.12,175.6 179.12,180.09 181.99,182.96 194.08,182.96 194.7,182.34 194.7,181.86 JBATT1.4
EC_SMI#: length 72.6
  TOP w0.089: v2(127.65,95.9) 127.3,95.55 127.3,94.21 U4.Y1
  TOP w0.102: v2(170.4,80.86) 168.99,82.27 168.99,86.11 166.75,88.35 162.69,88.35 155.87,95.17 155.21,95.17 153.47,96.91 151.79,96.91 148.37,100.33 144.82,100.33 142.39,102.76 140.64,102.76 v1(140.62,102.78) 140.58,102.82 128.38,102.82 v2(128.3,102.89) ; U31.15 175.08,82.16 174.58,81.66 v2(174.58,80.97)
  IN1 w0.127: v2(127.65,95.9) 127.65,96.14 128.3,96.79 v2(128.3,102.89)
  IN2 w0.127: v2(170.4,80.86) 174.47,80.86 v2(174.58,80.97)
  BOTTOM w0.102: R247.2 128.63,100.73 128.63,101.78 128.3,102.1 v2(128.3,102.89)
EC_SPI_CLK: length 134.1
  TOP w0.102: U31.126 173.99,73.72 174.58,73.12 v2(174.89,73.12)
  IN2 w0.127: v2(169.55,109.98) 169.55,110 166.17,113.38 137.52,113.38 136.84,112.7 129.89,112.7 129.37,112.18 126.75,112.18 124.39,109.81 124.11,109.81 122.41,108.11 111.1,108.11 109.84,106.86 109.84,99.97 109.6,99.73 109.6,98.71 109.88,98.43 v2(111.64,98.43)
  BOTTOM w0.102: v2(111.64,98.43) 111.39,98.43 111.26,98.31 111.26,98.01 111.39,97.89 112.26,97.89 112.39,97.76 112.39,97.56 112.26,97.43 111.37,97.43 111.25,97.3 111.25,97.1 111.37,96.97 112.36,96.97 112.49,96.85 112.49,96.27 112.39,96.16 112.14,96.16 112.02,96.05 112.02,95.88 112.14,95.76 112.4,95.76 112.52,95.64 112.52,95.47 112.4,95.35 111.95,95.35 111.83,95.23 111.83,95.06 111.95,94.95 112.39,94.95 112.49,94.84 112.49,94.64 112.39,94.54 111.78,94.54 111.66,94.42 111.66,94.25 111.78,94.13 112.39,94.13 112.49,94.03 112.49,93.82 112.39,93.72 111.8,93.72 111.68,93.6 111.68,93.44 111.8,93.32 112.39,93.32 112.52,93.19 112.52,92.92 112.39,92.8 112.24,92.8 112.11,92.67 112.11,92.44 112.24,92.31 112.5,92.31 112.63,92.19 112.63,91.69 112.5,91.56 RP2.6 ; v2(174.89,73.12) 175.61,73.85 175.61,78.19 173.81,80 173.81,81.28 173.01,82.08 173.01,84.59 173.18,84.77 173.18,89.79 175.03,91.63 175.03,95.22 v1(174.31,95.94) 174.31,97.73 170.62,101.42 170.62,106.35 169.55,107.41 v2(169.55,109.98)
EC_SPI_CS#: length 120.4
  TOP w0.102: v2(174.89,73.71) 174.79,73.81 U31.128 ; v2(111.77,92.89) 111.77,94.76 111.65,94.88 111.21,94.88 110.81,95.27 110.81,97.3 v1(110.45,97.67) v2(110.45,99.04)
  IN2 w0.127: v2(168.93,109.98) 166.69,112.21 165.39,112.21 164.65,112.95 137.91,112.95 137.19,112.23 130.04,112.23 129.56,111.74 126.93,111.74 124.57,109.38 124.29,109.38 122.59,107.68 111.46,107.68 110.27,106.49 110.27,99.22 v2(110.45,99.04)
  BOTTOM w0.102: RP2.5 111.46,92.06 111.41,92.11 111.41,92.53 v2(111.77,92.89) ; v2(174.89,73.71) 175.2,74.03 175.2,78.03 173.4,79.83 173.4,81.11 172.46,82.05 172.46,84.68 172.75,84.97 172.75,90.04 174.56,91.84 174.56,94.42 173.26,95.72 173.26,98.09 170.19,101.17 170.19,106.13 168.93,107.39 v2(168.93,109.98)
EC_SPI_SI: length 142.1
  TOP w0.102: U31.120 171.59,73.42 171.69,73.32 171.69,72.32 v2(171.65,72.29)
  IN2 w0.127: v2(169.58,110.69) 166.42,113.85 137.09,113.85 136.58,113.34 129.93,113.34 129.19,112.61 126.29,112.61 123.11,109.43 111.22,109.43 108.66,106.87 108.66,102.09 109.25,101.5 109.25,100.29 108.83,99.87 108.83,98.17 109.57,97.43 111.26,97.43 v2(112.28,98.45)
  BOTTOM w0.102: v2(169.58,110.69) 168.97,110.69 168.51,110.23 168.51,107.31 169.87,105.95 169.87,100.9 172.92,97.85 172.92,93.33 173.76,92.49 173.76,91.8 172.45,90.49 172.45,85.18 171.62,84.35 171.62,82.41 173.04,80.99 173.04,79.74 174.82,77.96 174.82,75.14 173.46,73.78 v3(173.15,73.78) v2(171.65,72.29) ; v2(112.28,98.45) 112.92,97.8 112.92,92.99 113.39,92.52 113.55,92.52 114.03,92.03 114.03,88.4 113.72,88.09 113.02,88.09 112.44,88.67 112.44,90.03 112.52,90.1 112.52,90.89 112.34,91.06 RP2.7
EC_SPI_SO: length 135.5
  TOP w0.102: v2(110.29,85.84) 110.46,86 110.46,87.03 110.29,87.2 110.29,92.42 109.86,92.85 109.86,94.93 v2(110.36,95.43) ; U31.119 171.19,73.04 v2(171.28,72.95)
  IN2 w0.127: v2(168.09,109.98) 168.09,110.25 166.38,111.96 165.29,111.96 164.55,112.7 138.02,112.7 137.29,111.97 132.77,111.97 132.01,111.21 130.06,111.21 129.44,110.6 126.14,110.6 124.67,109.13 124.39,109.13 122.69,107.43 111.76,107.43 110.92,106.59 110.92,105.64 111.27,105.28 111.27,101.33 112.72,99.88 112.72,97.97 110.36,95.6 v2(110.36,95.43)
  BOTTOM w0.102: v2(171.28,72.95) 172.7,74.37 173.55,74.37 174.44,75.25 174.44,77.85 172.64,79.65 172.64,80.89 171.15,82.38 171.15,84.35 172.03,85.23 172.03,87 171.33,87.7 171.33,89.84 v1(172.7,91.21) 173.39,91.89 173.39,92.22 172.56,93.05 172.56,97.72 169.53,100.75 169.53,105.65 168.09,107.08 v2(168.09,109.98) ; RP2.8 111.44,90.56 111.31,90.43 111.31,86.85 v2(110.29,85.84)
EC_TACH: length 167.6
  TOP w0.102: v2(175.1,87.06) 175.4,87.36 U31.28 177.83,87.36 v1(177.93,87.46) 178.4,87.46 R605.2
  IN1 w0.127: v2(98.09,160.89) 97.87,160.67 97.87,146.78 98.6,146.04 98.6,123.34 97.82,122.56 97.82,114.69 98.63,113.88 100.14,113.88 102.35,116.09 111.65,116.09 112.36,115.39 121.95,115.39 123.2,114.15 129.23,114.15 130.69,115.61 141.01,115.61 141.22,115.4 151.08,115.4 151.75,114.73 162.42,114.73 166.78,119.09 171.52,119.09 173.15,117.46 v2(173.46,117.46)
  BOTTOM w0.102: JFAN1.2 97.26,159.88 97.58,159.88 98.09,160.39 v2(98.09,160.89) ; v2(173.46,117.46) 173.46,116.89 177.29,113.06 177.29,93.22 176.42,92.36 176.42,88.36 175.12,87.06 v2(175.1,87.06)
EC_TS_ON#: length 123.9
  TOP w0.102: U31.97 162.39,73.97 162.12,73.71 v1(159.77,73.71) v2(159.25,73.71) ; v2(201.16,148.05) 201.1,147.99 R722.1 R5581.1
  IN2 w0.127: v2(159.09,104.16) 162.97,104.16 164.72,102.41 192.31,102.41 193.39,103.49 193.39,109.79 201.32,117.72 201.32,136.23 204.32,139.24 204.32,141.02 201.91,143.43 201.91,143.78 201.16,144.53 v2(201.16,148.05)
  BOTTOM w0.102: v2(159.25,73.71) 159.48,73.93 159.48,79.13 158.52,80.1 158.52,81.74 157.86,82.4 157.86,84.04 158.59,84.77 158.59,85.6 158.16,86.03 158.16,94.99 158.71,95.54 158.71,103.78 v2(159.09,104.16)
EC_TX: length 167.1
  TOP w0.102: R505.1 v2(197.75,162.68) ; JP3.2 v2(183.85,33.3) ; U31.30 175.49,88.16 175.13,88.51 175.13,89.35 175.43,89.65 175.94,89.65 176.83,90.54 v2(176.83,91.62)
  IN2 w0.127: v2(197.75,162.68) 197.92,162.84 199.34,162.84 204.5,157.68 204.5,147.38 206.18,145.7 206.18,143.15 204.64,141.61 204.64,139.2 201.57,136.13 201.57,117.61 193.65,109.69 193.65,103.39 192.41,102.16 177.96,102.16 v2(177.76,101.95)
  BOTTOM w0.102: v2(183.85,33.3) 183.7,33.3 183.13,33.87 183.13,43.12 178.15,48.1 178.15,53.37 176.46,55.06 176.46,68.72 176.8,69.06 176.8,83.72 176.46,84.06 176.46,87.62 176.75,87.92 176.75,91.54 v2(176.83,91.62) 176.83,92.32 177.76,93.25 v1(177.76,99.93) v2(177.76,101.95)
EC_VGA_EN: length 58.4
  TOP w0.102: v2(177.79,84.34) 177.79,83.95 177.19,83.36 U31.18
  IN2 w0.254: v2(187.3,130.52) 187.3,129.41 186.7,128.8 186.7,128.52 183.51,125.34 183.51,117.28 181.88,115.66 179.6,115.66 v2(179.43,115.82)
  BOTTOM w0.102: v2(177.79,84.34) 177.25,84.88 177.25,86.88 178.11,87.75 178.11,88.16 177.34,88.93 177.34,90.37 177.49,90.52 177.49,91.64 179.91,94.06 v1(179.91,97.6) 179.91,110.66 179.08,111.49 179.08,115.47 v2(179.43,115.82)
  BOTTOM w0.254: v2(187.3,130.52) 187.3,131.38 PR820.1
ECAGND: length 90.5
  TOP w0.254: U31.69 159.28,87.36 v2(159.08,87.56)
  TOP w0.508: v2(183.76,61.05) 183.57,61.24 PR228.2 ; PR225.1 187.47,79.75 187.47,78.73 PQ208.3 186.97,78.42 v2(186.46,78.92) ; PQ206.3 v2(183.78,77.5) ; v2(189.92,77.24) 190.15,77.47 PQ207.3
  IN1 w0.508: v2(183.78,77.5) 184.26,77.02 184.26,76.11 183.31,75.16 183.31,73.99 179.67,70.35 179.67,65.24 183.76,61.15 v2(183.76,61.05)
  IN2 w0.508: v2(159.55,60.4) 159.54,60.41 167.53,60.41 168.81,59.14 182.67,59.14 183.76,60.22 v2(183.76,61.05) ; v2(183.78,77.5) 185.03,77.5 v2(186.46,78.92) 188.24,78.92 v2(189.92,77.24)
  BOTTOM w0.508: v2(159.55,60.4) 159.53,60.42 159.53,70.22 160.14,70.83 160.14,81.05 158.52,82.68 158.52,83.76 159.84,85.09 v1(159.84,86.03) 159.84,86.8 v2(159.08,87.56)
EDID_CLK: length 21.6
  TOP w0.102: JLVDS1.20 94.94,144.73 95.23,144.73 95.3,144.66 v2(95.3,144.41) ; UT2.29 85.5,133.28 85.67,133.44 85.67,133.72 85.76,133.81 85.76,134.15 v2(85.59,134.33)
  IN2 w0.127: v2(85.59,134.33) 85.69,134.44 85.69,135.69 86.9,136.9 87.98,136.9 91.6,140.52 93.7,140.52 95.74,142.56 95.74,143.09 95.47,143.36 95.47,144.24 v2(95.3,144.41)
  BOTTOM w0.102: RT10.1 86.41,133.06 86.41,133.27 85.83,133.84 85.83,134.08 v2(85.59,134.33)
EDID_DATA: length 21.9
  TOP w0.102: JLVDS1.19 95.26,145.12 95.26,145.03 95.3,144.99 95.47,144.82 v2(95.72,144.82) ; UT2.28 86,133.28 85.9,133.38 85.9,133.62 85.99,133.72 85.99,134.15 v2(86.17,134.33)
  IN2 w0.127: v2(95.72,144.82) 95.8,144.74 95.8,143.49 96.07,143.23 96.07,142.43 93.83,140.19 91.74,140.19 88.12,136.57 87.04,136.57 86.02,135.56 86.02,134.47 v2(86.17,134.33)
  BOTTOM w0.102: RT9.1 86.64,133.06 86.64,133.37 86.06,133.94 86.06,134.22 v2(86.17,134.33)
EDP_COMP: length 6.3
  TOP w0.508: R60.2 79.11,101.6 v1(79.53,102.02) 80.5,102.99 81.41,102.99 v2(81.99,102.42)
  BOTTOM w0.381: v2(81.99,102.42) 81.51,102.9 JCPU1.E24
EDP_CPU_AUX: length 19.7
  IN2 w0.089: 74.58,116 74.58,115.98 74.56,115.96 74.56,107.99 73.53,106.96 73.53,106.18 73.75,105.97 73.95,105.97 74.02,106.04 v2(74.02,106.41)
  IN2 w0.127: v2(74.74,118.4) 74.58,118.23 74.58,116
  BOTTOM w0.089: v2(74.02,106.41) 73.55,105.94 JCPU1.N27
  BOTTOM w0.102: C190.1 74.52,123.01 74.52,118.62 v2(74.74,118.4)
EDP_CPU_AUX#: length 19.8
  IN2 w0.089: v2(74.02,105.46) 74.02,105.65 73.93,105.75 73.66,105.75 73.32,106.09 73.32,107.05 74.34,108.08 74.34,115.97 74.32,115.99 74.32,116
  IN2 w0.127: v2(74.16,118.4) 74.32,118.23 74.32,116
  BOTTOM w0.089: JCPU1.M27 74.51,105.94 v2(74.02,105.46)
  BOTTOM w0.102: v2(74.16,118.4) 74.3,118.54 74.3,123.08 C191.1
EDP_CPU_AUX#_R: length 14.3
  TOP w0.102: v2(81.83,132.24) 82.04,132.03 82.21,132.03 82.4,131.84 82.56,131.84 82.7,131.98 UT2.1
  BOTTOM w0.102: C191.2 74.25,124.6 74.25,124.85 74.7,125.3 76.92,125.3 79.01,127.39 79.01,129.68 81.37,132.03 81.62,132.03 v2(81.83,132.24)
EDP_CPU_AUX_R: length 14.2
  TOP w0.102: UT2.2 82.7,131.48 82.57,131.62 82.32,131.62 82.12,131.81 81.99,131.81 v2(81.83,131.65)
  BOTTOM w0.102: v2(81.83,131.65) 81.67,131.82 81.46,131.82 79.23,129.59 79.23,127.3 77.01,125.08 74.78,125.08 74.47,124.76 74.47,124.46 74.59,124.34 C190.2
EDP_CPU_LANE_N0: length 10
  BOTTOM w0.089: 73.4,116 73.26,115.86 72.69,115.86 72.67,115.85 72.67,115.85 72.11,115.29 72.11,114.78 72.51,114.37 JCPU1.P35
  BOTTOM w0.102: 73.4,116 v4(75.76,118.36) 76.12,118.72 76.12,120.1 76.14,120.13 76.14,120.8 76.12,120.83 76.12,121.21 C193.1
EDP_CPU_LANE_N0_R: length 12.8
  TOP w0.102: v2(81.78,129.41) 81.94,129.58 82.51,129.58 82.61,129.48 UT2.6
  BOTTOM w0.102: v2(81.78,129.41) 81.63,129.56 80.59,129.56 79.93,128.9 79.93,125.96 v4(78.74,124.77) 77.76,123.78 76.74,123.78 76.03,123.07 76.03,122.68 76.19,122.52 C193.2
EDP_CPU_LANE_P0: length 10
  BOTTOM w0.089: JCPU1.R35 71.51,114.37 71.84,114.7 71.9,114.77 71.9,115.38 72.52,116
  BOTTOM w0.102: C192.1 75.9,121.28 v4(75.9,120.44) 75.9,118.81 75.82,118.73 75.8,118.73 75.39,118.32 75.39,118.29 73.17,116.08 72.6,116.08 72.52,116
EDP_CPU_LANE_P0_R: length 12.9
  TOP w0.102: UT2.5 82.61,129.98 82.42,129.79 81.97,129.79 v2(81.76,130)
  BOTTOM w0.102: C192.2 75.81,122.79 75.81,123.16 76.65,124 77.67,124 78.39,124.72 78.39,124.74 78.77,125.12 78.79,125.12 79.71,126.04 79.71,128.99 80.5,129.78 81.54,129.78 v2(81.76,130)
EDP_HPD#: length 21
  TOP w0.089: 87.23,102.56 v1(84.72,102.56) 82.91,102.56 v2(81.99,103.48)
  TOP w0.102: Q6.1 88.68,102.25 88.38,102.56 RC1.1 87.23,102.56
  IN2 w0.089: v2(81.99,103.48) 78.39,103.48 77.86,104 72.92,104 72.4,104.52 72.4,106.05 v2(72.04,106.41)
  BOTTOM w0.089: JCPU1.P27 v2(72.04,106.41)
EN_VCORE2: length 4.4
  TOP w0.102: v1(25.15,93.22) 26.67,93.22 PR935.1
  TOP w0.254: PR935.1 27.94,91.95 PU902.3
ENBKL: length 121.1
  TOP w0.102: v2(154.24,92.66) 153.91,92.33 153.91,88.56 154.58,87.89 154.58,85.68 155.7,84.56 U31.76 ; UT2.17 89.08,128.48 v2(89.23,128.33)
  IN1 w0.127: v2(96.4,127.41) 96.66,127.15 96.66,126.52 97.83,125.35 97.83,123.01 97.57,122.74 97.57,114.58 98.53,113.62 100.24,113.62 102.46,115.84 111.55,115.84 112.25,115.14 121.85,115.14 123.09,113.89 129.33,113.89 130.8,115.35 140.91,115.35 141.11,115.15 150.73,115.15 151.57,114.31 v2(156.65,114.31)
  BOTTOM w0.102: v2(154.24,92.66) 154.58,93 154.58,96.38 v1(155.75,97.55) 156.65,98.45 v2(156.65,114.31) ; v2(96.4,127.41) 90.55,127.41 R438.2 89.63,128.33 v2(89.23,128.33)
ENLDO_3V5V: length 54.3
  TOP w0.254: v2(101.15,10.37) 101.56,10.37 PR412.2
  IN1 w0.254: v4(111.63,3.53) 110.39,3.53 103.54,10.37 v2(101.15,10.37)
  IN2 w0.254: v2(101.15,10.37) 100.03,9.26 92.1,9.26 90.3,7.46 80.87,7.46 77.76,4.35 69.58,4.35 68.46,5.47 68.46,6.97 68.75,7.26 v2(68.98,7.26)
  BOTTOM w0.102: v2(101.15,10.37) v1(101.15,11.16)
  BOTTOM w0.254: PR411.1 PR415.1 68.74,7.5 v2(68.98,7.26)
ENLDO_3V5V_1: length 3.6
  TOP w0.254: PR412.1 101.75,9.19 PC419.1 101.75,7.61 v2(101.88,7.48)
  BOTTOM w0.102: v1(101.73,8.29) 101.88,8.15 v2(101.88,7.48)
  BOTTOM w0.254: PU402.3 101.65,7.1 101.88,7.33 v2(101.88,7.48)
EXT_MIC: length 239.6
  TOP w0.254: MIC1.1 23.32,70.03 23.32,67.38 24.29,66.42 27.97,66.42 28.71,67.15 CA42.1 30.5,66.16 v1(30.5,64.06) 30.5,59.74 24.65,53.88 23.91,53.88 v2(23.9,53.9) ; CA41.1 157.95,42.85 RA23.2 156.28,42.85 v2(156,42.56) 154.95,42.56 154.69,42.83 CA44.1
  IN2 w0.254: v2(23.9,53.9) 24.21,53.58 24.21,34.29 22.9,32.97 22.9,19.46 26.3,16.06 40.48,16.06 41.77,17.34 42.14,17.71 42.14,18.65 42.54,19.05 47.69,19.05 47.73,19.1 47.76,19.1 48.48,19.82 115.79,19.82 125.14,29.17 125.14,43.84 126.32,45.02 132.09,45.02 133.46,46.38 133.46,53.14 134.8,54.48 145.05,54.48 146.04,53.48 146.04,46.75 148.24,44.55 152.74,44.55 154.73,42.56 v2(156,42.56)
FB1_VGA: length 3.8
  TOP w0.102: v1(191.39,144.04) 190.09,144.04
  TOP w0.254: PC874.1 190.09,144.04 190.75,143.38 v2(190.75,142.59)
  BOTTOM w0.254: PR842.2 190.97,142.81 v2(190.75,142.59)
FB2_VGA: length 2.1
  TOP w0.102: PR846.1 194.39,139.85 v1(194.65,139.58)
  TOP w0.254: PR846.1 193.58,139.84 PC848.2
FB_VGA: length 13.4
  TOP w0.203: PU801.8 190.77,139.26 v2(190.86,139.35)
  TOP w0.254: PR843.1 v2(190.09,142.49) ; PR846.2 192.67,140.22 192.95,140.5 v2(193.09,140.5)
  IN1 w0.254: v2(193.09,140.5) 192.01,140.5 v2(190.86,139.35)
  IN2 w0.254: v2(190.09,142.49) 190.74,141.84 190.86,141.84 191.37,141.34 191.37,139.86 v2(190.86,139.35)
  BOTTOM w0.254: v2(190.86,139.35) 189.97,138.46 PR849.1 ; PR842.1 190.06,142.53 v2(190.09,142.49) 190.09,142.4 190.41,142.08 v1(190.58,142.08) 191.27,142.08 PC847.2
FDI_CSYNC: length 76.4
  TOP w0.102: v2(122.15,78.34) 122.46,78.03 U4.AL39 ; v2(108,82) 105.23,84.77 105.23,105.99 102,109.22 94.84,109.22 91.09,112.97 85.77,112.97 84.69,111.88 84.69,110.25 83.39,108.95 79.51,108.95 v2(77.99,107.43)
  BOTTOM w0.089: v2(122.15,78.34) 122.06,78.34 121.51,77.78 120.16,77.78 119.66,78.28 118.59,78.28 118.25,77.94 115.38,77.94 115.3,78.02 ; v2(77.99,107.43) 78.51,107.94 JCPU1.H29
  BOTTOM w0.102: v2(108,82) 111.32,82 v1(113.25,80.08) 115.3,78.02
FDI_CTX_PRX_N0: length 83.1
  TOP w0.089: U4.AJ35 123.54,79.83 v2(123.24,80.13)
  IN2 w0.089: v2(71.93,111.49) 72.11,111.66 72.11,111.8 71.99,111.91 71.65,111.91 71.5,111.76 71.5,109.9 71.64,109.75 71.64,104.3 72.24,103.71 77.49,103.71 78.16,103.04 85.85,103.04 87.03,104.22 87.11,104.22 87.13,104.24 87.2,104.24 87.22,104.26 87.23,104.26
  IN2 w0.127: 87.23,104.26 97.51,104.26 98.86,102.91 101.18,102.91 v2(101.36,103.09)
  BOTTOM w0.089: JCPU1.P33 72.38,111.94 v2(71.93,111.49) ; 115.3,79.26 115.53,79.03 122.37,79.03 122.85,79.52 122.85,79.74 v2(123.24,80.13)
  BOTTOM w0.102: 115.3,79.26 111.86,82.7 106.21,82.7 103.85,85.06 103.85,99.45 102.09,101.2 102.09,102.68 101.86,102.91 101.54,102.91 v2(101.36,103.09)
FDI_CTX_PRX_N1: length 80.2
  TOP w0.102: U4.AL35 122.56,79.83 v2(122.21,80.18)
  IN2 w0.089: v2(72.93,110.46) 73.12,110.46 73.25,110.59 73.25,110.77 73.08,110.93 72.66,110.93 72.21,110.47 72.21,109.23 72.6,108.84 72.6,106.94 72.96,106.59 72.96,105.72 73.69,104.99 84.43,104.99 85.96,106.52 87.2,106.52 87.22,106.54 87.23,106.54
  IN2 w0.127: v2(102.97,104.32) 102.77,104.32 100.56,106.54 87.23,106.54
  BOTTOM w0.089: v2(72.93,110.46) 73.41,110.94 JCPU1.N32
  BOTTOM w0.102: v2(122.21,80.18) 122,79.97 121.79,79.97 121.44,79.61 115.83,79.61 115.45,79.99 112.12,83.32 106.5,83.32 104.47,85.35 104.47,100.06 103.19,101.33 103.19,103.84 102.97,104.06 v2(102.97,104.32)
FDI_CTX_PRX_P0: length 83.1
  TOP w0.089: v2(123.25,79.51) 123.53,79.23 U4.AJ36
  IN2 w0.089: 87.23,104 87.12,104 85.94,102.82 78.07,102.82 77.4,103.49 72.15,103.49 71.43,104.21 71.43,109.66 71.28,109.81 71.28,111.85 71.56,112.13 71.83,112.13 71.93,112.23 v2(71.93,112.42)
  IN2 w0.127: 87.23,104 97.41,104 98.76,102.66 101.21,102.66 v2(101.36,102.5)
  BOTTOM w0.089: 115.3,78.96 115.42,78.83 122.45,78.83 123.13,79.51 v2(123.25,79.51) ; JCPU1.R33 71.68,111.94 71.93,112.19 v2(71.93,112.42)
  BOTTOM w0.102: v2(101.36,102.5) 101.55,102.69 101.77,102.69 101.87,102.59 101.87,101.11 103.63,99.36 103.63,84.97 106.12,82.48 111.77,82.48 115.3,78.96
FDI_CTX_PRX_P1: length 80.2
  TOP w0.089: 122.63,79.23 122.56,79.23 v2(122.22,79.56)
  TOP w0.102: U4.AL36 122.63,79.23
  IN2 w0.089: 87.23,106.29 87.22,106.29 87.2,106.3 86.05,106.3 84.52,104.77 73.6,104.77 72.74,105.64 72.74,106.5 72.38,106.85 72.38,108.75 71.99,109.14 71.99,110.56 72.58,111.15 72.78,111.15 72.93,111.3 v2(72.93,111.45)
  IN2 w0.127: 87.23,106.29 100.45,106.29 102.55,104.18 v2(102.55,103.91)
  BOTTOM w0.089: JCPU1.P32 72.67,110.94 72.93,111.2 v2(72.93,111.45)
  BOTTOM w0.102: v2(102.55,103.91) 102.81,103.91 102.98,103.75 102.98,101.24 104.25,99.97 104.25,85.26 106.41,83.11 112.03,83.11 115.36,79.77 115.36,79.77 115.74,79.4 121.53,79.4 121.88,79.75 122.03,79.75 v2(122.22,79.56)
FDI_INT: length 73.9
  TOP w0.089: v2(77.98,108.42) 77.63,108.07 77.63,104.86 v2(78.09,104.4)
  TOP w0.102: v2(122.15,77.73) 122.44,77.44 U4.AL40
  IN2 w0.089: v2(78.09,104.4) 78.46,104.03 85.09,104.03 86.7,105.64 87.23,105.64
  IN2 w0.127: v2(101.33,103.82) 101.33,104.59 100.15,105.78 87.37,105.78 87.23,105.64
  BOTTOM w0.089: JCPU1.J29 77.51,107.96 v2(77.98,108.42) ; v2(122.15,77.73) 121.92,77.49 120.2,77.49 119.59,78.1 118.66,78.1 118.32,77.76 115.53,77.76 115.3,77.54 115.3,77.54
  BOTTOM w0.102: v2(101.33,103.82) 100.83,103.32 100.83,101.47 103.15,99.16 103.15,84.77 106.84,81.07 111.59,81.07 v1(114.42,78.24) 115.13,77.54 115.3,77.54
FDI_RCOMP: length 4.6
  TOP w0.089: v2(119.69,75) 120.07,75 120.3,75.23 120.3,75.56 120.72,75.98 U4.AR44
  BOTTOM w0.089: 118.62,74.85 118.81,75.04 v1(119.01,75.04) 119.65,75.04 v2(119.69,75)
  BOTTOM w0.102: R145.1 119.31,74.09 119.1,74.3 118.87,74.3 118.58,74.59 118.58,74.81 118.62,74.85
GATEA20: length 120
  TOP w0.102: v2(115.85,103.75) 116.04,103.56 RP15.8 ; v2(121.29,90.74) 121.63,90.4 U4.AN10 ; U31.1 174.6,76.56 174.34,76.82 173.71,76.82 173.31,77.21 v2(173.31,77.54)
  IN1 w0.089: v2(121.29,90.74) 120.93,91.1 120.93,92.08 120.74,92.27 120.74,92.97 119.2,94.51 119.2,94.79
  IN1 w0.127: 119.2,94.79 119.2,96.12 119.43,96.35 119.43,96.96 118.89,97.49 118.89,99.8 115.85,102.84 v2(115.85,103.75)
  IN2 w0.127: v2(115.85,103.75) 115.85,103.43 115.15,102.73 113.32,102.73 113.01,103.03 113.01,104.13 115.29,106.41 123.12,106.41 124.82,108.11 125.09,108.11 126.56,109.58 129.86,109.58 130.48,110.2 132.43,110.2 133.18,110.94 137.7,110.94 138.44,111.68 158.09,111.68 158.83,110.94 165.84,110.94 v2(166.82,109.97)
  BOTTOM w0.102: v2(166.82,109.97) 166.82,109.29 166.44,108.91 166.44,103.44 166.44,103.44 166.44,101.21 170.21,97.43 170.21,93.98 170.48,93.71 170.48,92.99 170.61,92.86 170.61,91.92 170.12,91.44 v1(170.12,88.54) 170.12,87.54 171.06,86.6 171.06,85.63 170.19,84.75 170.19,81.98 171.67,80.49 171.67,79.2 173.31,77.57 v2(173.31,77.54)
GENLK_CLK: length 1.7
  TOP w0.102: T1.1 140.87,132.97 v2(140.42,133.41)
  BOTTOM w0.102: UV1.AD29 139.96,133.87 v2(140.42,133.41)
GENLK_VSYNC: length 1.5
  TOP w0.102: v2(139.22,133.47) 139.31,133.39 T2.1
  BOTTOM w0.102: v2(139.22,133.47) 138.82,133.87 UV1.AC29
GPIO_28_FDO: length 10.6
  TOP w0.102: v1(151.77,129.12) 151.47,129.42 RV26.2 151.45,130.11 RV31.2 151.12,131.35 v2(150.87,131.35)
  IN1 w0.102: v2(150.87,131.35) 150.7,131.52 148.49,131.52 148.33,131.37 144.51,131.37 v2(144,131.87)
  BOTTOM w0.102: v2(144,131.87) 144.4,131.47 UV1.AK32
GPU_GPIO0: length 81
  TOP w0.254: PR834.1 192.94,137.58 v2(193.17,137.36)
  IN2 w0.102: 152.86,126.76 151.96,127.67 151.86,127.67 151.12,128.41 151.12,129.4 149.8,130.72 149.11,130.72 148.28,131.54 148.28,132.95 147.57,133.66 147.57,135.56 148.01,136 148.01,138.11 147.38,138.74 146.64,138.74 146.42,138.97 146.42,139.7 144.96,141.17 144.93,141.17 v2(144.2,141.89)
  IN2 w0.127: 152.86,126.76 154.71,124.91 155.71,124.91 159.36,121.27 171.5,121.27 172.77,122.54 172.77,124.13 173.72,125.08 173.72,127.97 174.21,128.46 176.07,128.46 179.02,131.42 180.02,131.42 180.14,131.29 183.35,131.29 183.82,131.75 185.41,131.75 186.1,132.45 188.78,132.45 189.68,131.54 190.66,131.54 191.65,132.53 191.65,134.5 193.17,136.02 v2(193.17,137.36)
  BOTTOM w0.102: UV1.AH20 143.08,141.89 v2(144.2,141.89)
  BOTTOM w0.254: PR818.1 190.82,136.04 191.28,136.5 192.32,136.5 v1(192.67,136.86) v2(193.17,137.36)
GPU_GPIO5: length 26.7
  TOP w0.102: v1(153.27,128.48) 152.97,128.18 v2(151.96,128.18) 151.71,127.92 151.71,126.71 152.34,126.08 DV1.2 152.34,124.27 RV5.2
  IN2 w0.102: v2(151.96,128.18) 151.96,128.88 149.28,131.56 148.91,131.56 148.48,131.98 148.48,133.03 147.77,133.74 147.77,135.47 148.22,135.91 148.22,138.2 147.43,138.99 146.9,138.99 146.63,139.25 146.63,139.78 145.12,141.29 145.12,141.81 144.58,142.34 144.11,142.34 v2(143.31,143.14)
  BOTTOM w0.102: v2(143.31,143.14) 142.85,143.6 UV1.AH17
GPU_IMON: length 103.2
  TOP w0.102: U31.64 162.39,92.1 v2(161.58,92.91)
  TOP w0.203: PU801.18 186.22,141.55 185.86,141.9 PR844.1
  TOP w0.254: PR844.1 186.29,143.61 v2(186.59,143.61)
  IN1 w0.254: v2(186.59,143.61) 191.56,143.61 v2(191.73,143.44)
  IN2 w0.127: v2(161.58,92.91) 161.85,92.91 163.83,90.93 178.14,90.93 178.91,91.7 181.05,91.7 181.45,91.3 v2(184.63,91.3)
  BOTTOM w0.102: v2(191.73,143.44) 193.01,143.44 194.53,141.92 194.53,137.65 193.56,136.68 193.56,134.79 188.48,129.7 187.8,129.7 187.57,129.47 185.03,129.47 183.73,128.17 183.73,123.8 185.48,122.06 v1(186.85,122.06) 187.37,122.06 188.68,120.75 188.68,117.79 187.88,116.99 187.88,109.98 186.02,108.12 186.02,100.86 183.94,98.78 183.94,96.13 184.63,95.45 v2(184.63,91.3)
  BOTTOM w0.254: PC849.1 PR847.2 186.59,143.7 v2(186.59,143.61)
GPU_RST#: length 13.6
  TOP w0.102: v2(138.12,132.8) 137.37,132.8 136.32,131.75 136.32,131.01 135.22,129.91 134.39,129.91 133.54,129.06 v1(133.54,127.75) 133.54,126.49 132.65,125.61 UV2.4 132.2,126.27 131.93,126.54 131.39,126.54 RV4.1
  BOTTOM w0.102: UV1.AA30 137.85,133.07 v2(138.12,132.8)
GPU_VID0: length 8
  TOP w0.203: PR812.1 181.57,134.8 181.94,135.16 185.29,135.16 185.42,135.3 PU801.31
  TOP w0.254: PR812.1 181.98,134.2 v2(182.26,133.92)
  BOTTOM w0.102: v1(180.54,134.6) 180.96,134.18 PR806.1
  BOTTOM w0.254: v2(182.26,133.92) 182,134.18 PR806.1
GPU_VID1: length 78.7
  TOP w0.203: PU801.32 185.82,135.12 185.47,134.77 183.23,134.77 183,134.54 PR811.1
  TOP w0.254: PR811.1 182.67,134.19 v2(182.28,134.58)
  IN1 w0.102: 152.86,147.81 152.6,147.81 151.3,146.52 149.22,146.52 148.88,146.17 146.91,146.17 v2(146.43,146.65)
  IN1 w0.127: v2(158.74,150.59) 158.74,150.27 157.31,148.84 154.3,148.84 153.27,147.81 152.86,147.81
  IN2 w0.127: v2(182.28,134.58) 180.57,134.58 175.64,129.65 173.72,129.65 172.57,128.51 172.57,125.84 170.35,123.62 161.02,123.62 158.41,126.22 158.41,135.38 156.85,136.94 156.85,146.97 158.54,148.66 158.54,150.4 v2(158.74,150.59)
  BOTTOM w0.102: UV1.AM13 146.05,147.03 v2(146.43,146.65) ; v1(159.13,151.19) 158.74,150.8 v2(158.74,150.59)
  BOTTOM w0.254: PR811.1 182.67,134.19 v2(182.28,134.58)
GPU_VID2: length 79.5
  TOP w0.203: PR810.1 v2(184.62,134.19) 185.42,134.19 186.22,134.99 PU801.33
  IN1 w0.102: v2(145.62,146.65) 146.3,145.97 148.97,145.97 149.27,146.27 151.39,146.27 152.61,147.5 152.86,147.5
  IN1 w0.127: 152.86,147.5 153.32,147.5 154.41,148.59 157.41,148.59 158.6,149.78 v2(158.99,149.78)
  IN2 w0.127: v2(184.62,134.19) 183.77,135.05 180.68,135.05 175.6,129.97 173.65,129.97 172.32,128.64 172.32,128.61 172.32,125.95 170.25,123.87 161.12,123.87 158.67,126.33 158.67,135.48 157.11,137.05 157.11,146.87 158.8,148.55 158.8,149.59 v2(158.99,149.78)
  BOTTOM w0.102: v2(145.62,146.65) 145.25,147.02 UV1.AL13 ; v2(158.99,149.78) 158.45,149.78 v1(158.15,150.09)
  BOTTOM w0.254: PR804.1 v2(184.62,134.19)
GPU_VID3: length 62.4
  TOP w0.102: v1(143.4,132.04) 143.24,131.87 v2(142.86,131.87)
  TOP w0.203: PU801.34 186.62,134.72 PR809.1
  TOP w0.254: v2(184.91,133.66) 184.91,133.66 PR809.1
  IN1 w0.102: 152.86,130.4 142.95,130.4 142.4,130.94 142.4,131.42 v2(142.86,131.87)
  IN1 w0.127: 152.86,130.4 153.42,130.4 154.95,128.86 157.6,128.86 158.6,127.85 158.6,125.86 160.07,124.4 160.62,124.4 161.02,124 170.95,124 172.38,125.44 172.38,127.44 173.8,128.86 180.18,128.86 180.31,128.99 184.77,128.99 186.66,130.88 186.66,131.91 v2(184.91,133.66)
  BOTTOM w0.102: v2(142.86,131.87) 142.45,131.47 UV1.AG32
  BOTTOM w0.254: v2(184.91,133.66) 185.04,133.66 PR803.1
GPU_VID4: length 63.3
  TOP w0.102: v1(141.96,131.79) 141.59,131.42 v2(141.59,131.24)
  TOP w0.203: PU801.35 187.02,134.61 186.46,134.05 PR808.1
  TOP w0.254: PR808.1 186.63,133.65 v2(187.09,133.2)
  IN1 w0.102: 152.86,129.66 152.43,130.09 142.73,130.09 v2(141.59,131.24)
  IN1 w0.127: 152.86,129.66 153.92,128.61 157.49,128.61 158.35,127.75 158.35,125.97 158.35,125.97 158.35,125.76 159.96,124.15 160.17,124.15 160.51,124.15 160.91,123.75 171.05,123.75 172.64,125.33 172.64,127.34 173.91,128.61 180.29,128.61 180.42,128.74 186.35,128.74 187.75,130.13 187.75,132.53 v2(187.09,133.2)
  BOTTOM w0.102: v2(141.59,131.24) 142.15,130.67 UV1.AG33
  BOTTOM w0.254: PR802.1 187.3,133.2 v2(187.09,133.2)
GPU_VID5: length 69
  TOP w0.203: PU801.36 v1(187.42,134.6) 187.42,134.39 187.63,134.18 187.63,134.18 187.77,134.04 PR807.1
  TOP w0.254: v2(187.11,133.86) 187.3,133.67 PR807.1
  IN2 w0.102: 152.86,127.15 152.64,127.38 152.64,128.56 149.44,131.76 148.99,131.76 148.78,131.98 148.78,137.36 148.61,137.52 148.61,139.07 145.09,142.59 144.63,142.59 v2(144.07,143.16)
  IN2 w0.127: 152.86,127.15 154.85,125.17 155.82,125.17 159.46,121.52 171.39,121.52 172.51,122.64 172.51,124.23 173.46,125.18 173.46,127.87 173.46,128.08 174.1,128.72 175.96,128.72 179.01,131.76 181.67,131.76 182.1,132.19 185.45,132.19 v2(187.11,133.86)
  BOTTOM w0.102: v2(144.07,143.16) 143.65,143.57 UV1.AJ17
  BOTTOM w0.254: PR801.1 186.78,134.19 v2(187.11,133.86)
GPU_VID6: length 5.2
  TOP w0.203: PU801.37 187.82,134.64 v2(188.09,134.37)
  BOTTOM w0.102: v1(184.83,135.43) PR814.1
  BOTTOM w0.254: PR814.1 186.52,134.87 186.86,134.87 187.36,134.37 v2(188.09,134.37)
GREEN: length 13.7
  TOP w0.102: v1(12.21,116.15) 11.74,116.62 11.17,116.62 v2(10.76,117.03)
  IN2 w0.127: v2(10.76,117.03) 10.52,117.27 7.16,117.27 6.25,116.36 JCRT1.2
  BOTTOM w0.102: L31.2 12.7,112.74 C526.1 12.68,112.76 U10.4 12.68,115.9 12,116.58 11.21,116.58 v2(10.76,117.03)
H_CATERR#: length 6
  TOP w0.089: 52.03,111.57 50.22,113.38 T31.1
  TOP w0.102: v2(53.01,111.46) 52.9,111.57 52.03,111.57
  BOTTOM w0.089: JCPU1.AN32 53.51,110.96 v2(53.01,111.46)
H_CPU_RSVD: length 3.9
  TOP w0.102: R66.2 78.99,103.39 v1(79.22,103.62) v2(79.99,104.39)
  BOTTOM w0.089: v2(79.99,104.39) 79.51,104.87 JCPU1.G26
H_CPU_SVIDALRT#: length 12.7
  TOP w0.102: R83.2 52.84,115.66 52.84,114.53 53.73,113.64 54.64,113.64 55.35,112.92 55.35,110.63 55.43,110.56 55.43,108.83 v1(54.48,107.88) v2(54.03,107.43)
  BOTTOM w0.089: JCPU1.AM28 54.51,106.95 v2(54.03,107.43)
H_CPU_TESTLO: length 11.1
  TOP w0.102: v2(72.97,117.78) 73.37,117.37 R64.2
  BOTTOM w0.089: 71.46,116 70,114.54 70,113.84 69.54,113.38 67.88,113.38 67.51,113.02 JCPU1.W34
  BOTTOM w0.102: 71.46,116 71.46,118.16 71.6,118.3 v1(72.17,118.3) 72.84,118.3 72.97,118.17 v2(72.97,117.78)
H_CPUPWRGD: length 106.7
  TOP w0.089: U4.AV3 119.9,92.95 v2(119.65,92.7)
  TOP w0.102: R15.2 44.57,101.2 44.76,101.39 47.04,101.39 47.27,101.16 C536.1 47.81,100.67 v2(48.04,100.9) ; v2(77.13,118.79) v3(77.13,119.36)
  IN1 w0.089: v2(119.65,92.7) 119.09,93.27 117.34,93.27 116.2,94.4 116.2,94.79
  IN1 w0.127: v2(77.13,118.79) 77.49,119.15 86.28,119.15 90.96,114.46 90.96,110.15 95.17,105.94 103.37,105.94 107.4,101.91 110.81,101.91 112.64,100.09 114.5,100.09 116.2,98.39 116.2,94.79
  IN2 w0.089: 68.56,116 67.93,115.36 57.96,115.36 56.56,113.97 56.56,112.97 v2(56.08,112.49) 54.54,110.94 52.81,110.94 48.24,106.37
  IN2 w0.127: 48.24,106.37 47.29,105.42 47.29,101.65 v2(48.04,100.9) ; 68.56,116 72.18,119.62 76.31,119.62 v2(77.13,118.79)
  BOTTOM w0.089: v2(56.08,112.49) 55.62,112.94 JCPU1.AL34
H_DRAMRST#: length 15
  TOP w0.089: v2(53.04,81.41) 52.4,82.05 52.4,82.56 52.15,82.81 48.24,82.81
  TOP w0.102: v2(47.97,82.64) 48.14,82.81 48.24,82.81
  BOTTOM w0.089: JCPU1.AN3 53.51,81.88 v2(53.04,81.41)
  BOTTOM w0.102: v2(47.97,82.64) 47.97,78.28 v1(46.71,77.03) 46.4,76.71 46.4,75.09 R46.1
H_PECI: length 167.6
  TOP w0.102: R255.2 v2(114.28,98.91) ; R669.2 v2(170.79,70.79)
  IN1 w0.089: v2(84.01,106.65) 84.01,109.45 83.41,110.04 80.13,110.04 78.24,111.94 57.87,111.94 57.49,111.55 57.49,107.15 57.26,106.92 51.51,106.92 v2(51.05,106.46)
  IN1 w0.127: v2(107.73,99.32) 109.07,99.32 109.8,98.6 111.09,98.6 111.42,98.93 112.52,98.93 112.92,99.34 113.86,99.34 v2(114.28,98.91)
  IN2 w0.089: v2(84.01,106.65) 84.74,106.65 85.28,107.19 87.23,107.19
  IN2 w0.127: v2(167.11,98.73) 159.49,98.73 154.54,103.68 149.8,103.68 147.73,105.75 129.19,105.75 125.75,102.31 120.55,102.31 119.18,100.94 117.56,100.94 115.97,99.35 114.72,99.35 v2(114.28,98.91) ; v2(107.73,99.32) 107.32,99.73 107.32,99.81 106.73,100.4 106.73,102.44 101.98,107.19 87.23,107.19
  BOTTOM w0.089: v2(51.05,106.46) 51.51,106 JCPU1.AR27
  BOTTOM w0.102: v2(170.79,70.79) 170.79,71.21 170.2,71.8 170.2,76.02 170.43,76.25 170.43,78.15 168.94,79.64 168.94,87.1 168.26,87.78 168.26,94.55 167.33,95.47 167.33,96.76 167.11,96.98 v1(167.11,97.72) v2(167.11,98.73)
H_PM_SYNC: length 102.4
  TOP w0.102: R10.1 45.58,104.49 v2(45.55,104.45) v1(44.83,104.45) ; v2(118.74,92.69) 119.09,93.04 U4.AY3
  IN1 w0.089: 116.5,93.75 116.5,93.74 117.36,92.89 118.54,92.89 v2(118.74,92.69)
  IN1 w0.127: 116.5,93.75 115.69,94.56 115.69,96.81 114.99,97.51 109.35,97.51 108.62,98.23 106.27,98.23 104.74,99.77 100.44,99.77 99.51,100.7 90.9,100.7 90.16,99.96 88.24,99.96 87.05,101.15 87.05,112.19 85.41,113.83 53.71,113.83 52.24,115.3 48.05,115.3 47.25,114.5 47.25,107.95 46.86,107.55 46.86,105.76 v2(45.55,104.45)
H_PM_SYNC_R: length 6.3
  TOP w0.089: 48.24,104.49 49.39,105.63 v2(49.39,106.4) 49.39,106.4 49.84,105.95 v1(50.67,105.95)
  TOP w0.102: R10.2 48.24,104.49
  BOTTOM w0.089: 49.93,106.94 v2(49.39,106.4)
  BOTTOM w0.102: JCPU1.AT28 49.93,106.94
H_PROCHOT#: length 316.2
  TOP w0.102: v2(180.64,116.17) 181.29,116.82 183.05,116.82 ; PQ101.6 183.06,116.83 183.05,116.82 ; PR915.1 21.42,125.89 20.89,125.36 v2(20.89,124.96) ; PQ101.3 184.36,116.05 184.46,116.15 184.46,116.57 184.21,116.82 183.05,116.82 ; PQ201.1 177.67,58.85 177.54,58.99 176.81,58.99 176.64,58.83 165.49,58.83 v2(164.53,59.79) 163.59,60.73 v1(163.59,63.23) Q37.1 C493.1 ; R9.1 46.37,110.92 R8.2 45.1,110.53 v2(45.1,110.02)
  IN1 w0.127: v2(45.1,110.02) 45.1,111.84 44.65,112.29 44.65,114.68 47.18,117.21 63.86,117.21 67.29,120.63 71.01,120.63 v2(72.65,122.27) 72.65,128.27 69.73,131.19 50.22,131.19 48.57,129.54 21.44,129.54 20.77,128.86 20.77,125.07 v2(20.89,124.96) ; v2(99.58,118.41) 102.15,118.41 103.07,117.5 121.64,117.5 123.72,115.42 128.7,115.42 130.16,116.88 141.54,116.88 141.78,116.63 158.12,116.63 158.76,116 160.69,116 162.34,117.65 164.27,117.65 166.63,120.01 174.31,120.01 177.92,116.41 180.4,116.41 v2(180.64,116.17) 180.64,88.22 179.2,86.79 179.2,81.54 178.73,81.07 178.73,76.22 177.6,75.09 177.6,73.64 170.78,66.82 168.93,66.82 167.38,65.28 167.38,62.6 164.58,59.79 v2(164.53,59.79)
  IN2 w0.127: v2(72.65,122.27) 73.53,121.4 96.6,121.4 v2(99.58,118.41)
H_PROCHOT#_R: length 8
  TOP w0.089: v2(54.04,109.41) 53.55,109.41 52.95,110.01 49.88,110.01 v1(49.38,110.51) 48.97,110.92 48.24,110.92
  TOP w0.102: R9.2 48.24,110.92
  BOTTOM w0.089: v2(54.04,109.41) 54.51,108.94 JCPU1.AM30
H_THRMTRIP#: length 77.6
  TOP w0.089: v1(54.64,115.26) 54.51,115.13 v2(54.51,114.56)
  TOP w0.102: R262.2 114.94,98.5 v2(114.94,98.93)
  IN1 w0.089: v2(54.51,114.56) 55.22,115.28 84.67,115.28 87.23,112.71
  IN1 w0.127: 87.23,112.71 87.66,112.28 87.66,101.26 88.45,100.47 89.9,100.47 90.65,101.22 99.71,101.22 100.65,100.27 104.95,100.27 106.48,98.74 108.83,98.74 109.56,98.02 114.23,98.02 114.94,98.73 v2(114.94,98.93)
  BOTTOM w0.089: JCPU1.AM35 v2(54.51,114.56)
HDA_BIT_CLK: length 7.2
  TOP w0.089: 137.96,80.28 v2(137.95,80.27) ; 137.96,82.62 136.53,84.05 134.93,84.05 U4.B25
  TOP w0.102: 137.96,80.28 138.19,80.51 v1(138.19,81.16) 138.19,82.4 137.96,82.62
  BOTTOM w0.102: RP12.1 137.9,80.78 137.7,80.58 137.7,80.38 137.8,80.27 v2(137.95,80.27)
HDA_BITCLK_AUDIO: length 48.3
  TOP w0.102: UA1.5 159.73,48.87 v2(159.81,48.79) ; v2(159.52,56.87) 159.52,56.87 RA21.2
  IN2 w0.127: v2(146.03,76.12) 146.03,75.44 147.35,74.12 152.89,74.12 154.4,72.6 v2(154.63,72.6)
  BOTTOM w0.102: v2(159.81,48.79) 159.71,48.89 159.71,56.68 v2(159.52,56.87) 159.52,57.15 v1(155.57,61.1) 155.06,61.61 155.06,72.17 v2(154.63,72.6) ; v2(146.03,76.12) 146.03,79.01 144.94,80.1 140.75,80.1 140.06,80.78 RP12.8
HDA_RST#: length 6.1
  TOP w0.089: U4.C24 134.88,84.41 135.36,84.89 136.31,84.89 v2(136.76,84.43)
  BOTTOM w0.102: v2(136.76,84.43) 136.95,84.24 136.95,83.55 137.46,83.04 137.46,82.1 137.78,81.78 RP12.3
HDA_RST_AUDIO#: length 50.8
  TOP w0.102: RA15.2 162.77,52.8 161.63,52.8 CA11.1 160.64,52.25 160.34,51.95 v2(160.34,51.32) 159.5,50.47 UA1.9
  IN2 w0.127: v2(146.88,76.25) 148.31,74.83 153.45,74.83 154.41,73.86 v2(154.67,73.86)
  BOTTOM w0.102: v2(146.88,76.25) 146.75,76.39 146.75,78.94 145.13,80.55 140.94,80.55 139.71,81.78 RP12.6 ; v2(154.67,73.86) v1(155.24,73.29) 155.52,73.01 155.52,62.3 160.34,57.47 v2(160.34,51.32)
HDA_SDIN0: length 69.9
  TOP w0.102: U4.L22 131.23,85.36 v2(131.23,85.59) ; RA9.1 162.87,49.29 v2(162.81,49.35)
  IN2 w0.089: v2(131.23,85.59) 131.63,85.99 133.55,85.99 135.97,88.41 136.76,88.41
  IN2 w0.127: 136.76,88.41 145.73,88.41 147.02,89.7 151.43,89.7 152.14,88.99 v2(154.72,88.99)
  BOTTOM w0.102: v2(162.81,49.35) 162.81,55.57 155.75,62.63 155.75,73.54 155.18,74.1 155.18,74.58 155.43,74.83 155.43,82.37 v1(155.3,82.5) 155.18,82.62 155.18,88.52 v2(154.72,88.99)
HDA_SDOUT_AUDIO: length 50.3
  TOP w0.102: UA1.4 159.54,48.47 159.71,48.3 v2(160.21,48.3)
  IN2 w0.127: v2(147.37,76.61) 148.74,75.24 153.86,75.24 v2(154.6,74.5)
  BOTTOM w0.102: v2(154.6,74.5) 154.6,74.37 154.12,73.89 154.12,67.27 154.83,66.56 154.83,61.37 v1(158.52,57.69) 159.12,57.09 159.12,56.41 159.41,56.12 159.41,48.62 159.73,48.3 v2(160.21,48.3) ; RP12.5 139.53,82.28 140.13,81.69 140.95,81.69 141.86,80.78 145.23,80.78 146.97,79.04 146.97,77.01 v2(147.37,76.61)
HDA_SPKR: length 89.6
  TOP w0.102: U4.AL10 122.48,90.4 v2(122.19,90.69) ; CA45.1 162.03,56.13 162.57,56.13 v2(162.7,56.26)
  IN2 w0.089: v2(122.19,90.69) 122.72,91.22 122.72,92.71 123.87,93.86 126.62,93.86 127.16,94.4 129.04,94.4 129.43,94.79
  IN2 w0.127: 129.43,94.79 130.24,95.6 130.24,96.85 133.08,99.69 136.13,99.69 137.3,100.86 139.1,100.86 140.2,99.76 147.57,99.76 150.21,97.11 154.53,97.11 v2(155.54,96.11)
  BOTTOM w0.102: v2(162.7,56.26) 162.49,56.26 156.2,62.55 v1(156.2,62.82) 155.98,63.04 155.98,73.44 155.98,73.44 155.98,73.63 155.89,73.72 155.41,74.2 155.41,74.48 155.66,74.73 155.66,82.8 155.41,83.05 155.41,89.35 154.72,90.04 154.72,90.47 155.07,90.83 155.07,95.2 155.54,95.66 v2(155.54,96.11) ; v2(122.19,90.69) 121.81,91.07 121.81,92.61 121.1,93.31 R102.2
HDA_SYNC: length 19.7
  TOP w0.089: U4.A22 136.22,85.22 136.65,84.8 137.07,84.8 137.14,84.73 137.14,84.17 137.2,84.12 v1(137.46,84.12) 137.75,84.12
  TOP w0.102: v2(143.58,79.6) 143.58,82.81 142.82,83.58 139.89,83.58 139.34,84.12 R100.1 138.29,84.12 138.29,84.12 137.75,84.12
  BOTTOM w0.102: RP12.2 138.59,81.28 138.68,81.19 138.68,79.89 138.97,79.6 v2(143.58,79.6)
HDA_SYNC_AUDIO: length 47.1
  TOP w0.102: UA1.8 159.49,50.07 160.09,50.67 v2(160.35,50.67)
  IN2 w0.127: v2(146.51,75.79) 147.82,74.48 153.09,74.48 154.38,73.2 v2(154.64,73.2)
  BOTTOM w0.102: v2(154.64,73.2) 155.29,72.55 155.29,62.04 v1(157.67,59.67) 159.97,57.36 159.97,51.63 159.94,51.59 159.94,51.08 v2(160.35,50.67) ; v2(146.51,75.79) 146.46,75.84 146.46,78.9 145.04,80.32 140.84,80.32 139.88,81.28 RP12.7
HDD_DET#: length 9.3
  TOP w0.089: 119.11,97.07 119.11,97.04 120.34,95.81 120.34,95.03 120.71,94.66 U4.AT1
  TOP w0.102: 119.11,97.07 119.11,99.19 v1(118.84,99.46) 118.29,100.02 117.15,100.02 116.69,100.48 RP15.4
HDMI_CLK+_CK: length 4.2
  BOTTOM w0.102: L35.1 23.95,64.43 24.23,64.7 24.73,64.7 25.27,65.24 25.27,66.02 25.57,66.33 25.94,66.33 C47.1
HDMI_CLK+_CONN: length 15
  TOP w0.102: v2(20.26,64.41) 20.08,64.59 19.84,64.59 19.25,63.99 19.08,63.99 18.94,63.85 RP5.7
  BOTTOM w0.102: L35.2 21.3,64.43 21.01,64.72 20.88,64.72 20.75,64.58 20.43,64.58 v2(20.26,64.41) 20.09,64.58 19.61,64.58 19.47,64.44 D28.7 D28.4 17.91,64.44 17.77,64.58 16.99,64.58 14.88,66.68 14.88,67.64 13.06,69.46 12.29,69.46 JHDMI1.10
HDMI_CLK-_CK: length 4.2
  BOTTOM w0.102: L35.4 23.92,65.23 24.23,64.92 24.64,64.92 25.04,65.31 v4(25.04,65.73) 25.04,66.1 25.48,66.55 26,66.55 C46.1
HDMI_CLK-_CONN: length 15.1
  TOP w0.102: RP5.8 18.9,64.35 19.05,64.21 19.16,64.21 19.76,64.81 20.07,64.81 v2(20.26,64.99)
  BOTTOM w0.102: JHDMI1.12 12.28,69.67 13.15,69.67 15.09,67.73 15.09,66.77 17.08,64.79 17.77,64.79 17.92,64.94 D28.5 D28.6 19.47,64.94 19.61,64.8 20.07,64.8 v2(20.26,64.99) 20.45,64.81 20.67,64.81 20.79,64.94 21.03,64.94 21.32,65.23 L35.3
HDMI_DET: length 27.6
  TOP w0.102: v2(16.73,70.03) 16.11,69.41 16.11,66.63 15.05,65.58 R488.2 15,65.11 15.22,64.88 16.52,64.88 17.94,66.3 21.5,66.3 22,65.8 v1(22,64.81) 22.4,64.41 Q93.1
  IN2 w0.127: v2(13.26,70.35) 13.26,73.54 12.96,73.84 10.62,73.84 JHDMI1.19
  BOTTOM w0.102: v2(13.26,70.35) D32.7 D32.4 16.25,70.35 16.58,70.03 v2(16.73,70.03)
HDMI_TX0+_CK: length 1.8
  BOTTOM w0.102: L36.1 28.76,60.84 29.05,61.13 29.4,61.13 C45.1
HDMI_TX0+_CONN: length 25.3
  TOP w0.102: RP6.5 19.36,59.6 19.5,59.74 19.73,59.74 20.32,59.15 20.52,59.15 v2(20.7,58.97)
  IN2 w0.127: JHDMI1.7 10.7,67.92 10.87,67.92 11,67.8 11,64.53 11.73,63.8 12.45,63.8 15.44,60.82 15.81,60.82 v2(15.98,60.65)
  BOTTOM w0.102: v2(15.98,60.65) 16.16,60.83 16.37,60.83 17.82,59.38 18.13,59.38 18.28,59.23 D29.1 D29.9 19.89,59.23 20.01,59.36 20.11,59.36 20.31,59.15 20.52,59.15 v2(20.7,58.97) 20.88,59.15 23.23,59.15 25.22,61.13 25.64,61.13 25.93,60.84 L36.2
HDMI_TX0-_CK: length 1.8
  BOTTOM w0.102: L36.4 28.72,61.64 29.02,61.35 29.49,61.35 C44.1
HDMI_TX0-_CONN: length 25.3
  TOP w0.102: RP6.6 19.37,60.1 19.51,59.96 19.82,59.96 20.41,59.37 20.52,59.37 v2(20.7,59.55)
  IN2 w0.127: JHDMI1.9 10.72,68.18 10.98,68.18 11.26,67.9 11.26,64.63 11.83,64.06 12.56,64.06 15.54,61.07 15.82,61.07 v2(15.98,61.23)
  BOTTOM w0.102: v2(15.98,61.23) 16.16,61.05 16.46,61.05 17.91,59.6 18.13,59.6 18.27,59.73 D29.2 D29.8 19.87,59.73 20.04,59.57 20.2,59.57 20.4,59.37 20.52,59.37 v2(20.7,59.55) 20.89,59.36 23.14,59.36 25.13,61.35 25.64,61.35 25.93,61.64 L36.3
HDMI_TX1+_CK: length 5.8
  BOTTOM w0.102: L37.1 23.99,62.6 24.28,62.89 24.5,62.89 25.22,63.62 25.24,63.62 25.65,64.03 25.65,64.04 26.54,64.93 v4(27.01,64.93) 27.76,64.93 C43.1
HDMI_TX1+_CONN: length 13.4
  TOP w0.102: RP5.5 18.94,62.85 19.08,62.99 19.9,62.99 v2(20.03,62.86)
  BOTTOM w0.102: JHDMI1.4 12.22,66.39 13.79,66.39 14.56,65.62 14.56,65.59 15.21,64.93 15.25,64.93 v4(16.59,63.59) 17.09,63.09 17.72,63.09 17.87,62.94 D28.1 D28.9 19.52,62.94 19.66,63.08 19.81,63.08 v2(20.03,62.86) 20.24,63.07 20.62,63.07 20.79,62.89 20.98,62.89 21.27,62.6 L37.2
HDMI_TX1-_CK: length 5.8
  BOTTOM w0.102: L37.4 23.98,63.4 24.27,63.11 24.41,63.11 v4(25.28,63.98) 26.45,65.15 26.73,65.15 26.74,65.16 27.27,65.16 27.29,65.15 27.77,65.15 C42.1
HDMI_TX1-_CONN: length 13.4
  TOP w0.102: v2(20.03,63.44) 19.8,63.21 19.08,63.21 18.94,63.35 RP5.6
  BOTTOM w0.102: L37.3 21.3,63.4 21.01,63.11 20.88,63.11 20.71,63.28 20.2,63.28 v2(20.03,63.44) 19.89,63.3 19.65,63.3 19.51,63.44 D28.8 D28.2 17.86,63.44 17.72,63.31 17.18,63.31 17.04,63.44 16.94,63.54 16.94,63.56 16.57,63.94 16.55,63.94 v4(15.01,65.48) 13.88,66.61 12.34,66.61 JHDMI1.6
HDMI_TX2+_CK: length 1.8
  BOTTOM w0.102: L38.1 28.76,62.66 29.06,62.95 29.52,62.95 C41.1
HDMI_TX2+_CONN: length 21.2
  TOP w0.102: RP6.7 19.31,60.6 19.45,60.74 19.84,60.74 19.95,60.84 20.28,60.84 v2(20.44,60.69)
  BOTTOM w0.102: JHDMI1.1 10.73,64.95 10.95,64.95 11.06,64.84 11.06,64.34 11.56,63.84 14.7,63.84 17.67,60.87 18.09,60.87 18.23,60.73 D29.4 D29.7 19.86,60.73 20,60.88 20.25,60.88 v2(20.44,60.69) 20.59,60.85 v4(21.69,60.85) 23.5,60.85 25.6,62.95 25.73,62.95 26.03,62.66 L38.2
HDMI_TX2-_CK: length 1.8
  BOTTOM w0.102: L38.4 28.78,63.46 29.07,63.17 29.36,63.17 C48.1
HDMI_TX2-_CONN: length 21.2
  TOP w0.102: v2(20.44,61.28) 20.22,61.06 19.86,61.06 19.75,60.96 19.44,60.96 19.3,61.1 RP6.8
  BOTTOM w0.102: JHDMI1.3 10.74,65.16 11.04,65.16 11.28,64.92 11.28,64.43 11.65,64.06 14.79,64.06 17.76,61.08 18.09,61.08 18.24,61.23 D29.5 D29.6 19.85,61.23 19.99,61.09 20.25,61.09 v2(20.44,61.28) 20.64,61.07 21.41,61.07 21.42,61.08 21.95,61.08 21.96,61.07 23.41,61.07 25.51,63.17 25.75,63.17 26.05,63.46 L38.3
HDMICLK_NB: length 139.6
  TOP w0.102: U4.R40 129.21,77.46 128.99,77.46 v2(128.8,77.65) ; RP21.4 16.38,72.9 16.24,72.76 16.24,72.66 16.35,72.55 18.3,72.55 18.96,71.9 18.96,71.33 19.18,71.1 v2(19.86,71.1)
  IN2 w0.089: v2(128.8,77.65) 128.67,77.78 128.45,77.56 128.45,76.69 128.71,76.44 129.33,76.44 130.39,75.37 130.39,74.89 130.41,74.87 130.41,74.85
  IN2 w0.127: 130.41,74.85 130.41,69.68 129.65,68.92 129.64,68.92 129.52,68.81 129.52,65.7 129.03,65.21 v2(129.03,65.03)
  BOTTOM w0.102: v2(19.86,71.1) 19.61,71.1 19.36,70.85 Q63.1 20.25,70.19 20.43,70.37 20.43,71.92 20.94,72.43 22.7,72.43 23.29,71.84 23.29,69.3 24.75,67.83 33.77,67.83 34.05,67.55 64.85,67.55 65.14,67.26 74.63,67.26 75.1,67.73 106.22,67.73 110.5,63.45 127.2,63.45 128.78,65.03 v2(129.03,65.03)
HDMICLK_R: length 18.2
  TOP w0.102: RP21.2 15.38,72.87 15.24,72.74 15.24,72.53 15.34,72.43 15.5,72.43 16.27,71.66 16.54,71.66 v2(16.76,71.89)
  IN2 w0.127: v2(19.98,72.5) 19.37,71.89 v2(16.76,71.89)
  BOTTOM w0.102: v2(19.98,72.5) 19.98,72.5 19.98,72.69 19.92,72.76 19.48,72.76 19.36,72.64 Q63.6 ; JHDMI1.15 11.03,72.25 11.03,73.64 11.66,74.28 12.9,74.28 14.22,72.96 14.22,71.81 14.32,71.72 14.46,71.72 14.6,71.85 D32.9 D32.1 16.25,71.85 16.4,71.71 16.58,71.71 16.76,71.89 v2(16.76,71.89)
HDMIDAT_NB: length 140.4
  TOP w0.102: v2(17.59,71.04) 18.43,71.04 18.73,71.35 18.73,71.8 18.21,72.32 16.25,72.32 16.01,72.56 16.01,72.78 15.88,72.91 RP21.3 ; v2(128.82,78.25) 129.01,78.06 129.21,78.06 U4.R39
  IN2 w0.089: 130.08,74.85 130.08,74.86 130.1,74.88 130.1,75.25 129.2,76.15 128.59,76.15 128.16,76.57 128.16,77.68 128.55,78.07 128.64,78.07 v2(128.82,78.25)
  IN2 w0.127: 130.08,74.85 130.08,69.82 129.52,69.25 129.5,69.25 129.19,68.95 129.19,65.83 128.8,65.44 v2(128.62,65.44)
  BOTTOM w0.102: v2(128.62,65.44) 128.62,65.19 127.1,63.68 110.6,63.68 106.32,67.95 75.01,67.95 74.54,67.48 65.24,67.48 64.94,67.78 v4(39.86,67.78) 34.14,67.78 33.87,68.06 24.85,68.06 23.52,69.39 23.52,71.93 22.79,72.65 20.73,72.65 20.4,72.98 18.3,72.98 18.06,72.74 Q63.4 18.06,71.21 17.89,71.04 v2(17.59,71.04)
HDMIDAT_R: length 16.6
  TOP w0.102: RP21.1 14.88,72.92 15.01,72.79 15.01,72.44 15.25,72.2 15.41,72.2 16.17,71.43 16.6,71.43 v2(16.76,71.27)
  BOTTOM w0.102: Q63.3 18.06,69.45 17.93,69.33 17.29,69.33 17.17,69.45 17.17,71.17 17.06,71.27 v2(16.76,71.27) 16.56,71.48 16.4,71.48 16.28,71.35 D32.2 D32.8 14.59,71.35 14.46,71.49 14.22,71.49 13.99,71.72 v4(13.99,72.03) 13.99,72.86 13.91,72.95 13.89,72.95 13.47,73.37 13.47,73.39 12.81,74.05 11.75,74.05 11.25,73.55 11.25,72.45 11.65,72.06 JHDMI1.16
HG1: length 0.8
  TOP w0.102: v1(38.39,121.09) 38.59,121.29 38.59,121.85
  vias: v4(27.53,123.25) v4(28.19,123.26) v4(37.55,121.99) v4(38.18,121.96)
HG2: length 14.7
  TOP w0.102: v4(37.57,105.59) v1(37.57,106.94)
  IN1 w1.016: 33.45,93.81 35.33,93.81 37.26,95.74 37.26,104.51
  vias: v4(32.03,93.26) v4(32.69,93.25) v4(36.91,105.59)
