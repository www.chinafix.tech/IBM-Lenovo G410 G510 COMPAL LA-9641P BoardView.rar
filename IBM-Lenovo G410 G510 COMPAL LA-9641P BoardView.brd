# Allegro board IBM-Lenovo G410 G510 COMPAL LA-9641P BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1.5VGS on TOP (solid shape): 131.64,148.57 131.64,147.74 131.48,147.57 128.96,147.57 128.67,147.86 127.59,147.86 127.58,147.87 127.57,147.94 127.54,148.01 127.54,148.43 127.57,148.46 130.5,148.46 130.71,148.68 131.54,148.68
+1.5VGS on TOP (solid shape): 129.79,140.24 130.58,140.24 130.66,140.16 130.66,139.6 130.63,139.57 130.09,139.57 129.91,139.39 129.91,138.51 130.09,138.33 130.09,136.71 129.91,136.52 129.91,136.32 129.51,135.93 129.12,135.93 128.94,136.11 128.94,140.25 129.23,140.54 129.5,140.54
+1.5VGS on TOP (solid shape): 144.46,174.88 144.46,173.8 144.16,173.5 143.48,173.5 143.03,173.83 142.5,173.66 142.25,173.41 142.25,172.56 141.59,171.89 140.43,171.89 140.21,172.11 140.21,172.71 140.28,172.78 140.53,172.78 140.54,172.78 140.85,172.78 140.85,172.78 140.9,172.78 141.34,173.23 141.34,175.09 141.41,175.15 144.19,175.15
+1.5VGS on TOP (solid shape): 115.13,137.44 115.13,136.18 114.84,135.9 113.44,135.9 113.03,135.48 112.99,135.45 112.74,135.45 112.65,135.54 112.65,136.08 112.66,136.12 112.68,136.16 112.98,136.16 113.15,136.41 113.15,136.43 113.24,136.52 113.26,136.52 113.48,137.08 112.91,136.86 112.91,136.84 112.84,136.77 112.82,136.77 112.75,136.76 112.68,136.74 112.66,136.77 112.65,136.81 112.65,137.43 112.8,137.59 114.98,137.59
+1.5VGS on TOP (solid shape): 112.88,155.33 112.92,155.28 112.97,155.25 113.04,155.17 113.44,155.17 113.51,155.24 115.83,155.24 115.96,155.12 115.96,154.41 115.86,154.36 115.77,154.29 115.64,154.16 115.52,153.97 115.48,153.76 115.48,153.51 115.34,153.37 115.34,152.66 115.13,152.45 112.78,152.45 112.55,152.68 112.55,152.87 112.67,153 112.71,153.16 112.73,153.23 112.8,153.26 112.9,153.29 112.98,153.36 113.03,153.43 113.04,153.51 113.04,153.53 113.15,153.63 113.17,153.63 113.48,153.95 113.17,154.26 113.15,154.27 113.04,154.37 113.04,154.38 112.99,154.48 112.92,154.54 112.86,154.57 112.8,154.58 112.72,154.62 112.7,154.7 112.68,154.87 112.58,155 112.55,155.02 112.55,155.16 112.72,155.33
+1.5VGS on TOP (solid shape): outline of 519 points within 121.97,110.67 137.14,125.18
+1.5VGS on TOP (solid shape): outline of 577 points within 140.15,147.86 146.91,153.63
+1.5VGS on BOTTOM (solid shape): 136.1,175.15 136.1,173.97 135.98,173.85 134.85,173.85 134.69,174.01 134.69,175.16 134.77,175.24 136.01,175.24
+1.5VGS on BOTTOM (solid shape): 118.47,174.55 118.47,172.01 117.84,171.37 117.71,171.37 116.54,172.54 115.42,172.54 115.36,172.6 115.36,174.53 115.51,174.67 118.35,174.67
+1.5VGS on BOTTOM (solid shape): 106.47,161.26 106.47,160.67 105.62,159.82 105.62,159.82 105.32,159.53 105.28,159.5 104.94,159.5 104.81,159.62 103.59,159.62 103.39,159.82 103.39,161.25 103.58,161.45 106.28,161.45
+1.5VGS on BOTTOM (solid shape): 106.47,161.26 106.47,160.67 105.79,159.99 105.77,159.97 105.32,159.53 105.28,159.5 104.94,159.5 104.81,159.62 103.59,159.62 103.39,159.82 103.39,161.25 103.58,161.45 106.28,161.45
+1.5VGS on BOTTOM (solid shape): 132.13,149.02 132.13,148.6 131.45,147.91 131.04,147.91 130.85,147.98 130.67,147.91 130.04,147.91 129.85,147.98 129.67,147.91 129.5,147.91 128.64,147.06 127.97,147.06 127.84,147.18 127.84,148.63 128,148.79 128.23,148.79 128.67,148.35 129.03,148.35 129.19,148.51 129.19,148.74 129.59,149.14 132.01,149.14
+1.5VGS on BOTTOM (solid shape): 115.08,150.5 115.08,149.88 115.32,149.65 115.32,147.95 115.33,147.93 115.38,147.72 115.5,147.54 115.58,147.46 115.58,146.82 115.4,146.65 114.16,146.65 113.99,146.81 113.99,147.83 114,147.88 114.04,147.92 114.44,147.98 114.52,148.37 114.42,148.54 114.24,148.63 114.17,148.7 114.19,148.8 114.3,148.91 114.3,150.4 114.51,150.61 114.98,150.61
+1.5VGS on BOTTOM (solid shape): 116.29,137.97 116.29,137.32 115.98,137.01 115.28,137.01 114.1,135.83 113.32,135.83 112.93,135.44 112.78,135.44 112.66,135.56 112.66,136.08 112.66,136.12 112.69,136.15 112.99,136.16 113.15,136.41 113.15,136.43 113.24,136.52 113.26,136.52 113.48,137.08 112.91,136.86 112.91,136.84 112.84,136.77 112.77,136.77 112.69,136.79 112.66,136.87 112.66,137.47 112.91,137.72 113.25,137.72 113.8,138.26 116,138.26
+1.5VGS on BOTTOM (solid shape): 115.38,155.29 115.38,155.28 115.43,155.23 115.43,153.54 115.06,153.17 115.06,152.77 114.86,152.57 113.33,152.57 112.9,153 112.9,153.29 112.94,153.31 112.98,153.35 113.01,153.38 113.03,153.44 113.04,153.51 113.04,153.53 113.15,153.63 113.17,153.63 113.44,154.1 112.89,154.12 112.7,154.12 112.58,154.25 112.58,154.49 112.61,154.52 112.66,154.57 112.68,154.63 112.7,154.69 112.71,154.76 112.71,154.78 112.74,154.81 112.76,154.81 112.86,154.82 112.96,154.86 113.04,154.95 113.09,155.05 113.09,155.07 113.17,155.15 113.4,155.15 113.48,155.1 113.56,155.08 113.64,155.06 113.72,155.05 113.98,155.05 114.09,155.06 114.2,155.1 114.3,155.15 114.38,155.22 114.58,155.42 115.25,155.42
+1.5VGS on BOTTOM (solid shape): outline of 95 points within 158.22,169.09 162.16,172.01
+1.5VGS on BOTTOM (solid shape): outline of 100 points within 127.57,171.4 133.99,175.54
+1.5VGS on VCC: 108.42,120.57 103.23,125.76 103.23,154.08 102.22,155.09 102.22,161.74 103.34,162.86 112.31,162.86 113.11,163.66 113.11,174.11 114.05,175.05 159.01,175.05 160.76,173.3 160.76,161.44 157.46,158.14 157.46,157.77 147.69,148 131.19,148 130.54,147.35 130.54,135.42 130.53,135.41 130.25,135.13 126.73,135.13 125.45,133.85 125.45,125.79 126.02,125.22 126.02,122.63 123.96,120.57
+1.5VS on TOP (solid shape): 196.76,25.58 196.76,22.43 196.6,22.27 194.55,22.27 194.27,22.55 194.27,25.44 194.55,25.71 196.62,25.71
+1.5VS on TOP (solid shape): 211.44,143.32 211.44,140.46 211.22,140.24 210.63,140.24 209.96,140.91 209.96,143.24 210.35,143.63 211.13,143.63
+1.5VS on TOP (solid shape): 119.24,104.47 119.24,103.81 118.92,103.48 118.92,102.09 118.76,101.93 118.42,101.93 118,102.35 118,104.41 118.21,104.62 119.09,104.62
+1.05VS on TOP (solid shape): 140.16,70.47 140.16,67.54 139.87,67.24 137.64,67.24 137.4,67.49 137.4,70.66 137.52,70.79 139.85,70.79
+1.05VS on TOP (solid shape): 115.84,70.13 115.84,68.96 115.78,68.89 113.42,68.89 113.31,69.01 113.31,70.06 113.42,70.18 115.79,70.18
+1.05VS on TOP (solid shape): 124.98,65.88 124.98,63.32 124.84,63.18 121,63.18 120.81,63.37 120.81,65.43 120.98,65.6 123.56,65.6 123.96,66 124.86,66
+1.05VS on TOP (solid shape): outline of 407 points within 120.22,81.97 129.29,87.48
+1.5VS on TOP (solid shape): outline of 439 points within 139.03,103.05 194.12,116.63
+1.05VS on BOTTOM (solid shape): 114.19,57.09 114.19,55.5 114.03,55.34 110.73,55.34 110.46,55.61 110.46,57.11 110.73,57.38 113.9,57.38
+1.5VS on BOTTOM (solid shape): 196.21,24.19 196.21,22.04 193.68,19.52 193.68,18.53 193.36,18.21 191.54,18.21 191.33,18.42 191.33,21.38 194.42,24.47 195.93,24.47
+1.5VS on BOTTOM (solid shape): 211.48,162.13 211.48,142.65 210.93,142.1 206.44,142.1 206.26,142.28 206.26,142.54 206.44,142.72 209.76,142.72 210.15,143.11 210.15,153.71 209.75,154.11 206.45,154.11 206.3,154.26 206.3,154.52 206.47,154.7 209.85,154.7 210.21,155.06 210.21,155.79 210.2,155.81 210.2,161.6 209.72,162.07 206.45,162.07 206.29,162.23 206.29,162.55 206.45,162.71 210.9,162.71
+1.5VS on BOTTOM (solid shape): outline of 256 points within 114.41,86.61 118.96,103.08
+1.05VS on BOTTOM (solid shape): outline of 554 points within 115.83,77.65 129.08,87.11
+1.05VS on VCC: 106.79,55.8 106.79,86.61 106.99,86.81 109.04,86.81 110.06,87.83 110.06,93.85 109.94,93.98 109.94,94.33 110.26,94.65 113.57,94.65 115.48,92.74 117.98,92.74 118.26,92.46 118.26,86.1 118.66,85.71 121.81,85.71 123.04,86.94 127.63,86.94 128.3,86.27 128.3,84.79 128.62,84.46 129.82,84.46 129.9,84.37 129.9,80.49 128.32,78.91 128.32,76.25 129.01,75.56 129.01,73.27 130.41,71.88 130.41,69.82 128.89,68.3 128.89,67.97 116.72,55.8 ; 1 cut-out
+1.5VS on VCC: 190.08,19.35 189.59,19.84 189.59,64.54 184.77,69.37 184.77,77.16 186.64,79.03 186.64,85.53 184,88.16 184,94.94 187.56,98.49 187.56,109.28 187.8,109.52 193.41,109.52 193.66,109.27 193.66,68.78 196.83,65.6 196.83,20.35 195.84,19.35
+1.5VSP on TOP (solid shape): 202.36,24.26 202.36,20.2 203.54,19.02 206.73,19.02 207.6,18.15 207.6,13.79 207.4,13.6 200.89,13.6 200.49,13.99 200.49,15.25 199.5,16.24 197.25,16.24 196.92,16.57 196.92,23.01 197.47,23.01 197.47,23.8 196.92,23.8 196.92,24.22 197.47,24.22 197.47,24.98 196.92,24.98 196.92,25.54 197.07,25.69 200.93,25.69
+1.5VSP on BOTTOM (solid shape): 203.18,21.77 203.18,19.5 203.18,19.49 203.18,16.85 203.72,16.32 207.67,16.32 208,15.98 208,13.96 207.68,13.64 200.79,13.64 200.42,14.01 200.42,15.45 197.96,17.91 197.96,24.15 198.22,24.41 200.54,24.41
+1.05VSP on BOTTOM (solid shape): outline of 101 points within 109.36,41.69 116.75,55.17
+1.8V_FB on TOP (solid shape): 115.12,174.11 115.12,172.69 115.07,172.64 113.38,172.64 113.28,172.74 113.28,174.07 113.43,174.22 115.02,174.22
+1.8V_LX on TOP (solid shape): 114.1,168.62 114.1,165.95 113.94,165.79 112.86,165.79 112.62,166.04 112.62,167.03 111.97,167.68 110.38,167.68 110.14,167.91 110.14,169.62 110.33,169.82 112.9,169.82
+1.8V_LX on BOTTOM (solid shape): 111.23,170.76 111.23,169.3 111.12,169.19 110.02,169.19 109.79,169.43 109.79,170.15 110.31,170.68 110.35,170.71 110.38,170.74 110.59,170.95 111.04,170.95
+1.8V_SNUB on TOP (solid shape): 112.07,166.34 112.07,165.35 111.88,165.16 110.1,165.16 110.09,165.16 109.95,165.19 109.81,165.16 109.81,165.16 109.47,165.16 109.46,165.16 109.35,165.17 109.25,165.16 109.2,165.16 109,165.35 109,165.82 109.01,165.83 109.01,166.26 109.27,166.52 111.89,166.52
+1.8V_VIN on TOP (solid shape): 113.05,174.2 113.05,170.36 112.76,170.07 111.07,170.07 110.91,170.23 110.91,170.5 110.99,170.58 111.44,170.58 111.47,170.6 111.47,171.92 111.43,171.96 110.98,171.96 110.93,172.01 110.93,172.49 110.08,173.34 110.08,174.25 110.28,174.46 112.79,174.46
+1.8V_VIN on BOTTOM (solid shape): 111.21,174.26 111.21,173.23 111.23,173.21 111.23,172.46 110.8,172.03 110.03,172.03 109.82,172.24 109.82,174.13 110.12,174.43 111.04,174.43
+1.8VGS on TOP (solid shape): outline of 178 points within 149.18,148.98 157.98,152.46
+1.8VGS on TOP (solid shape): 135.31,149.53 135.63,149.32 135.95,149.53 136.21,149.53 136.28,149.49 136.31,149.41 136.59,148.8 137.25,148.9 137.58,149.23 137.68,149.26 137.75,149.19 138.15,148.95 138.4,149.35 138.39,149.38 138.48,149.47 138.72,149.23 138.72,147.95 138.63,147.87 136.63,147.87 136.54,147.92 136.55,148.03 136.28,148.55 136.01,148.03 136.02,147.92 135.93,147.87 135.77,147.87 135.68,147.92 135.67,148.01 135.33,148.48 135.12,147.94 135.14,147.87 135.11,147.8 135.02,147.72 134.58,147.72 133.72,148.57 133.55,148.57 133.55,149.39 133.59,149.43 134.01,149.43 134.41,149.23 134.83,149.4 134.96,149.53
+1.8VGS on BOTTOM (solid shape): 116.34,164.83 116.34,164.02 116.13,163.81 113.59,163.81 113.3,164.1 113.3,164.73 113.43,164.85 116.31,164.85
+1.8VGS on IN1 (solid shape): 158.16,152.97 158.16,151.46 157.94,151.24 156.97,151.24 156.76,151.45 156.76,152.78 157.11,153.13 158,153.13
+1.8VGS on IN1 (solid shape): 116.49,165.21 116.49,164.44 115.9,163.85 114.33,163.85 114.15,164.03 114.15,164.7 114.42,164.97 115.04,164.97 115.51,165.44 116.26,165.44
+1.8VGS on IN1 (solid shape): outline of 876 points within 137.03,148.12 151.02,150.85
+1.8VGSP on TOP (solid shape): 116.38,168.58 116.38,165.92 116.25,165.78 114.57,165.78 114.38,165.97 114.38,168.42 114.64,168.68 116.28,168.68
+1.8VGSP on BOTTOM (solid shape): 116.31,168.64 116.31,165.07 116.29,165.04 115.86,165.04 115.83,165.07 115.83,165.54 115.78,165.6 113.93,165.6 113.85,165.52 113.85,165.15 113.73,165.03 113.27,165.03 112.68,164.44 111.4,164.44 111.01,164.83 111.01,168.53 111.23,168.75 116.2,168.75
+1.35V on TOP (solid shape): 32.46,62.05 32.46,60.11 32.38,60.03 31.69,60.03 31.63,60.09 31.63,62.04 31.72,62.13 32.38,62.13
+1.35V on TOP (solid shape): outline of 8356 points within 47.35,22.96 84.43,63.58
+1.35V_CPU_VDDQ on TOP (solid shape): outline of 8464 points within 47.76,62.38 86.8,92.89
+1.35V_CPU_VDDQ on BOTTOM (solid shape): 78.91,92 78.91,91 78.6,90.69 77.59,90.69 77.4,90.51 77.39,90.51 76.59,89.7 76.38,89.7 75.74,90.35 74.28,90.35 74.09,90.15 74.09,89.77 74.28,89.58 74.28,89.33 74.15,89.2 73.9,89.2 72.73,90.37 71.33,90.37 71.12,90.17 71.12,89.81 71.32,89.62 71.32,89.37 71.19,89.25 70.85,89.25 70.78,89.31 70.78,89.31 69.76,90.33 68.37,90.33 67.73,89.69 67.31,89.69 66.66,90.35 65.33,90.35 64.69,89.7 64.38,89.7 63.67,90.41 62.39,90.41 61.7,89.72 61.38,89.72 60.69,90.41 59.35,90.41 58.78,89.84 58.78,89.77 58.72,89.71 58.26,89.71 57.59,90.38 57.59,92.14 57.89,92.44 78.47,92.44
+1.35VP on TOP (solid shape): 38.69,10.23 38.69,9.13 38.53,8.97 37.83,8.97 37.71,9.09 37.71,10.23 37.84,10.36 38.55,10.36
+1.35VP on TOP (solid shape): 64.55,22.65 64.55,15.4 59.44,10.3 57.66,10.3 53.26,5.89 53.26,4.97 52.98,4.69 47.8,4.69 47.1,5.39 47.1,16.99 54.4,16.99 54.4,14.44 54.83,14.01 56.76,14.01 58.59,15.85 58.59,16.93 57.95,17.57 54.98,17.57 54.4,16.99 47.1,16.99 47.1,22.4 47.5,22.8 55.29,22.8 55.29,22.29 55.99,22.29 55.99,22.8 56.49,22.8 56.49,22.29 57.19,22.29 57.19,22.8 60.56,22.8 60.61,22.75 60.61,22.28 60.62,22.26 62.56,22.26 62.59,22.29 62.59,22.74 62.66,22.81 64.39,22.81
+3V_HDD on BOTTOM (solid shape): 160,125.31 160,120.22 159.83,120.05 156.72,120.05 156.45,120.32 156.45,123.04 156.99,123.57 157.94,123.57 157.94,123.52 157.95,123.47 157.97,123.42 157.99,123.37 158.02,123.33 158.06,123.29 158.1,123.25 158.15,123.23 158.19,123.21 158.25,123.19 158.3,123.19 158.35,123.19 158.41,123.21 158.46,123.23 158.5,123.25 158.54,123.29 158.58,123.33 158.61,123.37 158.63,123.42 158.65,123.47 158.66,123.52 158.66,123.57 158.65,123.63 158.63,123.68 158.61,123.73 158.58,123.77 158.54,123.81 158.5,123.84 158.46,123.87 158.41,123.89 158.35,123.9 158.3,123.9 158.25,123.9 158.19,123.89 158.15,123.87 158.1,123.84 158.06,123.81 158.02,123.77 157.99,123.73 157.97,123.68 157.95,123.63 157.94,123.57 156.99,123.57 157.53,124.12 157.53,125.55 157.65,125.66 159.64,125.66
+3V_LAN on TOP (solid shape): 31.47,31.95 31.47,30.98 31.29,30.81 30.17,30.81 29.95,31.04 29.95,31.9 30.03,31.99 31.42,31.99
+3V_LAN on TOP (solid shape): 39.4,26.49 39.97,26.49 40.1,26.35 40.1,26.1 40.24,25.96 40.75,25.96 40.94,26.15 40.94,26.34 41,26.4 41.57,26.4 41.64,26.34 41.64,25.77 41.45,25.58 41.44,25.58 40.91,25.04 40.91,23.07 41.3,22.67 46.27,22.67 46.59,22.36 46.59,20.58 46.49,20.48 46.16,20.48 46.11,20.54 46.11,21.02 46.09,21.05 44.78,21.05 44.75,21.02 44.75,20.55 44.69,20.48 39.95,20.48 39.83,20.61 39.83,24.15 39.66,24.33 35.38,24.33 34.56,25.14 33.92,25.14 33.87,25.2 33.87,25.31 33.93,25.38 34.85,25.38 35.09,25.13 37.83,25.13 37.96,25.26 37.96,26.72 38.03,26.79 39.09,26.79
+3V_LAN on IN1 (solid shape): 31.29,31.1 31.29,29.83 30.97,29.51 30.27,29.51 30.02,29.77 30.02,31.23 30.14,31.35 31.03,31.35
+3V_LAN on IN1 (solid shape): 39.22,27.04 39.22,25.64 38.97,25.38 38.21,25.38 37.38,26.21 37.38,27.1 37.64,27.35 38.91,27.35
+3V_PCH on TOP (solid shape): 91.84,90.98 91.84,90.75 92.34,90.24 94.57,90.24 94.67,90.14 94.67,88.71 94.5,88.54 92.65,88.54 92.39,88.8 92.39,88.82 92.39,89.14 91.9,89.64 91.89,89.64 91.38,90.15 89.58,90.15 89.44,90.29 89.44,90.69 89.81,91.06 91.76,91.06
+3V_PCH on TOP (solid shape): 127.74,100.34 127.74,100.08 127.68,99.88 127.74,99.69 127.74,99.46 127.59,99.31 126.85,99.31 126.7,99.47 126.7,99.57 126.52,99.74 126.04,99.74 125.97,99.82 125.97,100.34 126.03,100.4 127.68,100.4
+3V_PCH on TOP (solid shape): 131.48,101.29 131.48,100.16 131.35,100.04 130.65,100.04 130.51,99.89 130.46,99.85 130.4,99.78 130.12,99.78 130.07,99.83 130.07,100.12 130.08,100.13 130.11,100.24 130.11,100.36 130.11,100.37 130.11,101.32 130.25,101.46 131.31,101.46
+3V_PCH on TOP (solid shape): 145.84,97.71 145.85,97.71 146.85,97.71 146.98,97.71 147.24,97.97 147.87,97.97 148,97.84 148,97.39 147.87,97.27 146.28,97.27 146.03,97.37 145.78,97.27 145.52,97.27 145.21,97.58 144.7,97.58 144.57,97.71 144.57,97.97 144.7,98.09 145.46,98.09
+3V_PCH on TOP (solid shape): 129.29,86.32 129.29,86.06 129.26,86.05 129.08,85.76 129.26,85.47 129.29,85.46 129.29,85.25 129.12,84.97 129.29,84.68 129.29,83.62 129.27,83.61 129.11,83.33 129.27,83.06 129.29,83.05 129.29,82.84 129.19,82.74 129.06,82.74 128.44,83.36 128.44,83.38 128.39,83.5 128.3,83.6 128.3,83.95 128.3,83.95 128.3,84 128.74,84.44 128.74,84.66 128.56,84.84 128.56,85.05 128.73,85.23 128.73,85.5 128.55,85.68 128.55,85.85 128.78,86.07 128.78,86.29 128.88,86.4 129.22,86.4
+3V_PCH on TOP (solid shape): outline of 102 points within 143.49,86.78 148.05,94.28
+3V_PCH on BOTTOM (solid shape): 144.5,74.04 144.5,73.56 143.94,73.01 143.72,73.01 143.48,73.25 143.48,73.82 143.81,74.15 144.38,74.15
+3V_PCH on BOTTOM (solid shape): 129.18,86.66 129.18,85.99 129.08,85.76 129.18,85.53 129.18,85.35 129.05,85.22 129.05,84.75 128.89,84.59 128.89,84.09 128.78,83.97 128.3,83.97 128.21,84.06 128.21,84.89 128.51,85.19 128.51,86.67 128.59,86.75 129.09,86.75
+3V_PCH on BOTTOM (solid shape): 126.44,82.05 126.44,81.32 126.27,81.15 125.13,81.15 124.99,81.29 124.06,81.29 123.9,81.45 123.9,81.74 125.14,81.74 125.14,81.69 125.15,81.64 125.16,81.59 125.18,81.55 125.21,81.51 125.25,81.47 125.29,81.44 125.33,81.42 125.38,81.4 125.43,81.4 125.48,81.4 125.53,81.4 125.58,81.42 125.62,81.44 125.66,81.47 125.7,81.51 125.73,81.55 125.75,81.59 125.77,81.64 125.77,81.69 125.77,81.74 125.77,81.79 125.75,81.84 125.73,81.88 125.7,81.92 125.66,81.96 125.62,81.99 125.58,82.01 125.53,82.02 125.48,82.03 125.43,82.03 125.38,82.02 125.33,82.01 125.29,81.99 125.25,81.96 125.21,81.92 125.18,81.88 125.16,81.84 125.15,81.79 125.14,81.74 123.9,81.74 123.9,81.85 124.09,82.04 124.84,82.04 124.99,82.18 124.99,82.73 125.1,82.84 125.66,82.84
+3V_PCH on BOTTOM (solid shape): outline of 193 points within 123.6,96.72 133.13,100.66
+3V_PCH on IN1 (solid shape): 136.03,83.93 136.12,83.88 136.12,83.79 136.27,83.36 136.7,83.51 138.26,83.51 138.48,83.3 138.48,82.92 138.28,82.73 137.18,82.73 137,82.78 136.82,82.73 136.13,82.73 135.43,83.42 135.43,83.8 135.55,83.93
+3V_PCH on IN2 (solid shape): outline of 411 points within 123.74,81.02 129.39,86.21
+3V_PCH on VCC: 139.66,82.6 138.92,83.34 138.92,83.54 137.19,85.27 134.42,85.27 133.87,84.71 128.73,84.71 128.55,84.89 128.55,86.63 128.2,86.99 128.2,88.08 128.58,88.46 128.58,97.12 126.69,99 126.69,99.86 127.47,100.63 131.19,100.63 131.96,99.87 144.53,99.87 145.27,99.13 145.27,85.37 142.5,82.6
+3V_ROM on TOP (solid shape): 136.1,63.84 136.1,63.48 135.54,63.48 135.54,62.98 136.1,62.98 136.1,61.1 135.54,61.1 135.54,60.59 136.1,60.59 136.1,60.26 136,60.16 133.98,60.16 133.66,60.47 133.66,63.68 133.92,63.93 136.01,63.93
+3VALW on TOP (solid shape): 110.76,172.32 110.76,170.18 110.69,170.1 109.97,170.1 109.77,170.3 109.77,172.26 109.92,172.41 110.67,172.41
+3VALW on TOP (solid shape): 137.22,61.41 137.22,60.27 137.14,60.2 136.32,60.2 136.27,60.25 136.27,61.44 136.32,61.49 137.14,61.49
+3VALW on TOP (solid shape): 174.52,128.05 174.52,127.76 174.36,127.6 173.53,127.6 173.53,127.92 172.48,127.92 172.48,128 172.48,128 172.48,128.21 172.52,128.25 174.31,128.25
+3VALW on TOP (solid shape): 101.45,123.25 102.32,123.25 102.51,123.06 102.51,122.76 102.3,122.55 101.49,122.55 101.23,122.3 100.16,122.3 100.01,122.44 100.01,123.33 100.15,123.47 101.23,123.47
+3VALW on TOP (solid shape): 46.58,20.19 46.58,16.73 46.2,16.34 43.86,16.34 43.42,16.78 43.42,17.63 42.58,18.47 42.16,18.47 41.85,18.79 41.85,19.94 42.24,20.34 46.43,20.34
+3VALW on TOP (solid shape): 89.83,16.36 89.83,13.58 89.62,13.36 88.67,13.36 88.62,13.42 88.62,13.9 88.56,13.96 86.68,13.96 86.64,13.92 86.64,13.45 86.55,13.36 84.33,13.36 83.31,12.34 78.24,12.34 77.56,13.01 77.56,15.49 78.01,15.94 84.85,15.94 85.61,16.7 89.5,16.7
+3VALW on TOP (solid shape): 154.96,94.07 156.37,94.07 156.78,93.66 156.78,93.27 156.52,93.01 152.9,93.01 151.5,91.61 151.5,90.79 149.8,89.1 148.71,89.1 148.53,88.92 148.34,88.92 148.22,89.04 148.22,92.47 148.32,92.57 148.7,92.57 148.72,92.59 148.73,92.6 148.75,92.62 148.75,93.88 148.71,93.93 148.28,93.93 148.22,93.99 148.22,94.44 148.36,94.58 154.45,94.58
+3VALW on BOTTOM (solid shape): 96.27,119.9 96.27,118.27 96.08,118.08 94.38,118.08 94.17,118.3 94.17,119.94 94.37,120.14 96.02,120.14
+3VALW on BOTTOM (solid shape): 142.89,97.25 142.37,97.25 142.2,97.43 142.2,98.24 141.76,98.68 141.76,99.29 141.87,99.39 142.89,99.39
+3VALW on BOTTOM (solid shape): 140.15,111.27 140.15,110.42 139.89,110.16 138.47,110.16 138.28,110.34 138.28,111.38 138.43,111.53 139.89,111.53
+3VALW on BOTTOM (solid shape): 195.4,12.24 195.4,11.37 195.67,11.1 197.39,11.1 197.44,11.04 197.44,10.85 197.41,10.82 194.48,10.82 194.28,11.01 194.28,12.26 194.54,12.51 195.14,12.51
+3VALW on BOTTOM (solid shape): 100.64,123.53 100.64,122.57 100.33,122.26 100.04,122.26 100.03,122.26 99.9,122.28 99.77,122.26 99.77,122.26 99.14,122.26 98.94,122.46 98.94,123.52 99.16,123.74 100.43,123.74
+3VALW on IN1 (solid shape): 95.69,118.59 95.69,117.58 95.52,117.41 93.37,117.41 93.18,117.59 93.18,118.55 93.42,118.79 95.5,118.79
+3VALW on IN1 (solid shape): 144.25,98.13 144.25,96.89 144,96.63 142.51,96.63 142.26,96.89 142.26,98.27 142.4,98.41 143.97,98.41
+3VALW on IN1 (solid shape): 156.8,93.98 156.8,93.04 156.67,92.9 154.97,92.9 154.79,93.08 154.79,94 154.95,94.16 156.62,94.16
+3VALW on IN1 (solid shape): 110.56,171.81 110.56,170.04 110.42,169.9 109.39,169.9 109.27,170.02 109.27,170.15 109.26,170.16 109.26,171.79 109.44,171.97 110.4,171.97
+3VALW on IN1 (solid shape): 138.89,111.38 138.89,110.65 138.88,110.64 138.88,110.44 138.67,110.22 136.94,110.22 136.71,110.45 136.71,111.35 136.94,111.58 138.69,111.58
+3VALW on IN1 (solid shape): 101.08,124.38 101.08,122.51 100.81,122.24 99.99,122.24 99.9,122.26 99.77,122.24 99.58,122.43 99.58,124.3 99.78,124.5 100.96,124.5
+3VALW on IN2 (solid shape): 88.18,16.34 88.18,15.2 87.97,14.98 86.22,14.98 85.94,15.26 85.94,16.27 86.21,16.54 87.98,16.54
+3VALW on IN2 (solid shape): 46.83,17.45 46.83,16.65 46.67,16.49 44.33,16.49 44.06,16.75 44.06,17.45 44.26,17.64 46.64,17.64
+3VALW on VCC: 87.46,13.64 87.23,13.87 87.23,15.82 87.97,16.56 96.24,16.56 108.57,28.89 108.57,30.93 109.05,31.42 118.07,31.42 118.86,32.2 118.86,47.08 133.42,61.64 137.74,61.64 138.62,62.52 138.62,64.71 138.72,64.82 141.11,64.82 142.92,66.63 153.03,66.63 155.43,69.03 155.43,93.54 156.23,94.35 161.99,94.35 162.8,93.54 162.8,67.84 156.47,61.52 150.88,61.52 150.22,60.86 150.22,58.57 149.99,58.34 141.74,58.34 140.74,57.34 135.38,57.34 130.66,52.63 130.66,49.06 129.29,47.69 125.6,47.69 122.28,44.37 122.28,30.77 117.33,25.82 117.33,20.89 117.24,20.8 106.47,20.8 99.31,13.64
+3VALW_EC on TOP (solid shape): 158.13,92.54 158.13,92.11 157.83,91.81 157.02,91.81 156.86,91.9 156.67,91.89 156.35,91.89 156.13,92.11 156.13,92.61 156.34,92.81 157.86,92.81
+3VALWP on TOP (solid shape): 90.96,12.68 90.96,9.11 90.47,8.63 79.03,8.63 78.22,7.82 78.22,6.7 77.87,6.34 75.54,6.34 74.99,6.9 74.99,11.41 75.5,11.91 83.39,11.91 84.68,13.21 90.43,13.21
+3VGS on TOP (solid shape): 150.29,128.7 150.29,124.33 150.43,124.19 151.2,124.19 151.26,124.17 151.31,124.16 151.33,124.14 151.33,123.07 151.17,122.91 150.09,122.91 149.89,123.11 149.89,127.7 149.49,128.1 149.49,128.72 149.58,128.81 150.17,128.81
+3VGS on TOP (solid shape): 133.57,124.9 133.59,124.84 133.59,124.61 132.44,123.47 132.44,122.93 132.23,122.72 130.69,122.72 130.54,122.87 130.54,123.71 130.66,123.83 131.51,123.83 131.78,124.1 131.78,124.46 132.24,124.91 132.25,124.91 132.48,125.14 133.33,125.14
+3VGS on TOP (solid shape): 150.49,119.31 150.52,119.29 150.57,119.27 151.11,118.73 155.9,118.73 155.96,118.67 155.96,117.88 155.89,117.8 151.43,117.8 150.74,117.12 149.21,117.12 149,117.32 149,117.93 149.22,118.15 149.23,118.15 149.68,118.6 149.68,119.07 149.93,119.31
+3VGS on TOP (solid shape): 148.56,137.36 148.65,137.37 150.73,137.37 150.85,137.26 150.85,136.34 150.64,136.14 143.35,136.14 143.29,136.2 143.29,136.65 143.34,136.7 143.89,136.7 144.15,136.96 144.6,136.96 144.61,136.95 144.76,136.92 144.91,136.95 144.95,136.95 144.98,136.93 145.27,136.75 145.56,136.93 145.58,136.96 147.73,136.96 148.14,137.37 148.47,137.37
+3VGS on BOTTOM (solid shape): 184.58,133.52 184.88,133.3 185.21,133.48 185.22,133.48 185.29,133.56 186.71,133.56 186.8,133.5 186.79,133.4 186.85,132.93 187.32,132.93 187.34,132.94 187.4,132.94 187.64,133.18 188.05,133.18 188.23,133.01 188.23,132.66 187.94,132.37 183.86,132.37 183.8,132.43 182.66,132.43 182.09,133 181.17,133 180.77,132.61 180.43,132.61 180.29,132.75 180.29,133.23 180.51,133.45 180.66,133.45 180.86,133.44 181.04,133.56 184.57,133.56
+3VLP on TOP (solid shape): 168.52,72.85 168.52,66.1 168.38,65.96 167.88,65.96 167.71,66.13 167.71,72.6 167.77,72.66 167.77,72.95 167.82,73 168.37,73
+3VLP on TOP (solid shape): 65.44,6.96 65.44,5.71 65.68,5.47 65.68,5.2 65.55,5.07 65.33,5.07 65.17,5.23 65.17,6.99 65.22,7.05 65.35,7.05
+3VS on TOP (solid shape): 17.56,74.94 17.56,74.12 17.32,73.89 15.87,73.89 15.71,74.04 15.71,74.89 15.86,75.04 17.45,75.04
+3VS on TOP (solid shape): 137.33,63.83 137.33,62.74 137.26,62.66 136.3,62.66 136.27,62.7 136.27,63.85 136.33,63.92 137.24,63.92
+3VS on TOP (solid shape): 190.21,131.35 190.21,130.15 189.65,129.59 188.26,129.59 187.91,129.94 187.91,130.67 188.9,131.66 189.9,131.66
+3VS on TOP (solid shape): 202.68,168.52 202.68,166.47 202.51,166.29 201.63,166.29 201.48,166.44 201.48,168.48 201.59,168.59 202.62,168.59
+3VS on TOP (solid shape): 85.78,21.33 85.78,17.23 85.74,17.19 85.73,17.19 84.77,16.22 80.92,16.22 80.67,16.47 80.67,21.09 81.37,21.79 85.32,21.79
+3VS on TOP (solid shape): 149.81,121.05 149.81,119.74 149.54,119.47 149.54,118.73 149.37,118.56 148.67,118.56 148.47,118.76 148.47,121.11 148.69,121.33 149.52,121.33
+3VS on TOP (solid shape): 203.69,22.91 204.32,22.91 204.4,22.82 204.4,22.69 204.23,22.52 202.79,22.52 202.65,22.65 202.65,23.49 202.77,23.61 202.98,23.61
+3VS on TOP (solid shape): 174.51,57.01 182.15,57.01 182.33,56.83 182.33,55.92 182.22,55.81 173.49,55.81 172.57,56.73 172.57,57.48 172.79,57.69 173.83,57.69
+3VS on TOP (solid shape): 98.36,60.73 98.36,60.43 98.18,60.25 97.8,60.25 97.63,60.08 97.63,59.28 97.39,59.04 95.93,59.04 95.8,59.17 95.8,59.93 95.93,60.06 95.93,60.75 96.05,60.88 98.21,60.88
+3VS on TOP (solid shape): 154.82,55.45 154.82,54.4 154.43,54.01 154.43,52.89 154.35,52.82 153.86,52.82 153.68,53 153.68,54.8 153.64,54.84 153.64,55.51 153.75,55.62 154.65,55.62
+3VS on TOP (solid shape): 149.08,98.33 149.08,97.33 148.95,97.2 148.32,97.2 148.19,97.33 148.19,97.9 147.87,98.22 147.17,98.22 146.79,97.84 145.9,97.84 145.46,98.28 144.51,98.28 144.18,97.96 144.18,94.26 144.06,94.13 143.9,94.13 143.78,94.25 143.78,98.7 144.06,98.98 148.42,98.98
+3VS on TOP (solid shape): 125.45,89.21 125.45,89.19 125.49,89.07 125.59,88.99 125.65,88.92 125.62,88.83 125.08,88.28 125.08,88.12 124.91,87.95 124.74,87.95 124.57,88.13 124.57,88.32 124.32,88.56 124.32,89.24 124.46,89.38 125.28,89.38
+3VS on TOP (solid shape): 95.93,48.32 95.93,47.34 96.44,46.83 96.44,46.41 96.27,46.24 95.97,46.24 95.78,46.43 95.07,46.43 94.96,46.54 94.99,46.57 95.09,46.85 94.96,47.1 94.94,47.12 94.94,47.15 94.79,47.3 93.4,47.3 93.17,47.53 93.17,48.28 93.39,48.5 95.75,48.5
+3VS on TOP (solid shape): 143.24,80.4 143.24,79.7 143.22,79.6 143.24,79.5 143.24,77.34 142.58,76.68 141.5,76.68 141.32,76.86 141.32,78.22 141.36,78.23 141.64,78.58 141.36,78.93 141.32,78.94 141.32,80.48 141.47,80.63 143.01,80.63
+3VS on TOP (solid shape): 200.48,144 200.48,142.93 199.43,141.87 199.43,139.3 198.76,138.63 196.62,138.63 196.14,139.11 196.14,141.09 197.5,142.44 197.5,142.44 197.85,142.67 197.75,143.08 197.75,143.37 197.83,143.52 197.82,143.7 197.82,143.91 198.41,144.5 199.98,144.5
+3VS on TOP (solid shape): outline of 121 points within 138.22,84.65 141.64,89.85
+3VS on BOTTOM (solid shape): 156.82,125.5 156.82,123.77 156.6,123.56 155.62,123.56 155.19,123.99 155.19,125.5 155.28,125.59 156.72,125.59
+3VS on BOTTOM (solid shape): 90.48,133.57 90.48,132.66 90.14,132.32 88.99,132.32 88.99,132.57 87.72,132.57 87.72,132.32 87.61,132.32 87.55,132.38 87.55,133.67 87.64,133.77 90.27,133.77
+3VS on BOTTOM (solid shape): 125.44,89.26 125.44,88.66 125.14,88.37 125.14,88.08 125.01,87.95 124.73,87.95 124.59,88.09 124.59,88.41 124.19,88.82 124.19,89.26 124.25,89.33 124.8,89.33 124.87,89.39 125.31,89.39
+3VS on BOTTOM (solid shape): 120.1,95.92 120.1,94.81 120.35,94.56 121.19,94.56 121.28,94.47 121.28,93.98 121.19,93.89 119.42,93.89 119.41,93.9 118.89,93.9 118.79,94 118.79,95.59 119.42,96.21 119.8,96.21
+3VS on BOTTOM (solid shape): 145.65,77.2 145.65,74.72 145.28,74.34 143.87,74.34 143.75,74.47 143.75,75.04 143.81,75.11 144.57,75.11 144.76,75.3 144.76,76.25 144.32,76.69 142.22,76.69 142.03,76.88 142.03,78.22 142.17,78.36 144.5,78.36
+3VS on BOTTOM (solid shape): 140.37,76.26 140.37,73.26 140.49,73.14 140.73,73.14 140.77,73.13 140.95,72.95 140.95,72.69 140.82,72.57 140,72.57 139.85,72.71 139.85,73.15 139.97,73.27 139.97,76.26 140.09,76.39 140.24,76.39
+3VS on BOTTOM (solid shape): 99.55,143.94 99.55,142.7 99.2,142.35 99.2,140.93 99.76,140.38 99.76,139.14 99.53,138.91 98.68,138.91 98.43,139.16 98.43,142.21 98.43,142.21 98.43,142.4 97.62,143.21 96.98,143.21 96.38,142.61 94.01,142.61 93.85,142.77 93.85,143.2 93.86,143.2 93.86,143.63 94.26,144.03 99.46,144.03
+3VS on BOTTOM (solid shape): outline of 144 points within 84.99,138.98 89.75,147.22
+3VS on BOTTOM (solid shape): outline of 250 points within 128.55,81.49 136.62,85.1
+3VS on IN1 (solid shape): 199.04,142.2 199.04,140.43 198.9,140.29 197.57,140.29 197.36,140.5 197.36,142.19 197.57,142.39 198.84,142.39
+3VS on IN1 (solid shape): 202.5,168.18 202.5,165.9 202.24,165.64 202.24,165.08 201.99,164.83 200.9,164.83 200.62,165.11 200.62,168.05 201.09,168.51 202.17,168.51
+3VS on IN1 (solid shape): 89.19,144.34 89.18,144.33 89.47,143.82 89.84,144.28 89.86,144.37 89.94,144.41 94.67,144.41 95.1,143.97 95.1,142.9 94.78,142.58 93.11,142.58 92.28,141.75 92.28,133.41 91.17,132.3 89.1,132.3 88.47,132.93 88.47,139.36 88.5,139.43 88.58,139.46 89.4,140.26 88.58,141.06 88.5,141.09 88.47,141.16 88.47,143.78 89.1,144.41 89.19,144.41
+3VS on IN2 (solid shape): 182.37,56.82 182.37,55.88 182.25,55.76 180.89,55.76 180.77,55.89 180.77,56.8 180.91,56.94 182.25,56.94
+3VS on IN2 (solid shape): 203.41,24.55 203.41,22.64 203.29,22.51 202.52,22.51 202.39,22.65 202.39,24.54 202.5,24.65 203.31,24.65
+3VS on VCC: outline of 188 points within 17.89,16.18 189.59,145.13
+3VS_CMOS on BOTTOM (solid shape): 98.05,142.49 98.05,141.84 97.92,141.71 93.98,141.71 93.72,141.98 93.72,142.23 93.72,142.24 93.72,142.32 93.87,142.47 96.49,142.47 97.05,143.02 97.52,143.02
+3VS_PS on BOTTOM (solid shape): outline of 111 points within 83.64,128.07 89.2,134.27
+3VS_TS on TOP (solid shape): 206.53,142.42 206.53,141.41 206.2,141.08 202.23,141.08 201.35,140.19 201.35,139.43 201.22,139.3 199.82,139.3 199.75,139.37 199.75,141.72 200.66,142.63 206.32,142.63
+3VS_WLAN on TOP (solid shape): 204.64,168.39 204.64,167.69 204.9,167.43 207.74,167.43 208.33,166.84 208.33,164.45 208.13,164.26 205.02,164.26 202.84,166.44 202.84,166.76 202.88,166.79 203.38,166.79 203.4,166.81 203.4,168.14 203.39,168.16 202.87,168.16 202.84,168.19 202.84,168.66 202.89,168.7 204.32,168.7
+3VS_WLAN on BOTTOM (solid shape): 206.88,165.02 208.2,165.02 208.45,164.77 208.45,163.94 208.15,163.64 204.82,163.64 204.52,163.94 204.52,164.64 204.91,165.03 206.85,165.03
+3VS_WLAN on BOTTOM (solid shape): 202.1,160.58 202.1,159.75 200.84,158.49 198.27,158.49 198.07,158.68 198.07,159.76 198.2,159.89 200.17,159.89 200.49,160.21 200.51,160.21 200.51,160.64 200.96,161.08 201.59,161.08
+3VS_WLAN on BOTTOM (solid shape): 206.17,153.54 206.17,153.54 206.17,153.37 206.42,153.12 208.12,153.12 208.3,152.94 208.3,152.67 208.13,152.49 206.49,152.49 206.3,152.31 206.26,152.26 206.03,152.03 205.51,152.03 205.4,152.15 205.4,153.59 205.57,153.76 205.95,153.76
+3VS_WLAN on BOTTOM (solid shape): 208.33,140.97 208.33,140.27 208.27,140.18 208.16,140.19 207.59,139.91 208.16,139.63 208.27,139.64 208.33,139.55 208.33,138.93 208,138.61 206.58,138.61 206.2,138.99 206.2,140.9 206.39,141.09 208.2,141.09
+3VS_WLAN on IN1 (solid shape): 208.39,164.77 208.39,162.61 207.82,162.04 206.61,162.04 206.04,162.61 206.04,164.77 206.48,165.21 207.94,165.21
+3VS_WLAN on IN1 (solid shape): 207.86,154.56 207.86,151.31 207.87,151.3 207.87,150.99 207.55,150.67 205.79,150.67 205.42,151.03 205.42,154.26 205.43,154.27 205.43,154.57 205.66,154.8 207.63,154.8
+3VS_WLAN on IN1 (solid shape): 208.26,141.72 208.26,140.31 208.21,140.23 208.11,140.23 207.59,139.91 208.11,139.6 208.21,139.6 208.26,139.51 208.26,138.86 208.01,138.61 206.55,138.61 206.3,138.85 206.3,141.86 206.52,142.08 206.52,142.11 207.87,142.11
+5V_DISPLAY on TOP (solid shape): 25.78,75.26 25.78,74.52 25.61,74.36 23.7,74.36 23.54,74.52 23.54,75.26 23.68,75.4 25.64,75.4
+5V_DISPLAY on TOP (solid shape): 28.92,85.06 28.92,84.33 28.69,84.1 27.67,84.1 26.45,85.32 26.45,86.26 26.69,86.49 27.5,86.49
+5V_DISPLAY on TOP (solid shape): 13.37,121.61 13.37,120.56 12.94,120.13 10.26,120.13 9.43,119.3 5.67,119.3 5.6,119.37 5.6,120.17 5.72,120.29 8.71,120.29 10.47,122.04 12.93,122.04
+5V_DISPLAY on TOP (solid shape): 15.54,74.83 15.54,74.04 15.47,73.96 14.52,73.96 14.21,73.65 14.21,72.37 14.71,71.87 14.71,69.79 14.53,69.6 13.78,69.6 13.63,69.75 13.63,71.68 12.66,72.65 11.9,72.65 11.64,72.91 11.64,73.56 11.97,73.9 12.11,73.9 13.23,75.01 15.36,75.01
+5V_DISPLAY on IN2 (solid shape): 13.36,121.49 13.36,120.33 13.19,120.17 12.01,120.17 11.79,120.39 11.79,121.48 12.07,121.76 13.08,121.76
+5V_DISPLAY on IN2 (solid shape): 24.8,75.17 24.8,74.55 24.56,74.31 22.87,74.31 22.71,74.48 22.71,75.24 22.88,75.4 24.56,75.4
+5V_DISPLAY on IN2 (solid shape): 27.98,86.39 27.98,85.84 27.82,85.69 26.59,85.69 26.09,86.19 26.09,86.81 26.33,87.06 27.31,87.06
+5V_DISPLAY on IN2 (solid shape): 15.57,74.96 15.57,74.17 15.31,73.91 13.46,73.91 13.16,74.22 13.16,74.79 13.46,75.09 15.44,75.09
+5V_HDD on TOP (solid shape): 166.1,121.9 166.1,117.28 166.05,117.27 165.86,117.18 165.75,116.99 165.74,116.95 164.26,116.95 164.07,117.14 164.07,122.1 164.26,122.29 165.72,122.29
+5V_HDD on BOTTOM (solid shape): 167.62,122.16 167.62,118.98 167.37,118.73 164.32,118.73 164.13,118.92 164.13,122.29 164.32,122.48 167.3,122.48
+5V_ODD on TOP (solid shape): 185.71,55.4 185.71,54.28 185.25,53.82 183.25,53.82 183.13,53.94 183.13,55.3 183.35,55.52 185.59,55.52
+5V_ODD on BOTTOM (solid shape): 200.19,59.61 200.55,59.3 201.02,59.32 201.06,59.34 201.29,59.1 201.29,57.58 199.82,57.58 199.77,57.53 199.75,57.53 199.31,57.35 199.12,56.91 199.12,56.89 197.28,55.04 193.25,55.04 193.25,55.05 193,55.05 193,55.05 193,55.6 191.87,55.6 191.84,55.57 191.66,55.57 191.66,55.04 191.3,55.04 191.27,55.08 191.27,56.46 191.45,56.64 192.48,56.64 192.48,56.64 192.53,56.64 195.19,59.29 198.93,59.29 199.24,59.61
+5V_ODD on IN1 (solid shape): 195.63,57.67 195.63,56.38 195.29,56.04 187.13,56.04 185.26,54.17 184.57,54.17 184.16,54.58 184.16,55.5 186.58,57.92 195.38,57.92
+5VALW on TOP (solid shape): 182.77,50.83 182.77,50.02 182.54,49.79 181.88,49.79 181.76,49.9 180.29,49.9 180.07,50.12 180.07,50.92 180.18,51.03 182.57,51.03
+5VALW on TOP (solid shape): 20.8,29.65 20.8,26.97 20.47,26.65 17.86,26.65 17.59,26.92 17.59,27.65 17.77,27.83 19.53,27.83 19.74,28.04 19.74,29.63 19.88,29.78 20.67,29.78
+5VALW on TOP (solid shape): 105.4,36.08 105.4,35.1 104.3,33.99 104.3,33.53 104.21,33.44 104.09,33.44 104.02,33.51 104.02,34.44 104.26,34.68 104.26,36.07 104.44,36.25 105.23,36.25
+5VALW on TOP (solid shape): 32.45,6.78 32.45,5.69 32.45,5.69 32.45,5.44 32.29,5.27 32.29,2.89 32.38,2.79 32.38,2.44 32.24,2.3 31.34,2.3 31.2,2.44 31.2,4.97 32.23,6.01 32.23,6.79 32.27,6.82 32.42,6.82
+5VALW on BOTTOM (solid shape): 19.04,43.92 19.04,43.25 18.72,42.92 18.72,42.07 18.56,41.92 18.32,41.92 18.15,42.09 18.15,42.91 17.77,43.29 17.77,43.89 17.87,43.99 18.98,43.99
+5VALW on BOTTOM (solid shape): 19.14,19.6 19.14,18.77 19.41,18.5 19.41,17.68 19.34,17.61 18.42,17.61 18.31,17.73 18.31,18.46 18.59,18.75 18.59,19.61 18.75,19.76 18.98,19.76
+5VALW on BOTTOM (solid shape): 126.79,12.1 126.79,3.36 126.11,2.67 124.15,2.67 122.62,4.21 121.91,4.21 121.72,4.4 121.72,10.14 121.76,10.18 122.27,10.18 122.29,10.2 122.29,12.13 122.25,12.17 121.8,12.17 121.72,12.24 121.72,12.8 121.96,13.04 125.85,13.04
+5VALW on BOTTOM (solid shape): 194.88,114.33 194.88,111.11 194.88,107.26 195.94,106.19 196.67,106.19 196.97,106.49 196.97,107.92 197.06,108.01 197.91,108.01 197.99,107.93 197.99,105.24 196.83,104.09 193.19,104.09 192.38,104.89 192.38,113.15 192.13,113.41 192.13,114.16 192.74,114.77 194.43,114.77
+5VALW on IN1 (solid shape): 20.42,43.77 20.42,43.22 20.1,42.9 18.04,42.9 17.75,43.19 17.75,43.82 18.1,44.17 20.02,44.17
+5VALW on IN1 (solid shape): 20.87,18.69 20.87,17.84 20.65,17.62 18.4,17.62 18.27,17.75 18.27,18.77 18.46,18.95 20.61,18.95
+5VALW on IN1 (solid shape): 20.91,27.49 20.91,26.93 20.59,26.61 18.53,26.61 18.24,26.91 18.24,27.54 18.59,27.89 20.51,27.89
+5VALW on IN1 (solid shape): 32.44,3.39 32.44,2.41 32.32,2.28 31.2,2.28 30.83,2.65 30.83,3.53 31.02,3.72 32.11,3.72
+5VALW on IN1 (solid shape): 110.47,19.94 110.47,19.2 110.28,19.01 108.62,19.01 108.17,19.47 108.17,20.17 108.25,20.26 110.15,20.26
+5VALW on IN1 (solid shape): 181.45,41.78 181.45,40.41 181.08,40.04 178.2,40.04 177.96,40.28 177.96,41.78 178.32,42.14 181.1,42.14
+5VALW on IN1 (solid shape): 182.82,18.27 182.82,16.9 182.45,16.54 179.57,16.54 179.33,16.78 179.33,18.28 179.68,18.63 182.46,18.63
+5VALW on IN1 (solid shape): 106.22,35.03 106.22,34.21 105.96,33.96 105.84,33.96 105.61,34.19 104.41,34.19 104.29,34.3 104.29,35.18 104.46,35.35 105.9,35.35
+5VALW on VCC: outline of 84 points within 17.89,5.13 193.66,121.97
+5VALWP on BOTTOM (solid shape): 112.17,14.49 112.17,13.32 112.38,13.11 113.2,13.11 113.46,13.37 113.46,14.52 113.61,14.67 114.98,14.67 116.03,13.63 121.2,13.63 121.53,13.3 121.53,4.33 121.39,4.19 116.55,4.19 116.33,4.41 116.33,5.19 116.88,5.74 116.88,9.28 116.55,9.61 115.48,9.61 114.75,8.88 114.75,7.87 114.67,7.79 110.63,7.79 110.06,8.36 110.06,14.55 110.18,14.67 111.99,14.67
+5VS on TOP (solid shape): 14.4,105.59 14.4,104.06 14.27,103.93 11.79,103.93 11.48,104.25 11.48,105.59 11.73,105.84 14.15,105.84
+5VS on TOP (solid shape): 18.5,127.26 18.5,126.46 18.31,126.27 16.71,126.27 16.39,126.59 16.39,127.28 16.62,127.52 18.24,127.52
+5VS on TOP (solid shape): 26.73,90.44 26.73,89.93 27.09,89.56 27.09,87.74 26.84,87.49 25.25,87.49 25.06,87.68 25.06,90.38 25.27,90.58 26.58,90.58
+5VS on TOP (solid shape): 15.49,68.42 15.49,66.3 15.36,66.17 14.75,66.17 14.65,66.28 14.65,67.42 14.52,67.55 13.06,67.55 12.94,67.68 12.94,68.63 13.06,68.76 15.16,68.76
+5VS on TOP (solid shape): 28.48,120.62 28.48,120.38 28.35,120.25 27.12,120.25 26.86,119.99 26.86,119.73 26.69,119.57 25.83,119.57 25.66,119.74 25.66,120.58 25.84,120.76 28.34,120.76
+5VS on TOP (solid shape): 182.68,49.27 182.68,48.21 182.41,47.94 180.25,47.94 180.1,48.09 180.1,48.37 180.31,48.59 181.68,48.59 181.85,48.75 181.85,49.16 182.07,49.39 182.57,49.39
+5VS on TOP (solid shape): 183.84,138.97 185.18,138.97 185.24,138.9 185.24,138.41 185.18,138.35 184.02,138.35 183.75,138.61 182.52,138.61 182.41,138.71 182.41,139.04 182.58,139.21 183.6,139.21
+5VS on TOP (solid shape): 26.47,73.72 29.88,73.72 30.07,73.53 30.07,72.55 29.52,72 26.41,72 25.78,72.63 23,72.63 22.77,72.87 22.77,74.02 22.94,74.19 26,74.19
+5VS on TOP (solid shape): 186.24,118.36 186.24,115 185.25,114.01 185.1,114.01 184.95,114.15 184.95,114.16 184.82,114.28 184.26,114.28 184.13,114.41 184.13,114.92 184.32,115.11 184.54,115.11 184.83,115.4 184.83,118.5 185.02,118.69 185.91,118.69
+5VS on TOP (solid shape): 169.18,118.62 169.18,117.56 168.77,117.14 167.57,117.14 167.37,117.21 167.16,117.14 166.99,117.14 166.8,117.33 166.8,118.67 167.05,118.92 168.89,118.92
+5VS on TOP (solid shape): 15.92,122.41 15.92,120.83 16.4,120.34 16.4,119.21 16.75,118.87 16.75,114.79 16.52,114.57 15.19,114.57 14.97,114.35 14.97,112.89 14.71,112.63 12.62,112.63 12.49,112.76 12.49,114.41 15.26,117.18 15.26,118.37 15.03,118.6 15.03,118.6 14.71,118.92 14.71,122.35 14.97,122.6 15.73,122.6
+5VS on TOP (solid shape): 152.81,47.91 152.81,47.74 151.59,46.52 150.93,46.52 150.44,46.02 150.44,45.27 150.26,45.09 149.61,45.09 149.55,45.15 149.55,46.57 149.58,46.6 150.32,46.6 150.91,47.19 151.82,47.19 152.61,47.98 152.75,47.98
+5VS on TOP (solid shape): 156.29,55.45 156.29,54.1 156.47,53.92 158.02,53.92 158.19,54.09 158.19,54.85 157.87,55.18 157.87,55.43 157.97,55.53 159.32,55.53 159.49,55.36 159.49,54.22 159.3,54.02 159.3,53.31 159.21,53.22 156.63,53.22 156.23,52.82 155.94,52.82 155.54,53.21 155.54,53.96 155.09,54.42 155.09,55.5 155.23,55.65 156.1,55.65
+5VS on BOTTOM (solid shape): 101.45,166.29 101.45,164.96 101.2,164.7 99.74,164.7 99.49,164.96 99.49,166.35 99.61,166.48 101.26,166.48
+5VS on BOTTOM (solid shape): 131.79,7.48 135.17,7.48 135.3,7.35 135.3,5.18 134.63,4.51 129.56,4.51 129.35,4.72 129.35,7.72 129.54,7.91 131.36,7.91
+5VS on BOTTOM (solid shape): 18.34,127.46 18.39,127.42 18.47,127.38 18.76,127.09 18.76,125.6 18.54,125.38 17.82,125.38 17.65,125.55 17.65,127.15 17.95,127.46
+5VS on BOTTOM (solid shape): 27.25,120.76 28.35,120.76 28.47,120.64 28.47,120.36 28.34,120.23 27.38,120.23 26.79,120.82 25.5,120.82 25.44,120.88 25.44,120.97 25.5,121.03 26.98,121.03
+5VS on BOTTOM (solid shape): 16.43,116.19 16.43,114.73 16.24,114.54 15.73,114.54 15.03,113.84 13.89,113.84 13.76,113.97 13.76,116 14.14,116.38 16.24,116.38
+5VS on BOTTOM (solid shape): 181.9,139.96 181.9,139.43 182.15,139.18 184.62,139.18 184.78,139.02 184.78,136.98 184.69,136.89 183.97,136.89 183.9,136.96 183.9,138.48 183.75,138.64 181.34,138.64 181.06,138.92 181.06,139.98 181.18,140.1 181.76,140.1
+5VS on BOTTOM (solid shape): 196.13,54.67 196.13,52.92 195.97,52.75 195.45,52.75 195.43,52.78 193.94,52.78 193.73,52.85 193.53,52.75 193.24,52.75 192.87,52.39 192.22,52.39 192.07,52.54 192.06,52.54 191.94,52.66 191.94,52.97 191.37,53.55 191.37,54.76 191.5,54.9 195.91,54.9
+5VS on IN1 (solid shape): 14.97,68.56 14.97,67.68 14.84,67.55 13.06,67.55 12.87,67.74 12.87,68.56 13,68.69 14.84,68.69
+5VS on IN1 (solid shape): 132.7,6.27 132.7,4.75 132.25,4.3 129.39,4.3 129.08,4.62 129.08,6.33 129.52,6.78 132.19,6.78
+5VS on IN1 (solid shape): 169.37,118.37 169.37,116.1 169.06,115.78 168.12,115.78 167.88,116.02 167.88,118.73 168.02,118.87 168.88,118.87
+5VS on IN1 (solid shape): 192.9,54.94 192.9,52.73 192.6,52.42 186.38,52.42 185.87,52.93 185.87,54.17 186.99,55.29 192.55,55.29
+5VS on IN1 (solid shape): 16.05,105.39 16.05,104.06 15.79,103.81 13.82,103.81 13.57,104.06 13.57,105.46 13.82,105.71 15.73,105.71
+5VS on IN1 (solid shape): 27.45,90.59 27.45,89.11 27.27,88.94 24.49,88.94 24.29,89.14 24.29,90.6 24.46,90.78 27.26,90.78
+5VS on IN1 (solid shape): 101.42,165.6 101.42,164.93 101.21,164.72 100.61,164.72 99.63,163.74 97.02,163.74 96.76,163.99 96.76,164.55 97.9,164.55 97.9,164.5 97.91,164.45 97.92,164.4 97.95,164.35 97.98,164.3 98.01,164.26 98.05,164.23 98.1,164.2 98.15,164.18 98.2,164.17 98.25,164.17 98.31,164.17 98.36,164.18 98.41,164.2 98.46,164.23 98.5,164.26 98.53,164.3 98.56,164.35 98.59,164.4 98.6,164.45 98.61,164.5 98.61,164.55 98.6,164.61 98.59,164.66 98.56,164.7 98.53,164.75 98.5,164.79 98.46,164.82 98.41,164.85 98.36,164.87 98.31,164.88 98.25,164.88 98.2,164.88 98.15,164.87 98.1,164.85 98.05,164.82 98.01,164.79 97.98,164.75 97.95,164.7 97.92,164.66 97.91,164.61 97.9,164.55 96.76,164.55 96.76,165.36 97.18,165.78 101.25,165.78
+5VS on IN1 (solid shape): outline of 178 points within 22.69,68.15 27.57,74.35
+5VS on IN1 (solid shape): outline of 388 points within 26.14,9.36 40.43,14.54
+5VS on IN2 (solid shape): 184.29,49.09 184.29,48.16 183.94,47.8 180.26,47.8 180.13,47.93 180.13,49.26 180.39,49.51 183.87,49.51
+5VS on IN2 (solid shape): 170.48,118.92 170.48,118.92 171.38,118.02 171.38,117.01 170.42,116.06 169.01,116.06 167.75,117.32 167.75,118.79 168.19,119.24 170.16,119.24
+5VS on IN2 (solid shape): 188.12,54.7 188.12,52.98 187.68,52.54 186.16,52.54 185.9,52.79 185.9,53.59 185.92,53.61 185.92,54.34 186.43,54.85 187.97,54.85
+5VS on IN2 (solid shape): 157.92,55.68 158.15,55.6 158.38,55.68 158.73,55.68 159,55.4 159,54.14 158.39,53.54 155.2,53.54 154.84,53.89 154.84,55.22 154.85,55.23 154.88,55.38 154.86,55.53 154.84,55.56 154.96,55.68
+5VS on IN2 (solid shape): 185.63,116.67 185.63,114.34 185.55,114.28 185.49,114.19 185.49,114.19 184.87,113.57 183.84,113.57 183.17,112.9 182.32,112.9 181.99,113.23 181.99,115 183.1,116.11 183.78,116.11 184.07,116.06 184.29,116.25 184.29,116.25 184.71,116.67 184.71,116.67 184.84,116.8 185.5,116.8
+5VS on VCC: 129.75,5.13 129.53,5.35 129.53,5.38 129.52,5.39 129.52,9.59 134.45,14.53 182.84,14.53 183.5,15.18 183.5,61.24 177.78,66.96 177.78,78.94 178.01,79.17 180.3,79.17 180.96,79.83 180.96,82.07 180.3,82.73 177.76,82.73 177.4,83.08 177.4,97.48 183.12,103.19 183.12,116.27 183.6,116.76 186.57,116.76 187.05,116.27 187.05,98.71 183.5,95.15 183.5,87.95 186.13,85.32 186.13,79.24 184.26,77.37 184.26,69.16 189.08,64.33 189.08,19.63 189.87,18.84 192.41,18.84 192.64,18.62 192.64,12.6 185.17,5.13
+AVDD on TOP (solid shape): 142.77,129.47 142.77,129.26 143.03,129.01 143.35,129.01 143.47,128.89 143.47,128.34 143.41,128.28 142.77,128.28 142.55,128.06 141.24,128.06 140.07,129.24 140.07,129.49 140.32,129.75 142.49,129.75
+VCCADAC on BOTTOM (solid shape): 131.04,75.66 131.04,75.04 130.98,74.99 130.98,73.77 130.98,73.77 130.98,72.56 130.8,72.39 130.06,72.39 129.94,72.5 129.94,72.95 130.17,73.18 130.17,73.64 130.12,73.69 130.12,73.89 130.12,73.9 130.02,74.39 129.58,74.61 128.42,74.61 128.31,74.49 128.23,74.57 128.23,75.64 128.33,75.74 130.95,75.74
+VCCST on BOTTOM (solid shape): 56.75,110.07 56.75,109.66 56.17,109.08 55.92,109.08 55.77,109.23 55.77,109.59 55.91,109.73 55.91,110.06 56.18,110.32 56.5,110.32
+VDD1DI on TOP (solid shape): 142.61,125.83 145.32,125.83 145.48,125.67 145.48,125.1 145.39,125.01 141.6,125.01 141.49,125.12 141.49,126.21 141.49,126.21 141.49,126.36 141.6,126.46 141.98,126.46
+VDDC_CT on TOP (solid shape): 142.06,136.14 142.06,136.13 142.15,135.96 142.32,135.87 142.33,135.87 142.61,135.59 142.61,134 142.57,133.95 142.06,133.95 141.98,133.99 141.96,134.07 141.93,134.26 141.79,134.4 141.77,134.42 141.77,135.18 141.51,135.44 141.33,135.44 141.29,135.44 141.07,135.44 140.89,135.25 140.89,134.99 140.81,134.91 140.51,134.91 140.38,135.04 140.38,136.45 140.51,136.58 141.62,136.58
+VDDC_CT on BOTTOM (solid shape): 142.15,136.78 142.15,136.42 142.06,136.19 142.15,135.97 142.15,135.56 142.01,135.41 141.75,135.41 141.59,135.58 141.11,135.58 140.95,135.42 140.72,135.42 140.58,135.56 140.58,136.78 140.76,136.96 141.97,136.96
+VDDR3 on TOP (solid shape): 142.79,138.11 143.01,137.89 143.81,137.89 143.97,137.73 143.97,137.13 143.84,137 143.26,137 142.51,137 142.25,136.74 141.47,136.74 141.35,136.86 141.35,139.51 141.55,139.71 142.79,139.71
+VDDR3 on BOTTOM (solid shape): 142.6,138.29 142.6,138.11 142.35,137.85 142.35,137.6 142.6,137.34 142.6,137.09 142.41,136.9 142.28,136.9 141.84,137.35 140.76,137.35 140.57,137.54 140.57,138.8 140.7,138.92 141.97,138.92
+VDDR4 on TOP (solid shape): 140.55,148.51 142.4,148.51 142.55,148.35 142.55,147.9 141.46,146.81 140.2,146.81 140.09,146.92 140.09,147.53 139.81,147.81 139.52,147.81 139.47,147.87 139.33,147.87 139.33,147.88 139.33,148.74 139.36,148.78 140.28,148.78
+VDDR4 on BOTTOM (solid shape): 142.18,148.9 142.18,148.21 142.17,148.21 142.17,148.02 142.12,147.93 142.02,147.93 141.55,147.63 142.08,147.47 142.1,147.49 142.17,147.49 142.17,147.38 141.99,147.08 142.18,146.79 142.18,146.46 142.06,146.2 142.18,145.94 142.18,145.29 142.13,145.24 142.12,145.24 142.02,145.15 141.53,145.15 141.53,145.19 141.28,145.48 140.93,145.35 140.84,145.31 140.76,145.35 140.68,145.43 140.59,145.48 140.58,145.49 140.44,145.62 140.44,146.66 139.77,147.33 139.77,147.34 139.54,147.57 139.54,147.78 139.55,147.8 139.56,147.82 140.06,148.32 140.82,149.08 141.99,149.08
GND on TOP (solid shape): 27.77,130.24 10.53,130.24 10.53,130.75 27.77,130.75
GND on TOP (solid shape): 10.49,103.91 10.49,102.74 10.28,102.53 8.95,102.53 8.84,102.64 8.84,103.95 9,104.1 10.29,104.1
GND on TOP (solid shape): 23.03,79.07 23.03,78.18 22.9,78.05 21.56,78.05 21.39,78.22 21.39,79.05 21.57,79.24 22.87,79.24
GND on TOP (solid shape): 23.27,86.22 23.27,85.35 23.12,85.2 21.66,85.2 21.54,85.32 21.54,86.22 21.72,86.4 23.09,86.4
GND on TOP (solid shape): 37.54,14.07 37.54,10.98 37.44,10.87 36.16,10.87 36,11.04 36,14.06 36.19,14.25 37.37,14.25
GND on TOP (solid shape): 43.13,108.57 43.13,105.33 42.83,105.02 39.78,105.02 39.49,105.31 39.49,108.46 39.9,108.88 42.83,108.88
GND on TOP (solid shape): 45.75,73.66 45.75,63.62 45.06,62.93 39.59,62.93 37.87,64.65 37.87,73.84 38.84,74.81 44.6,74.81
GND on TOP (solid shape): 46.11,113.45 46.11,112.8 46.03,112.72 44.88,112.72 44.83,112.77 44.83,113.41 44.94,113.52 46.03,113.52
GND on TOP (solid shape): 58.47,16.88 58.47,15.9 56.71,14.14 54.88,14.14 54.53,14.49 54.53,16.94 55.04,17.45 57.89,17.45
GND on TOP (solid shape): 73.46,15.74 73.46,14.52 73.13,14.19 69.93,14.19 69.63,14.49 69.63,15.8 70,16.16 73.03,16.16
GND on TOP (solid shape): 74.78,103.43 74.78,100.89 74.47,100.57 71.48,100.57 71.42,100.63 71.42,103.49 71.67,103.74 74.47,103.74
GND on TOP (solid shape): 81.73,125.25 81.73,122.66 81.48,122.42 80.27,122.42 80.09,122.6 80.09,125.15 80.28,125.34 81.63,125.34
GND on TOP (solid shape): 81.91,59.89 81.91,57.81 81.58,57.47 77.48,57.47 77.12,57.83 77.12,59.93 77.4,60.21 81.59,60.21
GND on TOP (solid shape): 87.71,20.3 87.71,17.37 87.45,17.11 86.08,17.11 85.91,17.28 85.91,20.41 86.07,20.57 87.44,20.57
GND on TOP (solid shape): 88.44,124.18 88.44,122.81 88.18,122.55 86.47,122.55 86.29,122.73 86.29,124.31 86.4,124.43 88.19,124.43
GND on TOP (solid shape): 105.59,33.91 105.59,33.3 105.38,33.09 104.45,33.09 104.38,33.16 104.38,33.28 105.15,34.05 105.45,34.05
GND on TOP (solid shape): 122.76,154.96 122.76,153.7 122.57,153.51 121.73,153.51 121.48,153.76 121.48,154.98 121.6,155.1 122.62,155.1
GND on TOP (solid shape): 127.55,66.04 127.55,64.78 127.19,64.42 125.66,64.42 125.44,64.65 125.44,65.96 125.73,66.26 127.34,66.26
