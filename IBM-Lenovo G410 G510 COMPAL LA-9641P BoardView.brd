# Allegro board IBM-Lenovo G410 G510 COMPAL LA-9641P BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MAA8: length 50.4
  TOP w0.102: UV5.T8 108.41,139.24 v1(108.41,140.01) 108.41,140.66 109.02,141.27 109.63,141.27 v2(109.88,141.03) ; UV7.T8 111.98,145.56 110.99,144.57 110.99,144.19 110.73,143.93 109.78,143.93 v2(109.23,143.38)
  IN1 w0.127: v2(109.23,143.38) 109.23,143.52 109.36,143.65 109.76,143.65 109.89,143.52 109.89,143.25 109.67,143.04 v2(109.67,142.63) 109.81,142.49 109.81,141.09 v2(109.88,141.03)
  IN2 w0.102: v2(126.5,141.89) 126.85,142.25 128.87,142.25 129,142.12 129,141.43 128.87,141.3 126.16,141.3 125.87,141.59 124.66,141.59 124.56,141.69 124.56,142.08 124.44,142.2 124.27,142.2 124.15,142.08 124.15,141.65 124.03,141.53 123.86,141.53 123.74,141.65 123.74,142.08 123.62,142.2 123.46,142.2 123.34,142.08 123.34,141.65 123.22,141.53 123.04,141.53 122.92,141.65 122.92,142.63 122.53,143.02 120.81,143.02
  IN2 w0.249: 120.81,143.02 118.79,143.02 118.66,142.89 116.61,142.89 115.55,141.83 114.87,141.83 114.42,141.37 113.64,141.37 113.19,141.83 112.86,141.83 112.34,142.36 111.71,142.36 111.49,142.58 110.47,142.58 110.36,142.46 109.84,142.46 v2(109.67,142.63)
  BOTTOM w0.102: UV1.H19 126.45,141.94 v2(126.5,141.89) ; UV8.T8 107.18,145.81 107.64,145.35 107.64,144.65 108.42,143.87 108.71,143.87 108.82,143.76 108.85,143.76 v2(109.23,143.38) ; UV6.T8 112,138.08 112,140.19 111.89,140.3 111.42,140.3 111.3,140.42 111.3,141.16 111.21,141.25 110.03,141.25 109.88,141.1 v2(109.88,141.03)
MAA9: length 45.7
  TOP w0.102: UV5.R3 111.23,137.26 110.85,137.63 110.85,138.66 110.37,139.13 v2(110.16,139.13) ; 120.81,142.78 121.06,142.78 121.31,143.02 122.73,143.02 122.83,142.92 122.83,142.62 122.93,142.52 123.14,142.52 123.24,142.62 123.24,142.92 123.34,143.02 123.93,143.02 124.06,142.9 124.06,142.46 123.98,142.38 123.98,141.73 124.11,141.61 124.3,141.61 124.42,141.73 124.42,142.07 124.54,142.2 124.73,142.2 124.86,142.07 124.86,141.53 124.99,141.41 125.93,141.41 126.05,141.53 126.05,141.86 v2(125.94,141.97) ; v2(109.05,145.23) 108.8,145.23 108.42,145.6 108.42,145.81 108.66,146.05 108.66,146.38 108.33,146.71 107.94,146.71 107.82,146.83 107.82,146.99 107.94,147.12 UV7.R3
  TOP w0.203: 120.81,142.78 116.77,142.78 116.56,142.57 116.56,142.09 116.44,141.97 v1(115.89,141.97) 115.75,142.11 115.75,142.78 115.62,142.91 114.28,142.91 114.16,142.78 114.16,142.27 114.03,142.15 113.52,142.15 113.28,142.39 113.28,142.39 113.28,143.08 113.15,143.2 112.53,143.2 112.4,143.08 112.4,142.47 112.28,142.34 111.78,142.34 111.2,142.92 110.21,142.92 v2(110.17,142.96)
  IN1 w0.102: 110.36,141.27 110.36,140.77 110.23,140.64 109.89,140.64 109.79,140.54 109.79,140.42 109.91,140.29 110.23,140.29 110.36,140.17 110.36,139.33 v2(110.16,139.13)
  IN1 w0.127: 110.36,141.27 110.15,141.47 110.15,142.88 110.17,142.9 ; 110.17,142.9 v2(110.17,142.96) ; 110.17,142.9 110.15,142.91 110.15,145.41 109.95,145.62 109.11,145.62 109.05,145.55 v2(109.05,145.23)
  BOTTOM w0.102: v2(125.94,141.97) 126.11,141.8 126.11,141.61 UV1.H20 ; v2(110.16,139.13) 110.06,139.13 109.68,138.75 109.12,138.75 108.81,138.45 108.81,137.39 108.67,137.25 UV6.R3 ; UV8.R3 110.91,147.12 110.26,146.47 110.26,145.98 109.91,145.63 109.57,145.63 109.17,145.23 v2(109.05,145.23)
MAA10: length 51.8
  TOP w0.102: v2(109.76,150.8) 109.53,150.8 109.41,150.67 109.41,150.5 109.53,150.38 110.29,150.38 110.51,150.16 111.02,150.16 UV7.L7 ; v2(109.45,133.57) 108.97,134.05 UV5.L7
  IN1 w0.102: 110.73,134.16 110.53,133.96 109.83,133.96 v2(109.45,133.57)
  IN1 w0.127: 110.73,134.16 111.79,135.22 111.79,135.49 112.73,136.43 113.45,136.43 115.03,138.01 115.03,140.25 116.54,141.76 116.54,143.7 v2(116.68,143.84) 116.68,144.25 114.47,146.46 114.47,146.91 113.55,147.84 113.14,147.84 110.18,150.8 v2(109.76,150.8)
  IN2 w0.102: v2(128.23,146.63) 128.93,145.93 128.93,144 129.18,143.74 129.18,142.58 129.05,142.45 125.23,142.45 124.48,143.19 123.39,143.19 123.09,143.49 121.38,143.49 120.94,143.93 120.81,143.93
  IN2 w0.249: v2(116.68,143.84) 116.68,143.94 117.1,144.36 118.45,144.36 118.75,144.05 119.12,144.05 119.43,144.36 119.82,144.36 120.25,143.93 120.81,143.93
  BOTTOM w0.102: v2(109.76,150.8) 109.59,150.8 109.2,150.41 108.63,150.41 108.5,150.28 108.5,150.17 108.4,150.07 108.08,150.07 107.98,150.17 UV8.L7 ; v2(128.23,146.63) 128.27,146.67 UV1.L13 ; UV6.L7 111.13,133.95 109.97,133.95 109.59,133.57 v2(109.45,133.57)
MAA11: length 44
  TOP w0.102: UV5.R7 108.35,137.25 109.03,137.93 109.76,137.93 v2(110.16,138.33) ; v2(109.76,146.02) 109.91,146.17 110.01,146.17 110.31,145.87 110.46,145.87 110.59,146 110.59,146.18 110.22,146.56 110.22,146.75 110.59,147.12 UV7.R7
  IN1 w0.127: v2(110.16,138.33) 110.16,138.58 111.1,139.52 111.1,139.57 111.67,140.13 111.67,141.36 112.39,142.08 112.39,142.97 112.2,143.16 112.2,143.37 v2(111.75,143.81) 111.58,143.64 111.28,143.64 111.13,143.78 111.13,144.01 111.33,144.22 111.33,144.54 110.99,144.89 110.55,144.89 110.43,145 110.43,145.73 110.14,146.02 v2(109.76,146.02)
  IN2 w0.102: v2(125.25,144.31) 124.84,144.72 124.19,144.72 123.79,145.12 123.01,145.12 122.77,145.36 122.77,145.82 122.42,146.17 120.81,146.17
  IN2 w0.249: v2(111.75,143.81) 111.4,143.81 111.21,144 111.21,145.21 111.44,145.44 112.5,145.44 112.62,145.31 112.62,144.16 113.25,143.53 113.86,143.53 114.15,143.83 114.15,144.82 113.77,145.2 113.77,146.12 114.26,146.61 114.81,146.61 115.02,146.82 115.76,146.82 116.41,146.17 120.81,146.17
  BOTTOM w0.102: UV8.R7 108.21,147.12 108.43,146.9 108.43,146.69 108.59,146.53 108.59,145.73 108.69,145.63 109.2,145.63 109.6,146.02 v2(109.76,146.02) ; v2(125.25,144.31) 125.65,144.72 UV1.G16 ; UV6.R7 111.11,137.25 110.68,137.68 110.68,137.78 110.16,138.29 v2(110.16,138.33)
MAA12: length 50.8
  TOP w0.102: v2(110.16,135.93) 109.75,136.34 108.72,136.34 UV5.N7 ; v2(109.76,148.41) 109.76,148.72 109.89,148.85 110.07,148.85 110.19,148.72 110.19,148.05 110.3,147.94 110.46,147.94 110.57,148.05 110.57,148.41 110.66,148.5 110.8,148.5 111.02,148.28 111.55,148.28 111.64,148.37 111.64,148.6 111.52,148.72 UV7.N7
  IN1 w0.102: 112.25,138.96 112.25,138.8 111.55,138.1 111.55,137.87 111.05,137.36 111.05,136.5 110.48,135.93 v2(110.16,135.93)
  IN1 w0.127: 112.25,138.96 113.01,139.72 113.01,140.3 114.28,141.57 114.28,143.08 113.67,143.69 v2(113.67,144.03) 113.63,144.03 112.75,144.91 112.55,144.91 110.71,146.74 110.71,147.1 110.55,147.27 110.55,147.44 110.75,147.65 110.75,147.83 110.61,147.98 110.32,147.98 110.21,148.09 110.21,148.38 110.07,148.51 109.86,148.51 v2(109.76,148.41)
  IN2 w0.102: 120.81,146.62 122.45,146.62 123.1,145.97 123.58,145.97 123.99,145.56 123.99,145.34 124.4,144.93 125.11,144.93 125.2,144.84 125.94,144.84 v2(126.45,144.32)
  IN2 w0.249: 120.81,146.62 117.41,146.62 116.67,147.35 114.91,147.35 114.62,147.06 113.99,147.06 113.76,147.29 112.93,147.29 112.58,146.94 112.58,146.09 112.58,146.09 113.08,145.59 113.08,144.62 v2(113.67,144.03)
  BOTTOM w0.102: UV8.N7 107.98,148.99 107.86,149.11 107.7,149.11 107.58,148.99 107.58,148.43 107.7,148.31 108.48,148.31 108.74,148.04 109.23,148.04 109.6,148.41 v2(109.76,148.41) ; v2(126.45,144.32) 126.7,144.32 UV1.J16 ; UV6.N7 111.53,135.65 111.65,135.77 111.65,136 111.58,136.07 110.74,136.07 110.66,136 110.66,135.63 110.54,135.51 110.29,135.51 110.16,135.63 v2(110.16,135.93)
MAA13: length 42.9
  TOP w0.102: UV7.T3 107.98,145.76 108.95,144.79 109.32,144.79 v2(109.76,144.35) ; 120.81,140.41 120.99,140.59 124.34,140.59 125,139.94 125,139.32 125.22,139.09 126.28,139.09 126.4,138.98 126.4,138.46 v2(126.3,138.36) ; v2(109.4,139.96) 109.4,139.76 109.64,139.52 110.32,139.52 111.23,138.61 UV5.T3
  TOP w0.203: 120.81,140.41 120.48,140.08 120,140.08 119.82,140.26 119.82,140.26 119.78,140.3 119.78,140.61 119.65,140.74 119.09,140.74 118.97,140.61 118.97,140.23 118.84,140.1 118.28,140.1 118.16,140.23 118.16,140.61 118.03,140.74 117.53,140.74 117.46,140.81 117.25,140.81 117.13,140.94 117.13,141.25 117,141.38 116.4,141.38 116.28,141.25 116.28,141.12 116.15,141 115.64,141 115.51,141.12 115.51,141.59 115.41,141.7 115.41,142.44 115.28,142.57 114.63,142.57 114.5,142.44 114.5,141.93 114.37,141.8 113.38,141.8 113.19,142 111.64,142 111.06,142.58 110.41,142.58 v1(110.21,142.38) 110,142.17 109.48,142.17 109.16,142.49 v2(108.73,142.49)
  IN1 w0.127: v2(109.76,144.35) 109.33,143.91 108.34,143.91 108.22,143.8 108.22,143.16 108.73,142.66 v2(108.73,142.49) 108.73,141.69 108.81,141.61 108.81,140.55 v2(109.4,139.96)
  BOTTOM w0.102: UV8.T3 110.76,145.9 110.76,145.34 v2(109.76,144.35) ; v2(126.3,138.36) 126.45,138.51 UV1.H23 ; UV6.T3 108.22,138.24 108.22,138.59 108.07,138.74 108.07,138.88 108.21,139.03 108.36,139.03 108.51,138.88 108.65,138.88 108.78,139.01 108.78,139.15 108.61,139.33 108.61,139.45 109.12,139.96 v2(109.4,139.96)
MAA14: length 50.1
  TOP w0.102: UV7.T7 111.18,145.98 111.28,145.88 111.58,145.88 111.68,145.78 111.68,145.58 111.58,145.48 111.18,145.48 111.06,145.35 111.06,145.11 110.93,144.98 110.74,144.98 110.61,145.11 110.61,145.29 110.48,145.41 110.27,145.41 110.14,145.29 110.14,144.47 110.27,144.35 v2(110.55,144.35) ; v2(110.81,139.86) 110.6,139.86 110.02,140.44 109,140.44 108.9,140.34 108.9,138.92 UV5.T7 ; v2(127.07,141.85) 126.51,142.42 125.2,142.42 124.38,143.24 121.24,143.24 121.12,143.12 121,143.12
  TOP w0.203: 121,143.12 116.14,143.12 115.89,143.37 115.35,143.37 114.84,143.88 114.26,143.88 114.13,144 114.13,144.36 114,144.49 113.48,144.49 113.14,144.14 113.14,143.67 113.01,143.55 112.36,143.55 112.24,143.67 v1(112.24,144.35) 112.84,144.95 112.84,145.13 112.49,145.48 112.31,145.48 111.32,144.5 111.32,144.08 111.17,143.93 111.17,143.6 v2(111.93,142.84)
  IN1 w0.102: 111.34,141.56 111.34,140.13 111.07,139.86 v2(110.81,139.86) ; v2(110.55,144.35) 110.55,144.42 110.75,144.63 110.93,144.63 111.05,144.5 111.05,144.24 110.92,144.11 110.92,143.67
  IN1 w0.127: 110.92,143.67 111.36,143.23 111.54,143.23 v2(111.93,142.84) 111.98,142.79 111.98,142.21 111.34,141.56
  BOTTOM w0.102: UV6.T7 111.79,138.61 111.79,139.8 111.67,139.93 111.42,139.93 111.3,139.8 111.3,139.13 111.17,139 110.94,139 110.81,139.13 v2(110.81,139.86) ; UV8.T7 107.72,146.32 107.59,146.19 107.59,145.95 107.72,145.82 107.97,145.82 108.1,145.69 108.1,145.45 107.87,145.22 107.87,145.05 107.99,144.93 108.16,144.93 108.19,144.97 108.34,144.97 108.48,144.82 108.48,144.68 108.26,144.46 108.26,144.32 108.43,144.15 108.72,144.15 108.9,143.96 110.09,143.96 110.47,144.35 v2(110.55,144.35) ; UV1.J19 127.25,142.03 v2(127.07,141.85)
MAA15: length 50.5
  TOP w0.102: UV5.M7 108.47,134.85 109.16,135.54 109.7,135.54 110.1,135.15 v2(110.16,135.15) ; v2(109.76,149.21) 109.76,149.18 109.89,149.05 110.22,149.05 110.32,149.16 110.32,149.34 110.42,149.44 110.63,149.44 110.73,149.34 110.73,149.16 110.8,149.08 111.21,149.08 111.3,149.18 111.3,149.4 UV7.M7
  IN1 w0.102: v2(110.16,135.15) 110.33,134.98 110.59,134.98 111.12,135.5 111.12,135.92 111.78,136.58 111.78,136.8 111.53,137.05 111.53,137.23 111.67,137.37 111.85,137.37 112.13,137.09 112.28,137.09 112.42,137.24 112.42,137.38 112.02,137.78 112.02,137.91 112.17,138.06 112.32,138.06 112.47,137.9 112.64,137.9 112.76,138.02 112.76,138.19 112.6,138.35 112.6,138.49 113.08,138.96 113.44,138.96 113.62,139.14
  IN1 w0.127: v2(109.76,149.21) 110.02,149.21 111.31,147.92 111.31,147.28 113.51,145.08 113.69,145.08 115.06,143.72 v2(115.06,141.33) 114.98,141.33 113.69,140.04 113.69,139.2 113.62,139.14
  IN2 w0.102: 120.81,142.57 121.19,142.57 121.31,142.68 122.49,142.68 122.72,142.45 122.72,141.46 122.85,141.33 125.85,141.33 126.07,141.1 128.41,141.1 128.52,141 128.52,140.5 128.63,140.38 128.8,140.38 128.92,140.5 128.92,141 129.02,141.1 129.45,141.1 v2(129.45,141.1)
  IN2 w0.249: 120.81,142.57 120.27,142.57 120.14,142.44 120.14,141.8 120.01,141.67 119.42,141.67 119.3,141.8 119.3,142.31 119.17,142.44 116.8,142.44 116.44,142.08 116.44,141.56 116.21,141.33 v2(115.06,141.33)
  BOTTOM w0.102: UV8.M7 108.66,148.84 109.24,148.84 109.61,149.21 v2(109.76,149.21) ; UV1.M21 129.85,140.69 v2(129.45,141.1) ; UV6.M7 111.36,134.85 111.44,134.92 111.44,135.2 111.37,135.27 110.93,135.27 110.83,135.17 110.83,134.88 110.73,134.78 110.62,134.78 110.26,135.15 v2(110.16,135.15)
MAB0: length 49.6
  TOP w0.102: v2(144.82,168.9) 145.88,169.97 UV12.N3 ; 134.3,156.12 134.3,154.6 132.65,152.94 132.65,151.05 132.51,150.91 v2(132.06,150.91) ; UV9.N3 131.77,166.44 131.88,166.33 132.07,166.33 132.18,166.44 132.18,166.91 132.44,167.17 132.44,168.13 132.51,168.2 132.72,168.2 132.86,168.06 v2(132.86,167.83)
  TOP w0.203: v2(138.02,164.99) 138.37,164.99 138.5,165.12 138.5,165.27 138.2,165.57 137.93,165.57 137.5,165.13 v1(137.5,164.87) 137.36,164.73 137.21,164.73 137.08,164.6 137.08,164.07 137.23,163.92 138.02,163.92 138.13,163.8 138.13,163.22 138.02,163.1 137.57,163.1 137.2,162.73 137.2,161.89 137.07,161.76 136.7,161.76 135.69,160.75 135.69,160.39 135.55,160.24 135.18,160.24 134.3,159.36 134.3,159.01 134.4,158.91 134.85,158.91 135.16,158.6 135.16,158.42 134.84,158.09 134.42,158.09 134.3,157.97 134.3,157.4 134.42,157.28 134.77,157.28 134.88,157.17 134.88,156.84 134.51,156.47 134.39,156.47 134.3,156.38 134.3,156.12
  IN1 w0.127: v2(132.86,167.83) 132.86,167.4 133.27,166.98 134.53,166.98 135.76,165.76 137.25,165.76 v2(138.02,164.99) 138.38,165.35 140.98,165.35 142.69,167.06 143.43,167.06 144.4,168.03 144.4,168.33 144.82,168.74 v2(144.82,168.9)
  BOTTOM w0.102: UV11.N3 145.9,167.14 145.2,167.85 145.2,168.43 144.82,168.81 v2(144.82,168.9) ; UV1.P8 131.61,150.91 v2(132.06,150.91) ; v2(132.86,167.83) 132.86,167.92 132.48,168.3 132.48,168.89 132.16,169.2 132.16,170.22 132.06,170.32 131.87,170.32 131.77,170.22 UV10.N3
MAB1: length 49.4
  TOP w0.102: v2(132.87,168.55) 132.65,168.55 132.37,168.83 132.37,169.77 UV9.P7 ; v2(144.81,168.18) 145.1,167.88 UV12.P7
  IN1 w0.127: v2(132.87,168.55) 132.87,168.84 134.08,170.05 134.26,170.05 134.39,169.92 134.57,169.92 134.75,170.1 134.75,170.28 134.62,170.41 134.62,170.59 134.8,170.77 134.98,170.77 135.11,170.64 135.29,170.64 135.47,170.82 135.47,171 135.34,171.13 135.34,171.31 135.53,171.5 v2(137.68,171.5) 137.79,171.61 139.24,171.61 139.44,171.41 141,171.41 142.66,169.75 144.52,169.75 145.22,169.05 145.22,168.75 144.81,168.33 v2(144.81,168.18)
  IN2 w0.102: 133.79,157.31 133.79,157.17 133.95,157.01 133.95,153.02 133.51,152.57 133.05,152.57 132.68,152.21 132.68,150.95 v2(132.06,150.33)
  IN2 w0.249: 133.79,157.31 133.79,163.45 134.82,164.48 134.82,165.39 136.39,166.96 136.39,166.99 136.41,167 136.41,167.66 136.51,167.77 136.51,170.33 v2(137.68,171.5)
  BOTTOM w0.102: v2(144.81,168.18) 144.81,168.36 144.41,168.75 144.41,169.14 145.1,169.83 UV11.P7 ; v2(132.06,150.33) 132.11,150.27 UV1.T9 ; v2(132.87,168.55) 132.87,168.38 133.26,167.99 133.26,167.64 132.57,166.95 UV10.P7
MAB2: length 48.5
  TOP w0.102: UV12.P3 145.1,169.78 144.15,168.83 v2(144.02,168.83) ; v2(130.89,150.87) 130.5,151.25 130.5,152.36 131.55,153.41 131.55,153.99 131.06,154.49 131.06,156.77 130.88,156.95 130.13,156.95 129.95,157.12 129.95,157.31 ; v2(133.66,167.91) 133.63,167.91 132.57,166.85 UV9.P3
  TOP w0.203: 129.95,157.31 129.95,159.08 130.23,159.36 132.05,159.36 132.38,159.69 132.38,159.89 v1(132.01,160.26) 131.68,160.59 131.68,160.89 132,161.21 132.21,161.21 132.94,160.49 133.18,160.49 133.96,161.27 133.96,161.58 133.67,161.87 133.27,162.28 133.27,162.48 133.62,162.82 133.87,162.82 134.56,162.14 134.83,162.14 135.19,162.5 135.19,163.31 137.82,165.94 v2(138.46,165.94)
  IN1 w0.127: v2(144.02,168.83) 143.6,168.41 143.6,167.88 143.01,167.29 142.6,167.29 141.72,166.41 141.58,166.41 140.85,165.68 138.73,165.68 v2(138.46,165.94) 138.42,165.99 136,165.99 134.77,167.21 134,167.21 133.66,167.56 v2(133.66,167.91)
  BOTTOM w0.102: v2(133.66,167.91) 133.28,168.29 133.28,168.77 132.57,169.47 UV10.P3 ; v2(144.02,168.83) 144.4,168.44 144.4,167.89 145.1,167.19 UV11.P3 ; UV1.P9 131.45,150.31 v2(130.89,150.87)
MAB3: length 52.4
  TOP w0.102: 129.27,157.19 v1(129.27,154.7) 129.27,154.2 129.04,153.98 129.04,152.6 129.61,152.04 v2(129.61,151.89) ; v2(134.46,167.83) 134.21,167.59 133.95,167.59 133.72,167.35 133.42,167.35 132.95,166.88 132.95,166.58 132.75,166.38 132.4,166.38 131.99,165.97 UV9.N2 ; v2(143.22,168.9) 143.54,168.9 143.85,169.21 144.12,169.21 144.7,169.79 144.7,170.11 144.95,170.37 145.5,170.37 UV12.N2
  TOP w0.203: v2(138.75,170.85) 138.62,170.71 138.39,170.71 137.41,169.73 137.41,169.33 137.95,168.79 137.95,167.69 137.63,167.37 137.63,166.72 134.42,163.51 133.33,163.51 129.27,159.45 129.27,157.19
  IN1 w0.127: v2(134.46,167.83) 134.86,168.24 134.86,168.7 136.9,170.74 138.64,170.74 v2(138.75,170.85) 138.98,170.62 140.84,170.62 142.16,169.3 142.82,169.3 v2(143.22,168.9)
  BOTTOM w0.102: UV10.N2 132.02,170.77 132.43,170.36 132.76,170.36 132.99,170.12 132.99,169.41 133.43,168.98 133.78,168.98 134.08,168.68 134.08,168.37 134.46,167.99 v2(134.46,167.83) ; v2(143.22,168.9) 143.22,168.78 143.6,168.4 143.6,168.06 144.68,166.98 144.68,166.62 144.91,166.38 145.49,166.38 UV11.N2 ; v2(129.61,151.89) 129.63,151.87 UV1.N7
MAB4: length 52.1
  TOP w0.102: v2(144.01,168.19) 144.72,167.47 144.72,166.35 UV12.P8 ; v2(129.59,151.32) 129.12,151.8 129.12,152.25 128.84,152.52 128.84,154.18 128.92,154.26 128.92,157.31 ; v2(133.67,168.55) 133.67,168.62 132.98,169.31 132.98,170.36 UV9.P8
  TOP w0.203: v2(138.27,171.19) v1(137.21,170.13) 137.03,169.95 137.03,169.28 137.6,168.7 137.6,167.83 137.32,167.55 137.32,166.96 134.22,163.85 133.14,163.85 128.92,159.64 128.92,157.31
  IN1 w0.127: v2(133.67,168.55) 136.19,171.07 138.15,171.07 v2(138.27,171.19) 138.36,171.28 139.1,171.28 139.3,171.08 140.82,171.08 142.38,169.52 143.88,169.52 144.41,168.99 144.41,168.66 144.01,168.26 v2(144.01,168.19)
  BOTTOM w0.102: v2(144.01,168.19) 144.01,168.28 143.62,168.66 143.62,168.97 143.88,169.22 144.09,169.22 144.7,169.84 144.7,170.37 UV11.P8 ; UV1.N8 129.84,151.07 v2(129.59,151.32) ; UV10.P8 132.97,166.37 132.97,166.96 133.54,167.53 133.81,167.53 134.04,167.75 134.04,168.09 133.67,168.46 v2(133.67,168.55)
MAB5: length 52.8
  TOP w0.102: v2(136.02,167.91) 135.88,167.77 135.88,167.63 134.63,166.38 133.07,166.38 132.65,165.97 UV9.P2 ; v2(129.75,149.86) 130.3,150.41 130.3,151.82 129.81,152.31 129.81,153.49 129.61,153.69 129.61,157.31 ; UV12.P2 144.9,170.77 144.5,170.37 144.13,170.37 143.88,170.12 143.88,169.81 143.66,169.59 142.44,169.59 v2(141.63,168.79)
  TOP w0.203: v2(138.46,169.71) 138.46,169.52 138.29,169.34 138.29,167.54 138.28,167.54 138.28,167.48 138.11,167.31 v1(138.11,166.71) 134.56,163.17 133.47,163.17 129.61,159.3 129.61,157.31
  IN1 w0.127: v2(136.02,167.91) 135.66,168.27 135.66,168.85 136.77,169.96 138.21,169.96 v2(138.46,169.71) 139.02,169.71 139.24,169.92 140.72,169.92 141.63,169.02 v2(141.63,168.79)
  BOTTOM w0.102: UV11.P2 144.89,165.97 144.49,166.37 144.04,166.37 143.9,166.52 143.9,166.98 143.48,167.4 142.65,167.4 142.01,168.03 142.01,168.41 v2(141.63,168.79) ; v2(136.02,167.91) 136.02,167.93 135.65,168.3 135.65,168.7 134.97,169.38 134.01,169.38 133.78,169.61 133.78,170.1 133.52,170.36 133.15,170.36 132.74,170.77 UV10.P2 ; UV1.N9 130.17,150.27 v2(129.75,149.86)
MAB6: length 50.9
  TOP w0.102: v2(142.39,168.19) 142.89,167.7 143.12,167.7 143.89,166.93 143.89,166.39 UV12.R8 ; v2(135.27,168.55) 135.05,168.55 133.79,169.81 133.79,170.35 UV9.R8
  IN1 w0.127: v2(135.27,168.55) 135.27,168.78 136.78,170.29 138.69,170.29 v2(138.74,170.24) 138.79,170.24 138.83,170.28 140.72,170.28 142.04,168.96 142.04,168.55 v2(142.39,168.19)
  IN2 w0.102: v2(134.36,150.85) 133.98,151.23 133.98,152.47 134.49,152.98 134.49,156.89 134.69,157.1 134.69,157.31
  IN2 w0.249: 134.69,157.31 134.69,163.08 135.69,164.07 135.69,164.91 136.73,165.95 136.98,165.95 138.1,167.06 138.1,167.32 138.69,167.9 138.69,168.75 138.55,168.89 138.55,169.12 138.91,169.48 139.31,169.48 140.11,170.28 140.11,171.24 139.97,171.39 139.4,171.39 139.23,171.22 139.23,170.65 138.82,170.24 v2(138.74,170.24)
  BOTTOM w0.102: UV1.U9 133.85,150.34 v2(134.36,150.85) ; v2(135.27,168.55) 135.27,168.39 135.64,168.03 135.64,167.68 135.4,167.44 134.98,167.44 134.71,167.17 134.04,167.17 133.76,166.89 133.76,166.36 UV10.R8 ; UV11.R8 143.91,170.38 143.91,169.75 143.81,169.64 143.71,169.64 143.57,169.5 143.45,169.5 143.31,169.64 142.53,169.64 142.05,169.17 142.05,168.71 142.39,168.37 v2(142.39,168.19)
MAB7: length 54.6
  TOP w0.102: v2(140.57,167.29) 140.23,167.63 140.23,168.36 140.43,168.56 140.86,168.56 141.05,168.74 141.05,169.18 142.25,170.38 143.72,170.38 144.11,170.77 UV12.R2 ; UV9.R2 133.37,165.98 133.24,166.11 133.09,166.11 132.95,165.97 132.95,165.72 133.12,165.55 134.51,165.55 135.41,166.46 135.67,166.46 135.91,166.21 136.19,166.21 136.89,166.92 v2(136.89,167.14)
  IN1 w0.127: v2(140.57,167.29) 140.54,167.32 139.82,167.32 139.62,167.12 v2(138.58,167.12) 138.35,167.34 137.57,167.34 137.37,167.14 v2(136.89,167.14)
  IN2 w0.102: v2(134.38,151.57) 134.38,151.31 134.49,151.21 134.69,151.21 134.78,151.3 134.78,151.83 135,152.04 135,152.23 134.91,152.31 134.81,152.31 134.69,152.43 134.69,152.65 134.76,152.72 134.93,152.72 135,152.79 135,153.04 134.91,153.13 134.76,153.13 134.69,153.2 134.69,153.46 134.76,153.53 135.28,153.53 135.35,153.6 135.35,153.87 135.26,153.96 134.75,153.96 134.69,154.02 134.69,154.31 134.74,154.37 135.52,154.37 135.62,154.47 135.62,154.67 135.52,154.77 134.75,154.77 134.69,154.84 134.69,155.15 134.74,155.2 134.87,155.2 134.93,155.27 134.93,155.54 134.85,155.63 134.76,155.63 134.69,155.7 134.69,155.97 134.76,156.04 134.88,156.04 134.94,156.1 134.94,156.39 134.89,156.44 134.76,156.44 134.69,156.51 134.69,156.78 134.77,156.85 135.07,156.85 135.15,156.93 135.15,157.31
  IN2 w0.249: 135.15,157.31 135.15,159.04 135.27,159.16 135.54,159.16 135.68,159.31 135.68,160 135.53,160.16 135.28,160.16 135.15,160.3 135.15,161.03 135.27,161.16 135.54,161.16 135.68,161.3 135.68,162.02 135.54,162.16 135.34,162.16 135.15,162.36 135.15,162.83 135.33,163.01 135.64,163.01 135.79,163.16 135.79,163.54 136.14,163.88 136.14,164.64 136.99,165.5 137.21,165.5 138.13,166.42 138.79,166.42 138.91,166.55 138.91,166.98 138.78,167.12 v2(138.58,167.12)
  BOTTOM w0.102: v2(140.57,167.29) 141.28,166.58 142.41,166.58 142.57,166.43 142.57,166.28 142.15,165.87 142.15,165.75 142.3,165.61 142.47,165.61 142.81,165.95 142.97,165.95 143.34,165.58 144.14,165.58 144.3,165.74 UV11.R2 ; UV10.R2 133.37,171.03 133.47,171.13 133.69,171.13 133.79,171.03 133.79,170.53 133.95,170.37 134.41,170.37 134.95,169.83 135.42,169.83 136.44,168.81 136.44,167.59 v2(136.89,167.14) ; UV1.U8 133.89,151.07 v2(134.38,151.57)
MAB8: length 51.7
  TOP w0.102: v2(140.61,168.18) 140.95,167.84 140.95,167.48 142.87,165.55 143.77,165.55 143.87,165.66 143.87,165.9 143.8,165.97 UV12.T8 ; UV9.T8 135.34,169.6 135.85,169.6 136.65,168.8 136.65,168.41 v2(136.97,168.09)
  IN1 w0.127: v2(136.97,168.09) 136.98,168.08 137.36,168.08 137.71,168.42 v2(139.17,168.42) 139.17,168.42 139.23,168.37 140.42,168.37 v2(140.61,168.18)
  IN2 w0.102: 138.95,157.31 138.73,157.09 138.73,155.48 138.56,155.32 138.56,154.24 137.48,153.15 137.48,150.92 137.35,150.79 v2(136.95,150.79)
  IN2 w0.249: v2(139.17,168.42) 140,168.42 140.16,168.59 140.16,168.84 139.87,169.14 139.87,169.4 141.06,170.58 141.36,170.58 141.9,170.04 141.9,169.71 141.12,168.92 141.12,166.91 140.86,166.64 140.48,166.64 138.41,164.58 138.41,163.87 138.69,163.6 138.69,161.48 139.17,161 139.17,157.53 138.95,157.31
  BOTTOM w0.102: UV11.T8 143.4,170.88 142.69,170.88 142.58,170.77 141.82,170.77 140.28,169.22 140.28,168.82 140.61,168.48 v2(140.61,168.18) ; UV10.T8 136.06,165.97 136.37,166.28 136.37,166.39 136.28,166.48 136.28,166.62 136.42,166.77 136.57,166.77 136.71,166.62 136.91,166.62 137.31,167.02 137.31,167.75 v2(136.97,168.09) ; UV1.Y9 136.43,150.27 v2(136.95,150.79)
MAB9: length 48.1
  TOP w0.102: UV12.R3 144.3,169.95 143.74,169.39 142.92,169.39 v2(142.43,168.9) ; v2(135.26,167.83) 135.26,167.58 134.77,167.09 134.55,167.09 134.3,167.35 134.06,167.35 133.81,167.09 133.52,167.09 133.37,166.94 UV9.R3
  IN1 w0.102: 137.54,167.66 137.41,167.53 135.31,167.53 135.26,167.59 v2(135.26,167.83)
  IN1 w0.127: v2(142.43,168.9) 142.7,168.9 142.81,168.79 142.81,167.88 142.67,167.75 139.24,167.75 v2(139.17,167.82) 139.1,167.75 137.63,167.75 137.54,167.66
  IN2 w0.102: 137.58,157.31 137.58,155.4 137.48,155.3 137.01,155.3 136.91,155.2 136.91,155 137.01,154.89 137.5,154.89 137.58,154.82 137.58,154.58 137.49,154.49 137.05,154.49 136.94,154.38 136.94,153.76 136.51,153.33 136.51,152.01 136.41,151.91 136.14,151.91 136.04,151.8 136.04,151.6 136.14,151.5 136.41,151.5 136.51,151.4 136.51,149.72 136.43,149.64 136.14,149.64 136.05,149.73 136.05,150.8 135.96,150.89 v2(135.57,150.89)
  IN2 w0.249: v2(139.17,167.82) 139.32,167.96 139.54,167.96 139.66,167.83 139.66,167.17 139.37,166.87 139.37,166.17 138.55,165.35 138.36,165.35 138.12,165.59 137.94,165.59 137.1,164.75 137.1,163.56 137.38,163.28 137.38,162.88 137.12,162.62 137.12,161.85 137.58,161.39 137.58,159.74 137.44,159.6 137.29,159.6 137.04,159.35 137.04,158.97 137.27,158.75 137.45,158.75 137.58,158.61 137.58,157.31
  BOTTOM w0.102: v2(142.43,168.9) 142.43,168.8 142.81,168.42 142.81,168.05 143.16,167.7 143.56,167.7 144.3,166.95 UV11.R3 ; UV1.W9 135.05,150.37 v2(135.57,150.89) ; v2(135.26,167.83) 135.26,167.94 134.88,168.32 134.88,168.87 134.57,169.18 133.51,169.18 133.37,169.32 UV10.R3
MAB10: length 54.9
  TOP w0.102: UV9.L7 130.17,169.03 129.69,168.56 v2(129.69,168.55) ; UV12.L7 147.38,166.89 147.38,167.13 147.44,167.19 147.98,167.19 148.15,167.36 148.15,167.52 148.08,167.6 147.46,167.6 147.38,167.67 147.38,167.85 147.72,168.19 v2(147.98,168.19)
  IN1 w0.102: 135.26,164.04 134.92,164.04 134.74,164.22 132.89,164.22 132.49,164.61 132.49,165.04 130.07,167.46 130.07,168.17 v2(129.69,168.55) ; 143,164.26 143.07,164.34 143.48,164.34 143.55,164.4 143.55,164.88 143.21,165.22 143.21,165.33 143.43,165.54 143.71,165.54 143.78,165.47 143.78,165.21 143.85,165.14 144.12,165.14 144.19,165.21 144.19,165.48 144.25,165.54 144.48,165.54 144.53,165.49 144.64,165.49 144.84,165.69 144.84,165.81 145.04,166.01 145.16,166.01 145.37,166.22 145.37,166.34 145.68,166.65 146.07,166.65 146.13,166.6 146.13,166.47 146.18,166.42 146.46,166.42 146.52,166.48 146.52,166.6 146.57,166.65 146.69,166.65 146.9,166.85 146.9,167 147.11,167.21 147.26,167.21 147.46,167.42 147.46,167.56 147.67,167.77 147.81,167.77 147.98,167.94 v2(147.98,168.19)
  IN1 w0.127: 143,164.26 143,163.79 142.9,163.69 v2(140.88,163.69) 140.37,163.69 140.25,163.8 138.96,163.8 138.48,163.33 137.48,163.33 137.22,163.6 136.35,163.6 135.91,164.04 135.26,164.04
  IN2 w0.102: 141.08,157.31 141.08,156.63 140.62,156.17 140.39,156.17 140.15,155.92 140.15,154.59 140.19,154.54 140.19,153.71 139.68,153.2 139.68,151.46 139.57,151.35 v2(139.17,151.35)
  IN2 w0.249: v2(140.88,163.69) 140.88,163.9 141.26,164.28 141.54,164.28 142.26,163.56 142.26,163.31 142.09,163.14 141.26,163.14 141.08,162.96 141.08,162.29 141.23,162.14 141.69,162.14 142.26,161.57 142.26,161.38 142.03,161.15 141.23,161.15 141.08,161 141.08,157.31
  BOTTOM w0.102: v2(129.69,168.55) 129.69,168.41 130.07,168.03 130.07,166.86 UV10.L7 ; UV11.L7 147.33,169.8 147.33,169.7 147.42,169.62 147.91,169.62 148.04,169.49 148.04,169.36 147.96,169.28 147.68,169.28 147.59,169.19 147.59,168.64 147.7,168.53 147.92,168.53 147.98,168.46 v2(147.98,168.19) ; v2(139.17,151.35) 139.05,151.47 138.75,151.47 138.65,151.37 UV1.AC8
MAB11: length 51
  TOP w0.102: v2(143.21,168.19) 143.14,168.13 143.14,167.98 143.42,167.7 143.56,167.7 143.7,167.84 143.87,167.84 143.98,167.72 143.98,167.55 143.84,167.41 143.84,167.26 143.98,167.12 144.12,167.12 144.24,167.24 144.24,167.4 144.31,167.47 144.43,167.47 144.52,167.38 144.52,166.86 144.43,166.77 UV12.R7 ; v2(134.47,168.55) 133.37,169.65 UV9.R7
  IN1 w0.127: v2(143.21,168.19) 143.21,167.82 142.9,167.52 142.22,167.52 142.09,167.39 142.09,167.1 141.63,166.64 141.48,166.64 140.93,166.08 v2(140.61,166.08) 138.94,166.08 138.66,166.36 136.09,166.36 135.01,167.44 134.29,167.44 134.06,167.67 134.06,168.14 v2(134.47,168.55)
  IN2 w0.102: v2(139.16,150.66) 138.87,150.66 138.79,150.75 138.79,152.42 139.37,153 139.37,154.04 139.94,154.61 139.94,156.61 140.36,157.02 140.55,157.02 140.63,157.1 140.63,157.31
  IN2 w0.249: 140.63,157.31 140.63,163.26 140.08,163.81 140.08,164.97 140.25,165.15 141.6,165.15 142.17,165.72 144.51,165.72 144.78,165.99 144.78,166.52 144.48,166.82 141.76,166.82 141.03,166.08 v2(140.61,166.08)
  BOTTOM w0.102: v2(143.21,168.19) 143.21,168.44 143.13,168.52 143,168.52 142.82,168.69 142.82,169.05 142.6,169.27 142.6,169.36 142.68,169.44 143.22,169.44 143.42,169.25 143.62,169.25 143.81,169.44 144.01,169.44 144.3,169.73 UV11.R7 ; v2(134.47,168.55) 134.47,168.38 134.85,168 134.85,167.6 134.66,167.41 133.98,167.41 133.9,167.33 133.85,167.28 133.67,167.28 133.37,166.98 UV10.R7 ; UV1.AC9 138.76,150.27 v2(139.16,150.66)
MAB12: length 48.5
  TOP w0.102: 138.73,156.85 138.73,154.22 137.91,153.4 137.91,152.32 v2(138.09,152.14) ; UV9.N7 132.08,169.66 v2(132.08,168.55) ; v2(145.59,168.19) 145.47,168.07 145.47,166.86 145.56,166.77 UV12.N7
  TOP w0.203: v2(139.59,171.87) 139.67,171.79 v1(139.67,170.75) 139.67,167.57 140.38,166.86 140.38,166.47 140.15,166.24 140.15,164.47 140.1,164.42 140.1,163.82 141.04,162.88 141.04,159.21 138.73,156.89 138.73,156.85
  IN1 w0.127: v2(145.59,168.19) 145.59,168.32 146.01,168.74 146.01,169.06 145.78,169.3 145.31,169.3 144.62,169.98 142.9,169.98 141.01,171.87 v2(139.59,171.87) 139.52,171.94 135.48,171.94 v2(132.08,168.55)
  BOTTOM w0.102: UV1.AA7 137.45,152.24 137.55,152.34 137.88,152.34 v2(138.09,152.14) ; UV11.N7 145.22,169.29 145.22,168.72 145.59,168.36 v2(145.59,168.19) ; UV10.N7 132.44,167.44 132.44,168.03 132.08,168.38 v2(132.08,168.55)
MAB13: length 47.4
  TOP w0.102: v2(136.06,168.53) 135.79,168.53 135.64,168.38 135.64,167.68 134.61,166.65 134.29,166.65 UV9.T3 ; UV12.T3 142.27,169.97 141.25,168.95 141.25,168.51 v2(141.58,168.18)
  IN1 w0.127: v2(136.06,168.53) 136.06,168.44 136.36,168.13 136.46,168.13 136.64,168.31 136.64,168.67 136.32,169 136.32,169.12 136.56,169.36 136.71,169.36 136.96,169.11 137.1,169.11 137.24,169.25 137.24,169.55 137.33,169.63 137.73,169.63 v2(137.84,169.52) 138.08,169.28 139.06,169.28 139.2,169.42 140.84,169.42 141.16,169.09 141.16,168.6 v2(141.58,168.18)
  IN2 w0.102: 134.24,157.31 134.24,153.02 133.78,152.55 133.78,151.04 133.62,150.89 v2(133.26,150.89)
  IN2 w0.249: 134.24,157.31 134.24,163.27 135.23,164.26 135.23,165.16 136.42,166.35 136.74,166.35 137.35,166.95 137.35,167.59 137.49,167.73 137.87,167.73 138.23,168.09 138.23,168.56 138.07,168.73 137.59,168.73 136.99,169.33 136.99,170.17 137.69,170.88 137.91,170.88 138.26,170.52 138.26,170.19 137.98,169.91 137.98,169.66 v2(137.84,169.52)
  BOTTOM w0.102: UV1.T8 133.07,151.07 v2(133.26,150.89) ; v2(136.06,168.53) 136.06,168.9 135.91,169.05 135.67,169.05 135.54,169.17 135.54,169.36 135.31,169.59 134.21,169.59 134.08,169.72 134.08,169.88 UV10.T3 ; v2(141.58,168.18) 141.58,168.03 142.41,167.19 143.08,167.19 UV11.T3
MAB14: length 53.8
  TOP w0.102: v2(135.94,167.15) 136.45,167.66 136.45,168.71 136.21,168.95 135.83,168.95 135.71,169.07 135.33,169.07 135.21,168.95 135.01,168.95 134.17,169.8 UV9.T7 ; v2(135.65,151.59) 136.24,152.17 136.24,153.5 v1(137.36,154.62) 137.54,154.8 137.54,157.27 137.56,157.28 137.56,157.31 ; v2(141.7,167.27) 141.7,167.71 141.82,167.83 142.08,167.83 142.31,167.6 142.31,166.42 142.47,166.25 142.63,166.25 142.71,166.34 142.71,167.33 142.82,167.43 143,167.43 143.1,167.34 143.1,166.45 143.22,166.33 143.4,166.33 143.5,166.43 UV12.T7
  TOP w0.203: 137.56,157.31 137.56,157.98 137.69,158.11 137.69,158.32 137.43,158.58 137.43,158.73 137.86,159.16 137.99,159.16 138.27,158.88 138.46,158.88 139.16,159.59 139.16,159.8 139.01,159.95 138.35,159.95 138.23,160.07 138.23,160.65 138.35,160.77 139.4,160.77 139.56,160.93 139.56,161.5 139.43,161.63 138.78,161.63 138.66,161.75 138.66,162.33 138.78,162.44 139.05,162.44 139.17,162.57 139.17,163.23 139.07,163.33 138.92,163.33 138.82,163.43 138.82,164.02 138.92,164.12 139.26,164.12 139.5,163.88 139.63,163.88 139.76,164.01 139.76,164.74 139.38,165.12 139.38,165.31 139.5,165.44 139.67,165.44 139.81,165.58 139.81,166.05 139.69,166.16 139.39,166.16 139.26,166.29 139.26,166.67 139.38,166.79 139.38,167.03 139.48,167.13 139.63,167.13 139.85,166.91 v2(139.85,166.67)
  IN1 w0.127: v2(135.94,167.15) 136.39,166.69 139.82,166.69 v2(139.85,166.67) 140,166.52 140.38,166.52 140.51,166.65 140.64,166.65 140.78,166.51 140.93,166.51 141.14,166.72 141.14,166.86 140.99,167.01 140.99,167.24 141.22,167.47 141.49,167.47 v2(141.7,167.27)
  BOTTOM w0.102: UV1.W8 135.57,151.59 v2(135.65,151.59) ; UV11.T7 143.38,169.85 143.16,169.85 143.03,169.97 143.03,170.52 142.91,170.64 142.74,170.64 142.62,170.52 142.62,170.19 142.54,170.1 141.7,170.1 141.2,169.6 141.2,167.77 v2(141.7,167.27) ; v2(135.94,167.15) 135.94,166.32 135.86,166.24 135.53,166.24 135.43,166.34 135.43,167.03 135.3,167.15 135.05,167.15 134.93,167.03 134.93,166.3 134.82,166.2 134.62,166.2 134.52,166.3 134.52,166.76 134.39,166.89 134.29,166.89 UV10.T7
MAB15: length 54.3
  TOP w0.102: v2(146.39,168.19) 146.39,167.08 UV12.M7 ; UV9.M7 131.28,169.66 v2(131.28,168.55) ; 136.18,157.31 136.18,154.92 135.11,153.85 v1(135.11,152.21) 135.11,150.47 v2(134.44,149.79)
  TOP w0.203: 136.18,157.31 136.18,158.45 137.54,159.81 137.54,162.14 138.48,163.08 138.48,164.61 138.92,165.05 138.92,166.81 139.03,166.93 139.03,167.31 138.71,167.63 138.71,169.27 139.21,169.77 139.21,171.45 139.14,171.52 139.14,172.22 v2(139.28,172.36)
  IN1 w0.127: v2(146.39,168.19) 146.39,168.32 146.8,168.72 146.8,169.06 146.34,169.52 145.4,169.52 144.71,170.21 143.15,170.21 141.04,172.32 139.31,172.32 v2(139.28,172.36) 135.35,172.36 131.95,168.96 131.69,168.96 v2(131.28,168.55)
  BOTTOM w0.102: v2(131.28,168.55) 131.28,168.39 131.65,168.03 131.65,167.45 UV10.M7 ; v2(146.39,168.19) 146.39,168.34 146.02,168.71 146.02,169.29 UV11.M7 ; UV1.U12 134.44,148.26 v2(134.44,149.79)
MAINPWON: length 154.4
  TOP w0.102: U31.104 165.19,72.97 164.51,72.29 164.51,70.2 v2(165.17,69.54)
  TOP w0.254: PR408.2 103.58,11.96 v3(103.57,11.96) v2(103.57,15.03)
  IN2 w0.127: v2(103.57,15.03) 105.1,16.56 119.93,16.56 121.84,14.65 179.46,14.65 v2(179.83,14.28)
  BOTTOM w0.102: v2(165.17,69.54) 165.17,57.99 168.02,55.13 174.12,55.13 176.51,52.73 176.51,45.77 181.64,40.65 181.64,16.1 v2(179.83,14.28)
MCT: length 24.3
  TOP w0.762: JLAN1.8 14.56,93.16 v1(15.15,92.56) 15.92,91.79 DLL1.2 17.52,90.21 16.52,89.21 RL14.1
  IN1 w0.762: 15.7,83.67 15.7,86.24 JLAN1.4 12.79,89.08 JLAN1.5 11.54,90.32 11.54,91.91 JLAN1.7 12.79,93.16 JLAN1.8
  BOTTOM w0.762: 15.52,81.18 15.52,79.49 16.23,78.79 TL1.11
  vias: v2(15.74,82.11) v2(15.75,82.7)
MDA0: length 27.1
  TOP w0.102: UV5.D7 107.61,128.03 107.61,126.68 107.86,126.44 108.17,126.44 108.44,126.17 108.44,125.19 108.61,125.03 109.01,125.03 109.12,124.92 109.12,124.88
  TOP w0.127: v2(121.7,128.43) 121.7,128.66 121.57,128.79 121.15,128.79 121.03,128.66 121.03,128.42 120.92,128.32 120.63,128.32 120.5,128.45 120.5,128.94 120.38,129.07 120.06,129.07 119.87,128.88 119.87,126.96 115.27,122.36 v1(114.9,122.36) 109.43,122.36 109.12,122.67 109.12,123.87 109,124 108.88,124 108.76,124.13 108.76,124.38 108.88,124.51 109,124.51 109.12,124.64 109.12,124.88
  BOTTOM w0.102: UV1.C37 122.8,128.72 122.65,128.72 122.64,128.73 122.26,128.73 122.26,128.72 121.99,128.72 v2(121.7,128.43)
MDA1: length 27.5
  TOP w0.102: UV5.C8 106.8,127.22 106.8,124.82 106.78,124.79
  TOP w0.127: v2(121.23,126.81) 121.17,126.81 115.17,120.81 v1(113.91,120.81) 109.32,120.81 106.78,123.35 106.78,124.79
  BOTTOM w0.076: 122.07,129.49 122.1,129.51 122.91,129.51 123.03,129.4
  BOTTOM w0.102: UV1.C35 123.03,129.4 ; 120.81,128.44 120.81,128.46 121.84,129.49 122.07,129.49
  BOTTOM w0.127: v2(121.23,126.81) 120.91,126.81 120.81,126.91 120.81,128.44
MDA2: length 27.1
  TOP w0.102: 107.11,124.79 107.11,125.01 107.18,125.09 107.54,125.09 107.61,125.17 107.61,126.26 107.23,126.65 UV5.B8
  TOP w0.127: v2(121.25,127.72) 120.7,127.16 120.7,126.75 115.1,121.16 109.44,121.16 108.46,122.13 108.46,122.36 108.34,122.49 108.11,122.49 107.98,122.61 107.98,122.81 v1(108.11,122.93) 108.34,122.93 108.46,123.06 108.46,123.3 108.31,123.45 107.23,123.45 107.11,123.58 107.11,123.93 107.23,124.06 107.89,124.06 108.02,124.18 108.02,124.44 107.89,124.56 107.23,124.56 107.11,124.69 107.11,124.79
  BOTTOM w0.102: UV1.A35 121.9,129.17 121.25,128.53 v2(121.25,127.72)
MDA3: length 27.9
  TOP w0.127: v2(120.35,127.91) 120.35,126.86 114.99,121.5 114.42,121.5 114.29,121.63 114.29,121.89 114.17,122.02 113.91,122.02 113.78,121.89 113.78,121.61 113.66,121.49 113.4,121.49 113.28,121.61 113.28,121.89 113.15,122.02 112.9,122.02 112.77,121.89 112.77,121.61 112.64,121.49 112.39,121.49 112.26,121.61 112.26,121.89 112.13,122.02 111.88,122.02 111.75,121.89 111.75,121.61 111.63,121.49 111.37,121.49 111.24,121.61 111.24,121.89 111.12,122.02 110.86,122.02 110.74,121.89 110.74,121.63 110.61,121.5 110.36,121.5 110.23,121.63 v1(110.23,121.89) 110.1,122.02 109.9,122.02 109.77,121.89 109.77,121.71 109.65,121.59 109.51,121.59 108.79,122.3 108.79,123.49 108.36,123.92 108.36,124.67 108.03,125.01 UV5.A7
  BOTTOM w0.102: UV1.E34 124.05,129.82 123.95,129.72 121.67,129.72 120.81,128.86
  BOTTOM w0.127: 120.81,128.86 120.35,128.4 v2(120.35,127.91)
MDA4: length 28.8
  TOP w0.102: 114.07,125.43 113.75,125.1 112.03,125.1 111.77,125.37 111.77,125.79 UV5.A2
  TOP w0.127: 114.07,125.43 114.24,125.6 114.24,126.71 114.35,126.81 114.68,126.81 114.78,126.71 114.78,126.36 114.88,126.26 115.17,126.26 115.27,126.36 115.27,126.73 115.37,126.83 115.55,126.83 115.65,126.93 115.65,127.37 115.76,127.47 116.36,127.47 116.47,127.57 116.47,132.03 117.24,132.8 117.24,134.13 117.34,134.24 117.67,134.24 117.77,134.13 v1(117.77,132.55) 117.87,132.45 118.18,132.45 118.28,132.55 118.28,134.11 118.38,134.21 118.8,134.21 118.9,134.11 118.9,133.11 119.03,132.98 123.05,132.98 124.15,131.88 v2(125.2,131.88)
  BOTTOM w0.102: UV1.G32 125.62,131.47 v2(125.2,131.88)
MDA5: length 27.9
  TOP w0.102: UV5.C3 110.99,127.89 110.65,127.89 110.32,127.56 110.32,125.32 110.5,125.14
  TOP w0.127: 110.5,125.14 111.11,124.53 114.52,124.53 117.13,127.14 117.13,129.69 117.25,129.82 118.78,129.82 118.9,129.95 118.9,130.2 118.78,130.33 v1(117.71,130.33) 117.25,130.33 117.13,130.45 117.13,131.56 117.25,131.68 117.56,131.68 117.69,131.56 117.69,130.99 117.81,130.86 119.83,130.86 120.07,131.1 120.83,131.1 121.3,130.63 v2(124.16,130.63)
  BOTTOM w0.127: v2(124.16,130.63) 123.91,130.87 UV1.D33
MDA6: length 28.5
  TOP w0.127: UV5.C2 112.42,127.25 114.07,127.25 114.17,127.35 114.17,127.71 114.27,127.81 114.6,127.81 114.7,127.71 114.7,127.3 114.8,127.2 115.12,127.2 115.22,127.3 115.22,127.75 115.32,127.85 v1(115.78,127.85) 116.03,127.85 116.14,127.95 116.14,128.25 116.03,128.36 115.37,128.36 115.27,128.46 115.27,128.76 115.37,128.86 116.03,128.86 116.14,128.97 116.14,132.2 116.87,132.94 116.87,134.52 116.97,134.62 119.19,134.62 119.29,134.52 119.29,133.45 119.42,133.32 119.67,133.32 119.8,133.45 119.8,134.49 119.93,134.62 120.21,134.62 120.34,134.49 120.34,133.44 120.47,133.31 120.73,133.31 120.86,133.44 120.86,134.4 120.96,134.5 122.71,134.5 v2(124.55,132.66)
  BOTTOM w0.102: v2(124.55,132.66) 124.51,132.62 124.51,131.81 UV1.F32
MDA7: length 28.3
  TOP w0.102: 120.81,131.46 120.82,131.45
  TOP w0.127: UV5.A3 111.11,126.16 110.87,126.16 110.74,126.03 110.74,125.37 111.24,124.86 114.38,124.86 116.8,127.28 116.8,131.89 116.92,132.01 117.98,132.01 118.1,131.89 118.1,131.33 118.23,131.2 118.48,131.2 118.61,131.33 118.61,132.52 118.74,132.65 118.99,132.65 119.12,132.52 119.12,131.33 119.25,131.2 119.53,131.2 119.65,131.33 v1(119.65,131.73) 119.65,132.52 119.78,132.65 120.72,132.65 120.85,132.52 120.85,132.22 120.72,132.09 120.34,132.09 120.21,131.96 120.21,131.59 120.34,131.46 120.81,131.46 ; 120.82,131.45 124.15,131.45 v2(124.43,131.18)
  BOTTOM w0.102: UV1.E32 124.05,131.56 v2(124.43,131.18)
MDA8: length 32
  BOTTOM w0.102: UV1.D31 123.35,132.17 122.72,132.17 122.57,132.31 122.06,132.31 121.82,132.07 121.08,132.07 ; 107.94,125.66 107.94,125.96 UV6.A3
  BOTTOM w0.127: 107.94,125.66 107.94,125.28 108.06,125.16 108.54,125.16 108.67,125.03 108.67,124.78 108.54,124.65 108.06,124.65 107.93,124.52 107.93,124.27 108.06,124.14 108.54,124.14 108.67,124.01 108.67,123.76 108.54,123.63 108.06,123.63 107.94,123.51 107.94,123.28 108.12,123.1 108.55,123.1 108.68,122.97 108.68,122.54 110.86,120.36 v1(112.24,120.36) 117.13,120.36 119.55,122.78 119.55,130.54 121.08,132.07
MDA9: length 32.7
  BOTTOM w0.102: UV1.F30 124.4,133.07 124.17,132.84 124.17,132.23 123.68,131.75 123.68,131.67 123.38,131.37 123.13,131.37 122.89,131.6 122.89,131.7 122.48,132.11 122.15,132.11 121.85,131.81 121.29,131.81 120.81,131.33 ; UV6.A2 107.24,126.05 107.61,125.68 107.61,124.79
  BOTTOM w0.127: 107.61,124.79 107.61,123.15 110.75,120 117.24,120 v1(117.27,120.02) 119.89,122.65 119.89,130.41 120.81,131.33
MDA10: length 32
  BOTTOM w0.102: 120.81,132.27 121.42,132.87 122.85,132.87 UV1.C30 ; UV6.C3 108.07,127.65 109.01,126.71 109.01,124.79
  BOTTOM w0.127: 109.01,124.79 109.01,123.01 110.46,121.56 110.56,121.56 111.02,122.02 111.2,122.02 111.38,121.84 111.38,121.66 v1(110.88,121.16) 110.88,120.98 111.1,120.77 111.28,120.77 111.69,121.17 112.05,121.17 112.53,120.7 117,120.7 119.22,122.92 119.22,130.68 120.81,132.27
MDA11: length 31.7
  BOTTOM w0.102: 109.34,124.79 109.34,126.01 109.27,126.08 109.27,126.94 108.17,128.04 107.62,128.04 UV6.C2 ; UV1.A30 122.28,133.1 121.18,133.1 120.81,132.73
  BOTTOM w0.127: 120.81,132.73 118.89,130.81 118.89,123.05 116.87,121.03 112.67,121.03 111.17,122.53 111.01,122.53 110.71,122.23 110.53,122.23 110.34,122.42 110.34,122.6 110.62,122.88 110.62,123.06 110.44,123.24 110.26,123.24 109.87,122.85 109.69,122.85 109.51,123.03 v1(109.51,123.21) 109.88,123.57 109.88,123.82 109.34,124.35 109.34,124.79
MDA12: length 33
  BOTTOM w0.102: UV6.D7 111.23,128.45 111.65,128.03 112.3,128.03 112.42,127.91 112.42,127.39 112.57,127.24 113.8,127.24 113.86,127.18 113.86,125.13 114.07,124.92 ; 121.53,135.72 121.53,135.73 121.8,135.73 122.01,135.94 122.46,135.94 122.5,135.98 122.98,135.98 123.25,135.71 123.25,135.62 123.68,135.19 124.31,135.19 124.83,134.67 UV1.F28
  BOTTOM w0.127: 114.07,124.92 114.31,124.69 115.82,124.69 115.95,124.81 115.95,133.97 116.66,134.68 116.66,136.87 116.78,136.99 117.06,136.99 117.19,136.87 117.19,136.32 117.33,136.18 117.64,136.18 117.77,136.31 117.77,136.92 117.9,137.04 v1(118.15,137.04) 118.28,136.92 118.28,136.31 118.4,136.18 118.66,136.18 118.79,136.31 118.79,137.04 118.91,137.17 119.17,137.17 119.29,137.04 119.29,136.44 120.01,135.72 121.53,135.72
MDA13: length 32.4
  BOTTOM w0.102: 120.81,135.01 121.01,135.01 121.25,134.77 121.92,134.77 122.33,135.18 122.63,135.18 122.93,134.87 UV1.C28
  BOTTOM w0.127: 120.81,135.01 120.52,135.01 119.92,134.42 118.09,134.42 117.96,134.54 117.96,134.86 118.09,134.99 v1(118.57,134.99) 119.22,134.99 119.35,135.11 119.35,135.39 119.22,135.52 117.52,135.52 117.39,135.39 117.39,133.98 117.52,133.85 118.88,133.85 119.01,133.72 119.01,133.47 118.88,133.34 117.25,133.34 117.13,133.21 117.13,124.27 116.89,124.03 113.85,124.03 112.77,125.1 112.52,125.1 111.98,124.56 111.63,124.56 111.23,124.97 UV6.A7
MDA14: length 32
  BOTTOM w0.102: 120.81,134.68 121.05,134.68 121.17,134.56 122.14,134.56 UV1.A28 ; 110.93,124.79 110.85,124.88 110.85,126.2 111.08,126.44 111.48,126.44 111.64,126.6 111.64,127.49 111.79,127.65 UV6.C8
  BOTTOM w0.127: 120.81,134.68 120.73,134.68 119.01,132.96 117.58,132.96 117.46,132.83 117.46,132.58 117.58,132.45 117.95,132.45 v1(118.08,132.33) 118.08,132.07 117.95,131.95 117.58,131.95 117.46,131.82 117.46,123.87 117.28,123.7 114.5,123.7 114.3,123.5 114.3,122.65 114.17,122.53 113.28,122.53 113.15,122.65 113.15,122.93 113.28,123.06 113.6,123.06 113.72,123.19 113.72,123.57 113.6,123.7 113.05,123.7 112.64,123.29 112.44,123.29 112.25,123.48 112.25,123.65 112.9,124.3 112.9,124.48 112.72,124.66 112.54,124.66 111.89,124.01 111.71,124.01 110.93,124.79
MDA15: length 32.8
  BOTTOM w0.102: UV6.B8 112.29,126.85 112.43,126.71 112.43,125.91 112.66,125.67 113.35,125.67 113.46,125.56 113.46,124.89 113.55,124.79 ; 120.81,135.34 120.96,135.34 121.33,134.97 121.83,134.97 122.24,135.38 122.71,135.38 122.88,135.21 123.36,135.21 123.7,134.87 UV1.E28
  BOTTOM w0.127: 113.55,124.79 113.99,124.36 116.49,124.36 116.8,124.66 116.8,125.06 116.67,125.19 116.4,125.19 116.28,125.31 116.28,125.57 116.4,125.69 116.67,125.69 116.8,125.82 116.8,126.07 116.67,126.2 116.4,126.2 116.28,126.33 116.28,126.58 116.4,126.71 116.67,126.71 116.8,126.84 116.8,127.09 116.67,127.22 116.42,127.22 116.29,127.34 116.29,127.6 116.42,127.73 116.67,127.73 116.8,127.85 116.8,128.11 116.67,128.23 116.4,128.23 116.28,128.36 116.28,128.61 116.4,128.74 116.67,128.74 116.8,128.87 116.8,129.12 116.67,129.25 v1(116.56,129.25) 116.42,129.25 116.29,129.38 116.29,129.63 116.42,129.76 116.67,129.76 116.8,129.88 116.8,130.14 116.67,130.27 116.42,130.27 116.29,130.39 116.29,130.65 116.42,130.77 116.67,130.77 116.8,130.9 116.8,131.15 116.67,131.28 116.42,131.28 116.29,131.41 116.29,131.66 116.42,131.79 116.67,131.79 116.8,131.92 116.8,132.17 116.67,132.3 116.42,132.3 116.29,132.42 116.29,132.68 116.42,132.81 116.67,132.81 116.8,132.93 116.8,133.19 116.67,133.32 116.42,133.32 116.29,133.45 116.29,133.7 116.42,133.83 116.85,133.83 116.99,133.97 116.99,135.72 117.11,135.85 119.36,135.85 119.68,135.53 119.68,135.21 119.81,135.08 120.12,135.08 120.38,135.34 120.81,135.34
MDA16: length 34.6
  TOP w0.102: UV5.H7 108.03,131.61 v2(108.42,131.22)
  IN2 w0.102: v2(108.42,131.22) 108.02,130.82 107.44,130.82 107.24,130.62 107.24,127.29 109.53,124.99
  IN2 w0.157: v2(124.16,135.58) 123.36,134.78 123.36,127.96 120.06,124.66 117.44,124.66 117.32,124.79 117.32,125.18 117.19,125.31 116.81,125.31 116.69,125.18 116.69,124.79 116.56,124.66 116.2,124.66 116.04,124.82 116.04,125.28 115.92,125.41 115.53,125.41 115.4,125.28 115.4,124.79 115.27,124.66 109.87,124.66 109.53,124.99
  BOTTOM w0.102: UV1.D27 124.07,135.67 v2(124.16,135.58)
MDA17: length 35.3
  TOP w0.102: v2(107.63,132.05) 107.23,131.65 UV5.H8
  IN2 w0.102: v2(107.63,132.05) 107.22,131.63 107.22,131.08 106.97,130.83 106.69,130.83 106.44,130.58 106.44,127.43 108.16,125.71
  IN2 w0.157: v2(124.39,136.1) 124.57,135.93 124.57,135.41 123.75,134.59 123.75,129.52 123.76,129.51 123.76,127.7 120.25,124.2 109.67,124.2 108.16,125.71
  BOTTOM w0.102: v2(124.39,136.1) 124.56,136.27 UV1.F26
MDA18: length 34.6
  TOP w0.102: UV5.F8 v2(107.62,129.65)
  IN2 w0.102: v2(107.62,129.65) 107.62,129.44 108.03,129.04 108.03,127.72 108.9,126.84 108.9,126.83
  IN2 w0.157: v2(123.65,136.18) 123.65,136.45 123.57,136.53 123.25,136.53 123.12,136.41 123.12,135.36 123.02,135.25 123.02,128.27 122.05,127.3 121.03,127.3 120.46,126.74 119.92,126.74 119.79,126.61 119.79,125.26 119.67,125.13 119.25,125.13 119.12,125.26 119.12,126.61 118.99,126.74 118.57,126.74 118.45,126.61 118.45,125.28 118.32,125.16 117.89,125.16 117.77,125.28 117.77,125.84 117.64,125.97 115.41,125.97 114.7,125.26 113.88,125.26 113.72,125.1 110.12,125.1 109.06,126.16 109.06,126.67 108.9,126.83
  BOTTOM w0.102: v2(123.65,136.18) 123.36,136.47 UV1.C26
MDA19: length 34.3
  TOP w0.127: v2(107.63,130.4) 108.01,130.01 108.06,130.01 UV5.F7
  IN2 w0.102: 109.03,128.13 109.03,128.8 108.61,129.22 108.2,129.22 108.03,129.38 108.03,129.99 v2(107.63,130.4)
  IN2 w0.157: 109.03,128.13 109.03,127.23 110.28,125.98 114.04,125.98 114.08,126.02 114.68,126.02 115.1,126.44 116.4,126.44 116.56,126.6 116.56,127.77 116.69,127.9 117.06,127.9 117.19,127.77 117.19,126.6 117.35,126.44 117.79,126.44 117.95,126.6 117.95,127.73 118.05,127.84 118.49,127.84 118.59,127.73 118.59,127.33 118.71,127.2 119.17,127.2 119.3,127.33 119.3,127.73 119.4,127.84 119.81,127.84 119.91,127.73 119.91,127.33 120.04,127.2 120.26,127.2 120.81,127.75 120.81,128.12 121.54,128.85 122.02,128.85 122.12,128.75 122.12,128.58 122.26,128.45 122.61,128.45 122.76,128.59 122.76,135.53 v2(121.97,136.32)
  BOTTOM w0.102: UV1.A26 122.09,136.47 121.97,136.35 v2(121.97,136.32)
MDA20: length 35.5
  TOP w0.127: UV5.G2 112.03,130.58 111.89,130.45 v2(111.62,130.45)
  IN2 w0.102: v2(124.42,137.62) 124.42,137.87 124.09,138.2 123.44,138.2 123.23,137.99 123.23,137.47 123.12,137.36 122.44,137.36 122.36,137.44 122.36,137.91 122.28,137.98 121.34,137.98 121.11,137.75 120.81,137.75 ; v2(111.62,130.45) 111.62,130.15 111.72,130.06 111.91,130.06 112.01,130.16 112.01,132.29 111.89,132.42 111.61,132.42 111.49,132.55 111.49,132.8 111.61,132.93 111.97,132.93 112.1,133.06 112.1,133.26 111.97,133.39 111.61,133.39 111.49,133.51 111.49,135.53 111.61,135.66 111.84,135.66 111.97,135.53 111.97,133.83 112.1,133.7 112.39,133.7 112.52,133.83 112.52,134.83 112.64,134.96 112.88,134.96 113.01,134.83 113.01,134.2 113.14,134.07 113.51,134.07 113.63,134.2 113.63,135.11 113.75,135.23 113.91,135.23 114.04,135.1 114.04,134.34 114.07,134.3
  IN2 w0.157: 120.81,137.75 120.11,137.75 119.18,136.83 115.8,136.83 115.58,136.6 115.58,136.27 115.7,136.14 116.37,136.14 116.52,135.98 116.52,135.67 116.37,135.51 114.77,135.51 114.64,135.38 114.64,134.97 114.77,134.85 115.54,134.85 115.67,134.72 115.67,134.4 115.54,134.27 114.1,134.27 114.07,134.3
  BOTTOM w0.102: UV1.F24 124.85,137.95 124.73,138.08 124.53,138.08 124.42,137.96 v2(124.42,137.62)
MDA21: length 34.8
  TOP w0.102: UV5.H3 111.23,131.79 111.1,131.91 110.57,131.91 110.21,131.54 110.21,130.95 109.85,130.59 109,130.59 108.87,130.46 108.87,129.98 109,129.85 109.58,129.85 109.71,129.73 109.71,128.33 109.84,128.2 110.14,128.2 110.29,128.36 110.29,130.39 110.85,130.95 v2(110.85,131.25)
  IN2 w0.102: v2(110.85,131.25) 111.13,131.25 111.2,131.32 111.2,135.57 111.36,135.73 111.36,136.32 111.49,136.45 111.7,136.45 111.83,136.32 111.83,135.99 111.96,135.86 112.24,135.86 112.36,135.99 112.36,137 112.49,137.13 112.72,137.13 112.85,137 112.85,135.73 112.96,135.62 114.07,135.62 ; 120.81,138.21 120.94,138.21 121.17,138.45 121.38,138.45 121.64,138.19 122.76,138.19 122.85,138.1 v2(122.85,137.77)
  IN2 w0.157: 120.81,138.21 119.29,138.21 119.15,138.07 119.15,137.45 118.98,137.29 115.61,137.29 115.12,136.79 115.12,136.18 114.9,135.97 114.57,135.97 114.22,135.62 114.07,135.62
  BOTTOM w0.102: UV1.C24 123.4,138.07 123.47,138.14 123.59,138.14 123.72,138.27 123.72,138.42 123.61,138.53 122.89,138.53 122.77,138.4 122.77,137.85 v2(122.85,137.77)
