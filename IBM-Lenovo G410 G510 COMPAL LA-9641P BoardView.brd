# Allegro board IBM-Lenovo G410 G510 COMPAL LA-9641P BoardView.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
MDU1511RH_POWERDFN56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
MDU1516URH_POWERDFN56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
MIC_WM-64PCY_2P
  round 1.626 hole 0.61: 1(0,0) 2(-1.9,0)
MT41J128M16JT-093_FBGA_96P_A39
  round 0.445 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A7(4.801,0) A8(5.601,0) A9(6.401,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B7(4.801,-0.8) B8(5.601,-0.8) B9(6.401,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C7(4.801,-1.6) C8(5.601,-1.6) C9(6.401,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D7(4.801,-2.4) D8(5.601,-2.4) D9(6.401,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E7(4.801,-3.2) E8(5.601,-3.2) E9(6.401,-3.2) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M7(4.801,-8.801) M8(5.601,-8.801) M9(6.401,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N7(4.801,-9.601) N8(5.601,-9.601) N9(6.401,-9.601) P1(0,-10.401) P2(0.8,-10.401) P3(1.6,-10.401) P7(4.801,-10.401) P8(5.601,-10.401) P9(6.401,-10.401) R1(0,-11.201) R2(0.8,-11.201) R3(1.6,-11.201) R7(4.801,-11.201) R8(5.601,-11.201) R9(6.401,-11.201) T1(0,-12.002) T2(0.8,-12.002) T3(1.6,-12.002) T7(4.801,-12.002) T8(5.601,-12.002) T9(6.401,-12.002)
  round 0.343 smd: F1(0,-4) F2(0.8,-4) F3(1.6,-4) F7(4.801,-4) F8(5.601,-4) F9(6.401,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G7(4.801,-4.801) G8(5.601,-4.801) G9(6.401,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H7(4.801,-5.601) H8(5.601,-5.601) H9(6.401,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J7(4.801,-6.401) J8(5.601,-6.401) J9(6.401,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K7(4.801,-7.201) K8(5.601,-7.201) K9(6.401,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L7(4.801,-8.001) L8(5.601,-8.001) L9(6.401,-8.001)
MURAT_BLM18PG181SN1D_L0603_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_LQM18FN4R7M00D_2P
  rect 0.559x1.041 smd: 1(0,0) 2(1.3,0)
MX25L1605AM2C-12G_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
NC7SZ08P5X_NL_SC70-5
  oval 0.457x0.711 smd: 1(-0.65,-0.925) 2(0,-0.925) 3(0.65,-0.925) 4(0.65,0.925) 5(-0.65,0.925)
NCP81103MNTWG_QFN36_5X5
  oval 0.203x1.041 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 19(3.2,4.95) 20(2.8,4.95) 21(2.4,4.95) 22(2,4.95) 23(1.6,4.95) 24(1.2,4.95) 25(0.8,4.95) 26(0.4,4.95) 27(0,4.95)
  oval 1.041x0.203 smd: 10(4.075,0.875) 11(4.075,1.275) 12(4.075,1.675) 13(4.075,2.075) 14(4.075,2.475) 15(4.075,2.875) 16(4.075,3.275) 17(4.075,3.675) 18(4.075,4.075) 28(-0.875,4.075) 29(-0.875,3.675) 30(-0.875,3.275) 31(-0.875,2.875) 32(-0.875,2.475) 33(-0.875,2.075) 34(-0.875,1.675) 35(-0.875,1.275) 36(-0.875,0.875)
  rect 3.505x3.505 smd: 37(1.6,2.475)
NCP81151MNTBG_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.194x0.787 smd: 9(0.75,1.1)
PJDLC05_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PMV65XP_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PSOT24C_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R0805_0OHM
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.445x0.445 smd: 1(0,0) 4(5.004,0)
  custom 0.114x0.114 smd: 2(1.194,0) 3(3.81,0)
RB715F_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
RB751V-40_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.14,0)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RP_1206_10P8R
  oval 0.356x0.914 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(2.6,1.422) 7(1.95,1.422) 8(1.3,1.422) 9(0.65,1.422) 10(0,1.422)
RT8207MZQW_WQFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
RTD2132S-GR_QFN32_5X5
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 17(3.5,4.95) 18(3,4.95) 19(2.5,4.95) 20(2,4.95) 21(1.5,4.95) 22(1,4.95) 23(0.5,4.95) 24(0,4.95)
  oval 1.041x0.254 smd: 9(4.225,0.725) 10(4.225,1.225) 11(4.225,1.725) 12(4.225,2.225) 13(4.225,2.725) 14(4.225,3.225) 15(4.225,3.725) 16(4.225,4.225) 25(-0.725,4.225) 26(-0.725,3.725) 27(-0.725,3.225) 28(-0.725,2.725) 29(-0.725,2.225) 30(-0.725,1.725) 31(-0.725,1.225) 32(-0.725,0.725)
  rect 3.353x3.353 smd: 33(1.75,2.475)
SANTA_130456-121_8P
  round 1.295 hole 0.889: 1(0,0) 2(1.02,1.1) 3(2.04,0) 4(3.06,1.1) 5(4.08,0) 6(5.1,1.1) 7(6.12,0) 8(7.14,1.1)
  oval 1.473x3.15 hole 0.711x2.388: 9(-5.955,-6.42) 10(13.095,-6.42)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SINGA_2SJ2352-000131F_6P
  oval 1.194x1.803 hole 0.61x1.194: 1(0,0) 2(11.8,0) 3(0,-5.57) 4(0,-8) 5(11.8,-2.5) 6(11.8,-8)
SSM3K7002FU_SC70-3
  oval 0.508x0.991 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
SUYIN_100042GR019M23DZL_19P-T
  round 0.813 hole 0.508: 1(0,0) 2(0.5,1.55) 3(1,0) 4(1.5,1.55) 5(2,0) 6(2.5,1.55) 7(3,0) 8(3.5,1.55) 9(4,0) 10(4.5,1.55) 11(5,0) 12(5.5,1.55) 13(6,0) 14(6.5,1.55) 15(7,0) 16(7.5,1.55) 17(8,0) 18(8.5,1.55) 19(9,0)
  oval 1.651x2.362 hole 0.889x1.6: 20(-2.75,1.7) 21(11.75,1.7)
  rect 1.854x2.896 hole 0.889x1.6: 22(13.65,-7.75)
  rect 1.854x3.505 hole 0.889x1.6: 23(-4.65,-6.5)
SUYIN_127043FB022G278ZR_22P
  round 1.092 hole 1.092 unplated: (-31.471,-2.6) (-0.281,-2.6)
  oval 0.889x2.388 smd: 1(0,0) 2(-1.27,0) 3(-2.54,0) 4(-3.81,0) 5(-5.08,0) 6(-6.35,0) 7(-7.62,0) 8(-13.97,0) 9(-15.24,0) 10(-16.51,0) 11(-17.78,0) 12(-19.05,0) 13(-20.32,0) 14(-21.59,0) 15(-22.86,0) 16(-24.13,0) 17(-25.4,0) 18(-26.67,0) 19(-27.94,0) 20(-29.21,0) 21(-30.48,0) 22(-31.75,0)
  round 5.994 hole 2.311: 23(4.124,-1.85) 24(-35.876,-1.85)
SUYIN_200082GR007M229ZR_7P-T
  round 1.194 hole 1.194 unplated: (-1.275,2.8) (15.275,2.8)
  round 1.6 hole 0.991: 1(0,0) 2(2,0) 3(6,0) 4(8,0) 5(10,0) 6(12,0) 7(14,0)
  custom 1.442x1.442 hole 2.108: 8(-3.5,0.75) 9(17.5,0.75)
SW_TJG-533-V-T-R_6P
  rect 0.61x0.991 smd: 1(0,0) 2(0,-4.4) 3(-3.7,0) 4(-3.7,-4.4)
  rect 0.457x1.397 smd: 5(0.675,-2.2) 6(-4.375,-2.2)
SY8032ABC_SOT23-6
  oval 0.61x0.991 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0.95,2.4) 6(0,2.4)
SY8208BQNC_QFN10_3X3
  oval 0.254x0.61 smd: 1(0,0) 2(0.45,0) 3(0.9,0) 4(1.35,0) 5(1.8,0) 6(2.25,0)
  rect 1.168x0.254 smd: 7(2.19,-0.675)
  rect 0.914x2.007 smd: 8(2.065,-2)
  custom 0.482x0.482 smd: 9(1.125,-1.775)
  rect 0.787x1.143 smd: 10(0.113,-1.6)
SY8208CQNC_QFN10_3X3
  oval 0.254x0.61 smd: 1(0,0) 2(0.45,0) 3(0.9,0) 4(1.35,0) 5(1.8,0) 6(2.25,0)
  rect 1.168x0.254 smd: 7(2.19,-0.675)
  rect 0.914x2.007 smd: 8(2.065,-2)
  custom 0.482x0.482 smd: 9(1.077,-1.775)
  rect 0.813x1.168 smd: 10(0.137,-1.587)
SY8208DQNC_QFN10_3X3
  oval 0.254x0.61 smd: 1(0,0) 2(0.45,0) 3(0.9,0) 4(1.35,0) 5(1.8,0) 6(2.25,0)
  rect 1.168x0.254 smd: 7(2.19,-0.675)
  rect 0.914x2.007 smd: 8(2.065,-2)
  custom 0.482x0.482 smd: 9(1.077,-1.775)
  rect 0.813x1.168 smd: 10(0.137,-1.587)
TAI-T_HCB2012KF-121T50_2P
  rect 0.991x0.991 smd: 1(0,0) 2(2,0)
TAI-T_VMPI0703AR-100M-Z01_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
TAI-T_VMPI1004AR-R36M-Z03_4P
  custom 0.876x0.876 smd: 1(0,0) 4(13.411,0)
  rect 2.997x0.508 smd: 2(2.007,0) 3(11.405,0)
TAITW_PUBAU1-09FNLSCNN4H0_9P
  round 1.295 hole 0.711: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.397x3.2 hole 0.787x2.591: 10(4.35,-2.38) 13(-11.35,-2.38)
  oval 1.397x2.489 hole 0.787x1.905: 11(4.35,-9.48) 12(-11.35,-9.48)
TPC12
  round 0.305 smd: 1(0,0)
TPCA8059-H_PPAK56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
TPCA8065-H_PPAK56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
TPD7S019-15DBQR_SSOP16
  oval 0.381x1.651 smd: 1(0,0) 2(0.635,0) 3(1.27,0) 4(1.905,0) 5(2.54,0) 6(3.175,0) 7(3.81,0) 8(4.445,0) 9(4.445,5.355) 10(3.81,5.355) 11(3.175,5.355) 12(2.54,5.355) 13(1.905,5.355) 14(1.27,5.355) 15(0.635,5.355) 16(0,5.355)
TPS51219RTER_QFN16_3X3
  oval 0.254x1.016 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 9(1.5,2.975) 10(1,2.975) 11(0.5,2.975) 12(0,2.975)
  oval 1.016x0.254 smd: 5(2.238,0.738) 6(2.238,1.238) 7(2.238,1.738) 8(2.238,2.238) 13(-0.738,2.238) 14(-0.738,1.738) 15(-0.738,1.238) 16(-0.738,0.738)
  rect 1.702x1.702 smd: 17(0.75,1.488)
Y_CM31532768DZFT_2P
  rect 1.092x1.905 smd: 1(0,0) 2(2.5,0)
Y_X3G025000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
YSCLAMP0524P_SLP2510P8-10-9
  oval 0.203x0.686 smd: 1(0,0) 2(0.5,0) 4(1.5,0) 5(2,0) 6(2,0.875) 7(1.5,0.875) 8(0.5,0.875) 9(0,0.875)
  oval 0.406x1.549 smd: 3(1,0.438)

## Nets
0.95V_EN: PC638.2 PR612.2 PR616.2 PU604.1
1.05V_EN: PC701.1 PR701.2 PR702.2 PR706.2 PU701.14
1.05VS_EN: PR702.1 U31.108
1.05VSP_B+: PC711.1 PC712.1 PC713.1 PC715.1 PL702.1 PQ701.5 PQ701.6 PQ701.7 PQ701.8
1.35V_B+: PC501.1 PC509.1 PC513.1 PC520.1 PL502.1 PQ501.5 PR509.1
1.35V_SN: PC517.1 PR515.2
3V5V_EN: PC431.1 PR407.1 PR408.1 PR409.1 PR410.1 PU402.1
3V_SN: PC415.1 PR404.2
3V_VIN: PC403.1 PC404.1 PC405.1 PC406.1 PC433.1 PL401.2 PU401.8
3VALW_EN: PC432.1 PR410.2 PU401.1
5V_SN: PC429.1 PR406.2
5V_VCC: PC422.1 PU402.5
5V_VIN: PC416.1 PC417.1 PC418.1 PC420.1 PC434.1 PL403.2 PU402.8
5VS_GATE: Q110.1 R646.2 R649.2
5VS_GATE_R: C726.1 R649.1 U38.4
+0.95VGS: CV54.1 CV55.1 CV56.1 CV80.1 CV81.1 CV82.1 CV83.1 CV84.1 CV85.1 CV86.1 CV87.1 CV88.1 LV6.1 PJ606.1 RV1.2 RV3.2 UV1.AK33 UV1.AK34 UV1.AL33 UV1.AM33 UV1.AN31 UV1.AN33 UV1.AP31 UV1.AP32 UV1.AP33 UV1.G30 UV1.G31 UV1.H29 UV1.H30 UV1.J29 UV1.J30 UV1.L28 UV1.M28 UV1.N27 UV1.N28 UV1.R28 UV1.T27 UV1.T28 UV1.U28
+0.95VGSP: PC622.1 PC629.1 PC631.1 PC633.1 PC635.1 PJ606.2 PL605.2 PR611.1
+0.675VS: C82.1 C83.1 C84.1 C85.1 C104.1 C105.1 C106.1 C107.1 JDIMM1.203 JDIMM1.204 JDIMM2.203 JDIMM2.204 PJ506.1
+0.675VSP: PC504.1 PC505.1 PJ506.2 PU501.2 PU501.20
+1.05V_+1.5V_RUN: C140.1 R214.2 R291.1 U4.AF34 U4.AK26 U4.AK28 U4.AN11 U4.AW40 U4.BB44 U4.BE22
+1.5VGS: CV49.1 CV60.1 CV61.1 CV66.1 CV67.1 CV68.1 CV69.1 CV70.1 CV71.1 CV72.1 CV73.1 CV74.1 CV75.1 CV76.1 CV77.1 CV78.1 CV79.1 CV105.1 CV106.1 CV107.1 CV108.1 CV109.1 CV112.1 CV113.1 CV115.1 CV116.1 CV117.1 CV118.1 CV119.1 CV120.1 CV121.1 CV122.1 CV124.1 CV125.1 CV128.1 CV129.1 CV130.1 CV132.1 CV134.1 CV135.1 CV136.1 CV138.1 CV139.1 CV141.1 CV144.1 CV145.1 CV146.1 CV147.1 CV148.1 CV152.1 CV154.1 CV155.1 CV156.1 CV158.1 CV159.1 CV160.1 CV161.1 CV162.1 CV164.1 CV165.1 CV166.1 CV167.1 CV168.1 CV169.1 CV170.1 CV171.1 CV174.1 CV175.1 CV176.1 CV177.1 CV178.1 CV179.1 CV181.1 CV183.1 CV184.1 CV185.1 CV186.1 CV187.1 CV188.1 CV189.1 CV190.1 CV191.1 CV192.1 CV193.1 CV194.1 RV39.2 RV48.1 RV49.1 RV50.1 RV51.1 RV52.1 RV62.1 RV63.1 RV67.1 RV68.1 RV74.1 RV75.1 RV78.1 RV80.1 UV1.AC7 UV1.AD11 UV1.AF7 UV1.AG10 UV1.AJ7 UV1.AK8 UV1.AL9 UV1.G11 UV1.G14 UV1.G17 UV1.G20 UV1.G23 UV1.G26 UV1.G29 UV1.H10 UV1.J7 UV1.J9 UV1.K8 UV1.K11 UV1.K13 UV1.L7 UV1.L12 UV1.L16 UV1.L21 UV1.L23 UV1.L26 UV1.M11 UV1.N11 UV1.P7 UV1.R11 UV1.U7 UV1.U11 UV1.Y7 UV1.Y11 UV4.1 UV4.2 UV4.3 UV5.A1 UV5.A8 UV5.B2 UV5.C1 UV5.C9 UV5.D2 UV5.D9 UV5.E9 UV5.F1 UV5.G7 UV5.H2 UV5.H9 UV5.K2 UV5.K8 UV5.N1 UV5.N9 UV5.R1 UV5.R9 UV6.A1 UV6.A8 UV6.B2 UV6.C1 UV6.C9 UV6.D2 UV6.D9 UV6.E9 UV6.F1 UV6.G7 UV6.H2 UV6.H9 UV6.K2 UV6.K8 UV6.N1 UV6.N9 UV6.R1 UV6.R9 UV7.A1 UV7.A8 UV7.B2 UV7.C1 UV7.C9 UV7.D2 UV7.D9 UV7.E9 UV7.F1 UV7.G7 UV7.H2 UV7.H9 UV7.K2 UV7.K8 UV7.N1 UV7.N9 UV7.R1 UV7.R9 UV8.A1 UV8.A8 UV8.B2 UV8.C1 UV8.C9 UV8.D2 UV8.D9 UV8.E9 UV8.F1 UV8.G7 UV8.H2 UV8.H9 UV8.K2 UV8.K8 UV8.N1 UV8.N9 UV8.R1 UV8.R9 UV9.A1 UV9.A8 UV9.B2 UV9.C1 UV9.C9 UV9.D2 UV9.D9 UV9.E9 UV9.F1 UV9.G7 UV9.H2 UV9.H9 UV9.K2 UV9.K8 UV9.N1 UV9.N9 UV9.R1 UV9.R9 UV10.A1 UV10.A8 UV10.B2 UV10.C1 UV10.C9 UV10.D2 UV10.D9 UV10.E9 UV10.F1 UV10.G7 UV10.H2 UV10.H9 UV10.K2 UV10.K8 UV10.N1 UV10.N9 UV10.R1 UV10.R9 UV11.A1 UV11.A8 UV11.B2 UV11.C1 UV11.C9 UV11.D2 UV11.D9 UV11.E9 UV11.F1 UV11.G7 UV11.H2 UV11.H9 UV11.K2 UV11.K8 UV11.N1 UV11.N9 UV11.R1 UV11.R9 UV12.A1 UV12.A8 UV12.B2 UV12.C1 UV12.C9 UV12.D2 UV12.D9 UV12.E9 UV12.F1 UV12.G7 UV12.H2 UV12.H9 UV12.K2 UV12.K8 UV12.N1 UV12.N9 UV12.R1 UV12.R9
+1.05VS: C129.1 C130.1 C131.1 C132.1 C134.1 C137.1 C138.1 C139.1 C143.1 C144.1 C145.1 C146.1 C147.1 C153.1 C159.1 LH2.1 PJ701.1 R78.2 R88.2 R258.2 R297.2 R299.2 R300.1 R595.2 R659.1 RP19.4 U4.AA18 U4.AA24 U4.AA26 U4.AD20 U4.AD22 U4.AD24 U4.AD26 U4.AD28 U4.AE18 U4.AE20 U4.AE22 U4.AE24 U4.AE26 U4.AG18 U4.AG20 U4.AG22 U4.AG24 U4.AK18 U4.AK20 U4.AK22 U4.AM18 U4.AM20 U4.AM22 U4.AN34 U4.AN35 U4.AP22 U4.AR22 U4.AT22 U4.L17 U4.R18 U4.U18 U4.U20 U4.U22 U4.U24 U4.U30 U4.U35 U4.U36 U4.V18 U4.V20 U4.V22 U4.V24 U4.V28 U4.V30 U4.Y18 U4.Y20 U4.Y22 U4.Y26 U4.Y30
+1.5VS: CV48.1 JWLN1.6 JWLN1.28 JWLN1.48 LH1.1 PJ602.1 R107.2 R135.1 R145.2 R244.1 R291.2 R655.1 U4.AM45 U4.AT45 U4.BD4 U4.BE16 U4.BE30 UV4.5 UV4.6 UV4.7 UV4.8
+1.5VS_PWRGD: PR602.1 PU601.2 R406.2
+1.05VSP: PC714.1 PJ701.2 PL701.2 PR707.1 PR709.2
+1.5VSP: PC607.1 PC608.1 PC609.1 PC610.1 PC611.1 PC612.1 PJ602.2 PL601.2 PR607.1
+1.8V_EN: PC619.1 PD601.2 PR623.2 PR626.1 PU603.1
+1.8V_FB: PC625.1 PR624.2 PR625.2 PU603.6
+1.8V_LX: PL604.1 PR614.1 PU603.3
+1.8V_SNUB: PC613.1 PR614.2
+1.8V_VIN: PC626.1 PJ605.2 PU603.4
+1.8VGS: LV1.2 LV2.2 LV3.1 LV4.1 LV5.1 LV7.1 LV8.1 LV10.1 PJ603.1 RV13.2 RV20.1 RV21.1 RV22.1 RV23.1 RV43.1
+1.8VGSP: PC618.1 PC620.1 PC625.2 PJ603.2 PL604.2 PR625.1
+1.35V: C69.1 C70.1 C71.1 C72.1 C73.1 C74.1 C75.1 C76.1 C77.1 C78.1 C79.1 C80.1 C81.1 C92.1 C94.1 C95.1 C96.1 C97.1 C98.1 C99.1 C100.1 C101.1 C102.1 C103.1 C185.1 J1.1 JDIMM1.75 JDIMM1.76 JDIMM1.81 JDIMM1.82 JDIMM1.87 JDIMM1.88 JDIMM1.93 JDIMM1.94 JDIMM1.99 JDIMM1.100 JDIMM1.105 JDIMM1.106 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM2.75 JDIMM2.76 JDIMM2.81 JDIMM2.82 JDIMM2.87 JDIMM2.88 JDIMM2.93 JDIMM2.94 JDIMM2.99 JDIMM2.100 JDIMM2.105 JDIMM2.106 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 PJ504.1 PJ505.1 R40.1 RP18.2 RP18.3
+1.35V_CPU_VDDQ: C54.1 C55.1 C56.1 C57.1 C58.1 C59.1 C60.1 C61.1 C62.1 C63.1 C64.1 J1.2 JCPU1.AB2 JCPU1.AB5 JCPU1.AB8 JCPU1.AB11 JCPU1.AE2 JCPU1.AE5 JCPU1.AE8 JCPU1.AE11 JCPU1.AH11 JCPU1.K11 JCPU1.N8 JCPU1.N11 JCPU1.T2 JCPU1.T5 JCPU1.T8 JCPU1.T11 JCPU1.W2 JCPU1.W5 JCPU1.W8 JCPU1.W11 R30.1
+1.35VP: PC522.1 PJ503.2 PJ504.2 PJ505.2 PL501.1 PR507.1 PU501.5
+3V_HDD: JHDD1.8 JHDD1.9 JHDD1.10 R552.2
+3V_LAN: CL8.1 CL10.1 CL12.2 CL13.1 CL14.1 CL15.1 CL16.1 J10.2 QL1.1 RL4.1 RL9.1 RL10.2 RL11.1 UL1.1 UL1.16
+3V_LDO: PC213.1 PU201.5 PU202.5
+3V_PCH: C35.1 C136.1 C152.1 C154.1 C160.1 C162.1 C780.1 C783.1 PJ1.1 Q121.1 R28.1 R29.1 R100.2 R105.2 R106.1 R119.1 R121.1 R173.1 R177.1 R181.2 R191.1 R201.2 R216.1 R221.1 R222.1 R226.2 R227.2 R252.1 R253.1 R256.1 R261.1 R272.1 R273.1 R311.1 R777.1 RA2.1 RA4.1 RP9.1 RP9.2 RP9.3 RP9.4 RP10.1 RP10.3 RP10.4 RP14.5 RP14.10 RP16.1 RP16.4 RP17.3 RP17.4 U1.5 U4.A26 U4.AJ30 U4.AJ32 U4.K8 U4.R20 U4.R22 U4.R24 U4.R26 U4.R28 U4.U26
+3V_ROM: C167.1 PJ2.1 PJ3.1 R229.1 R230.1 U4.AD12 U8.8
+3VALW: C605.1 C723.1 C782.1 J10.1 JLED1.2 JP3.1 JPWRB1.1 PC606.1 PC628.1 PJ1.2 PJ3.2 PJ401.2 PJ605.1 PR103.1 PR108.2 PR206.2 PR211.2 PR214.2 PR315.1 PR602.2 PU601.7 PU604.7 Q121.3 QL1.3 R266.1 R304.2 R307.2 R593.2 R601.1 R606.2 R642.2 R694.2 R764.1 RP10.2 RV35.1 U39.5 U39.6 U39.7 U39.8
+3VALW_EC: C653.1 C654.1 C655.1 C657.1 C658.1 C662.1 L44.1 R301.1 R304.1 R590.1 R600.1 R604.1 U31.9 U31.22 U31.33 U31.96
+3VALWP: PC408.1 PC409.1 PC410.1 PC411.1 PC412.1 PC413.1 PJ401.1 PL402.2 PR414.2 PU401.4
+3VGS: CV46.1 LV9.1 PR801.2 PR802.2 PR803.2 PR804.2 PR805.2 PR806.2 PR816.1 PR830.1 PR831.1 PR833.1 QV3.2 QV3.5 QV8.1 RV5.1 RV6.1 RV18.1 RV24.1 RV25.1 RV26.1 RV36.1 U9.1 UV2.5
+3VLP: C535.1 PC414.1 PR101.2 PR209.2 PR220.2 PU401.5 R301.2 R643.2 R653.1 R701.2 RA1.1 U31.111 U31.125
+3VS: C86.1 C87.1 C108.1 C109.1 C135.1 C157.1 C158.1 C173.1 C537.1 C724.1 C725.1 CA8.1 CA9.1 CA10.1 CA15.1 J6.1 JCR1.1 JDIMM1.199 JDIMM2.199 JLVDS1.21 JLVDS1.24 PJ2.2 PR215.2 PR604.1 PR618.1 PR916.2 Q11.2 Q11.5 Q63.2 Q63.5 Q83.3 Q93.2 Q95.2 Q130.2 Q130.5 Q156.3 QV8.3 R11.1 R93.1 R101.1 R102.1 R108.1 R125.1 R126.1 R138.2 R167.1 R172.1 R176.2 R182.2 R184.2 R195.2 R223.2 R248.1 R249.1 R259.1 R268.1 R270.1 R271.1 R276.2 R277.2 R278.1 R280.2 R281.2 R286.2 R287.2 R302.1 R335.1 R485.2 R552.1 R555.1 R605.1 R645.1 R5583.1 RA5.2 RA15.1 RP1.1 RP1.2 RP1.3 RP1.4 RP13.5 RP13.10 RP15.5 RP15.10 RP16.2 RP16.3 RP17.1 RP17.2 RP21.5 RP21.6 RT1.1 U4.AE14 U4.AF12 U4.AG14 U4.AK30 U4.AK32 U4.L24 U4.M31 U4.R30 U4.R32 U6.5 U10.7 U39.1 U39.2 U39.3 U72.5 UA1.2 UA1.18
+3VS_CMOS: C519.1 JLVDS1.26 Q83.1
+3VS_PS: LT1.2 LT2.2 RT1.2 RT4.2 RT9.2 RT10.2
+3VS_TS: C1322.2 JTS1.6 Q156.1 R5583.2
+3VS_WLAN: C547.1 C548.1 J6.2 JWLN1.2 JWLN1.24 JWLN1.39 JWLN1.41 JWLN1.52
+5V_DISPLAY: C543.1 JCRT1.9 JHDMI1.18 R31.1 R33.1 RP21.7 RP21.8 U73.3
+5V_HDD: C598.1 C599.1 C602.1 JHDD1.14 JHDD1.15 JHDD1.16 R550.2
+5V_ODD: C604.1 C608.1 J9.2 JODD1.9 JODD1.10 JODD2.8 JODD2.9 Q99.1
+5VALW: C720.1 D22.5 D31.5 JLED1.1 PC510.1 PC708.1 PJ402.2 PR514.1 PU501.12 PU701.9 R568.1 R594.2 R623.1 R765.1 R778.1 R780.1 RV37.1 U35.2 U35.3 U36.2 U36.3 U38.5 U38.6 U38.7 U38.8
+5VALWP: PC211.1 PC423.1 PC424.1 PC425.1 PC426.1 PC427.1 PC428.1 PJ402.1 PL404.2 PR413.2 PU202.1 PU202.3 PU402.4
+5VS: C529.1 C531.1 C544.1 C591.2 C696.1 C721.1 C722.1 CA18.1 CA19.1 CA20.1 CA21.1 CA22.1 CA23.1 CA26.1 DA3.5 J9.1 JLED1.3 JTP1.6 PC812.1 PC872.1 PC914.1 PR106.2 PR107.2 PR844.2 PR848.2 PR863.2 PR908.1 PR932.1 PR933.2 PU101.8 PU801.24 PU801.25 PU901.15 Q99.3 R303.1 R550.1 R581.2 R598.2 R603.2 R644.1 U10.1 U10.2 U38.1 U38.2 U38.3 U73.1 UA1.13 UA1.16 UA1.28
+AVDD: CV17.1 CV18.1 CV19.1 LV1.1 UV1.AD34
+V18R: C667.1 U31.124
+VCCADAC: C126.1 C127.1 C128.1 C133.1 LH1.2 U4.P45
+VCCIO_OUT: C53.1 JCPU1.AN35 PC909.2 PR906.2 PR910.2 R8.1 R26.1 R78.1 R81.1 R87.2 RC1.2
+VCCST: JCPU1.AK31
+VDD1DI: CV20.1 CV21.1 CV22.1 LV2.1 UV1.AC33
+VDD_MEM15_REFDA: CV98.1 RV49.2 RV55.1 UV1.L18
+VDD_MEM15_REFDB: CV101.1 RV51.2 RV58.1 UV1.Y12
+VDD_MEM15_REFSA: CV99.1 RV50.2 RV56.1 UV1.L20
+VDD_MEM15_REFSB: CV102.1 RV52.2 RV59.1 UV1.AA12
+VDDC_CT: CV89.1 CV90.1 CV91.1 LV8.2 UV1.AF26 UV1.AF27 UV1.AG26 UV1.AG27
+VDDR3: CV92.1 CV94.1 CV95.1 LV9.2 UV1.AF23 UV1.AF24 UV1.AG23 UV1.AG24
+VDDR4: CV96.1 CV97.1 LV10.2 UV1.AD12 UV1.AF11 UV1.AF12 UV1.AF13 UV1.AF15 UV1.AG11 UV1.AG13 UV1.AG15
GND: C4.2 C6.2 C35.2 C53.2 C54.2 C55.2 C56.2 C57.2 C58.2 C59.2 C60.2 C61.2 C62.2 C63.2 C64.2 C65.2 C66.2 C67.2 C68.2 C69.2 C70.2 C71.2 C72.2 C73.2 C74.2 C75.2 C76.2 C77.2 C78.2 C79.2 C80.2 C81.2 C82.2 C83.2 C84.2 C85.2 C86.2 C87.2 C88.2 C89.2 C90.2 C91.2 C92.2 C93.2 C94.2 C95.2 C96.2 C97.2 C98.2 C99.2 C100.2 C101.2 C102.2 C103.2 C104.2 C105.2 C106.2 C107.2 C108.2 C109.2 C110.2 C111.2 C112.2 C113.1 C115.2 C118.2 C119.2 C120.1 C126.2 C127.2 C128.2 C129.2 C130.2 C131.2 C132.2 C133.2 C134.2 C135.2 C136.2 C137.2 C138.2 C139.2 C140.2 C143.2 C144.2 C145.2 C146.2 C147.2 C149.2 C152.2 C153.2 C154.2 C155.2 C156.2 C157.2 C158.2 C159.2 C160.2 C162.2 C163.2 C164.2 C165.2 C166.2 C167.2 C169.2 C170.2 C171.2 C172.2 C173.2 C174.2 C175.2 C176.2 C177.2 C178.2 C179.2 C180.2 C181.2 C182.2 C183.2 C184.2 C185.2 C186.2 C411.2 C412.2 C492.2 C493.2 C494.2 C516.2 C519.2 C520.2 C522.2 C523.2 C524.2 C525.2 C526.2 C527.2 C529.2 C531.2 C535.2 C536.2 C537.2 C541.2 C543.2 C544.2 C547.2 C548.2 C591.1 C598.2 C599.2 C602.2 C604.2 C605.2 C607.2 C608.2 C653.2 C654.2 C655.2 C657.2 C658.2 C660.2 C661.1 C662.2 C663.2 C664.2 C667.2 C696.2 C714.2 C720.2 C721.2 C722.2 C723.2 C724.2 C725.2 C726.2 C727.2 C736.2 C780.2 C781.2 C782.2 C783.2 C1322.1 C1331.2 CA5.2 CA6.2 CA7.1 CA8.2 CA9.2 CA10.2 CA11.2 CA15.2 CA16.2 CA17.2 CA19.2 CA21.2 CA22.2 CA23.2 CA24.2 CA25.2 CA30.1 CA31.2 CA32.2 CA33.2 CA34.2 CA35.2 CA38.2 CA39.2 CA40.2 CA43.2 CA64.1 CA65.1 CA66.1 CL1.1 CL2.2 CL3.2 CL4.2 CL5.2 CL6.2 CL7.1 CL8.2 CL10.2 CL12.1 CL13.2 CL14.2 CL15.2 CL16.2 CL17.2 CL18.2 CL19.2 CL20.2 CL21.2 CL22.2 CL23.2 CL24.2 CL25.2 CL26.2 CL28.2 CL29.2 CL31.2 CL61.1 CL62.1 CL63.1 CL64.1 CLRP2.1 CLRP3.2 CT1.2 CT2.2 CT3.2 CT4.2 CT5.2 CT6.2 CT7.2 CT8.2 CT9.2 CT10.2 CT11.2 CT12.2 CV17.2 CV18.2 CV19.2 CV20.2 CV21.2 CV22.2 CV23.2 CV26.2 CV27.2 CV28.2 CV29.2 CV30.2 CV31.2 CV32.2 CV33.2 CV34.2 CV35.2 CV36.1 CV37.1 CV38.2 CV39.2 CV40.2 CV43.2 CV44.2 CV45.2 CV46.2 CV48.2 CV49.2 CV52.2 CV53.2 CV54.2 CV55.2 CV56.2 CV57.2 CV58.2 CV59.2 CV60.2 CV61.2 CV62.2 CV63.2 CV64.2 CV65.2 CV66.2 CV67.2 CV68.2 CV69.2 CV70.2 CV71.2 CV72.2 CV73.2 CV74.2 CV75.2 CV76.2 CV77.2 CV78.2 CV79.2 CV80.2 CV81.2 CV82.2 CV83.2 CV84.2 CV85.2 CV86.2 CV87.2 CV88.2 CV89.2 CV90.2 CV91.2 CV92.2 CV94.2 CV95.2 CV96.2 CV97.2 CV98.2 CV99.2 CV100.2 CV101.2 CV102.2 CV103.2 CV104.2 CV105.2 CV106.2 CV107.2 CV108.2 CV109.2 CV112.2 CV113.2 CV115.2 CV116.2 CV117.2 CV118.2 CV119.2 CV120.2 CV121.2 CV122.2 CV124.2 CV125.2 CV126.2 CV127.2 CV128.2 CV129.2 CV130.2 CV132.2 CV134.2 CV135.2 CV136.2 CV138.2 CV139.2 CV141.2 CV144.2 CV145.2 CV146.2 CV147.2 CV148.2 CV149.2 CV150.2 CV152.2 CV154.2 CV155.2 CV156.2 CV158.2 CV159.2 CV160.2 CV161.2 CV162.2 CV164.2 CV165.2 CV166.2 CV167.2 CV168.2 CV169.2 CV170.2 CV171.2 CV172.2 CV173.2 CV174.2 CV175.2 CV176.2 CV177.2 CV178.2 CV179.2 CV181.2 CV183.2 CV184.2 CV185.2 CV186.2 CV187.2 CV188.2 CV189.2 CV190.2 CV191.2 CV192.2 CV193.2 CV194.2 CV195.2 CV196.2 CV197.2 CV198.2 D15.1 D22.2 D24.1 D25.1 D27.3 D28.3 D29.3 D30.3 D31.2 D32.3 DA1.1 DA2.1 DA3.2 DL1.2 H1.1(TP-1) H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H7.1(TP-1) H8.1(TP-1) H10.1(TP-1) H11.1(TP-1) H12.1(TP-1) H18.1(TP-1) J11.1 J12.1 JBATT1.6 JBATT1.7 JBATT1.8 JBATT1.9 JBATT2.6 JBATT2.7 JBATT2.8 JBATT2.9 JCPU1.A3 JCPU1.A4 JCPU1.A7 JCPU1.A10 JCPU1.A13 JCPU1.A16 JCPU1.A19 JCPU1.A22 JCPU1.A25 JCPU1.A27 JCPU1.A29 JCPU1.A31 JCPU1.A33 JCPU1.AA11 JCPU1.AA25 JCPU1.AA27 JCPU1.AA29 JCPU1.AA31 JCPU1.AA33 JCPU1.AA35 JCPU1.AB1 JCPU1.AB3 JCPU1.AB4 JCPU1.AB6 JCPU1.AB7 JCPU1.AB9 JCPU1.AB10 JCPU1.AC11 JCPU1.AC25 JCPU1.AC27 JCPU1.AC29 JCPU1.AC31 JCPU1.AC33 JCPU1.AC35 JCPU1.AD7 JCPU1.AD11 JCPU1.AE1 JCPU1.AE3 JCPU1.AE4 JCPU1.AE6 JCPU1.AE7 JCPU1.AE9 JCPU1.AE10 JCPU1.AE25 JCPU1.AE27 JCPU1.AE29 JCPU1.AE31 JCPU1.AE33 JCPU1.AE35 JCPU1.AF6 JCPU1.AF8 JCPU1.AF11 JCPU1.AG6 JCPU1.AG11 JCPU1.AG25 JCPU1.AG27 JCPU1.AG29 JCPU1.AG31 JCPU1.AG33 JCPU1.AG35 JCPU1.AH1 JCPU1.AH2 JCPU1.AH3 JCPU1.AH4 JCPU1.AH5 JCPU1.AH6 JCPU1.AH7 JCPU1.AH8 JCPU1.AH9 JCPU1.AH10 JCPU1.AJ5 JCPU1.AJ11 JCPU1.AK5 JCPU1.AK11 JCPU1.AK25 JCPU1.AK26 JCPU1.AK28 JCPU1.AK29 JCPU1.AK30 JCPU1.AK32 JCPU1.AK34 JCPU1.AL1 JCPU1.AL2 JCPU1.AL3 JCPU1.AL4 JCPU1.AL5 JCPU1.AL6 JCPU1.AL7 JCPU1.AL8 JCPU1.AL9 JCPU1.AL10 JCPU1.AL11 JCPU1.AL12 JCPU1.AL14 JCPU1.AL15 JCPU1.AL17 JCPU1.AL18 JCPU1.AL19 JCPU1.AL20 JCPU1.AL21 JCPU1.AL22 JCPU1.AL23 JCPU1.AL24 JCPU1.AL31 JCPU1.AL32 JCPU1.AM4 JCPU1.AM7 JCPU1.AM10 JCPU1.AM13 JCPU1.AM16 JCPU1.AM19 JCPU1.AM20 JCPU1.AM21 JCPU1.AM22 JCPU1.AM23 JCPU1.AM24 JCPU1.AM25 JCPU1.AM32 JCPU1.AN2 JCPU1.AN4 JCPU1.AN7 JCPU1.AN10 JCPU1.AN13 JCPU1.AN16 JCPU1.AN19 JCPU1.AN21 JCPU1.AN24 JCPU1.AN27 JCPU1.AN30 JCPU1.AN34 JCPU1.AP1 JCPU1.AP4 JCPU1.AP7 JCPU1.AP10 JCPU1.AP13 JCPU1.AP16 JCPU1.AP19 JCPU1.AP27 JCPU1.AP34 JCPU1.AP35 JCPU1.AR2 JCPU1.AR4 JCPU1.AR7 JCPU1.AR10 JCPU1.AR13 JCPU1.AR16 JCPU1.AR19 JCPU1.AR22 JCPU1.AR25 JCPU1.AR26 JCPU1.AR28 JCPU1.AR31 JCPU1.AR34 JCPU1.AT3 JCPU1.AT4 JCPU1.AT7 JCPU1.AT10 JCPU1.AT13 JCPU1.AT16 JCPU1.AT19 JCPU1.AT21 JCPU1.AT24 JCPU1.AT27 JCPU1.AT30 JCPU1.AT32 JCPU1.AT33 JCPU1.AT34 JCPU1.B2 JCPU1.B4 JCPU1.B7 JCPU1.B10 JCPU1.B13 JCPU1.B16 JCPU1.B19 JCPU1.B22 JCPU1.B34 JCPU1.C1 JCPU1.C2 JCPU1.C4 JCPU1.C7 JCPU1.C10 JCPU1.C13 JCPU1.C16 JCPU1.C19 JCPU1.C22 JCPU1.C24 JCPU1.C26 JCPU1.C28 JCPU1.C30 JCPU1.C32 JCPU1.C34 JCPU1.D4 JCPU1.D7 JCPU1.D10 JCPU1.D13 JCPU1.D16 JCPU1.D19 JCPU1.D22 JCPU1.D25 JCPU1.D27 JCPU1.D29 JCPU1.D31 JCPU1.D33 JCPU1.D35 JCPU1.E1 JCPU1.E4 JCPU1.E7 JCPU1.E10 JCPU1.E13 JCPU1.E16 JCPU1.E19 JCPU1.E22 JCPU1.E25 JCPU1.F4 JCPU1.F6 JCPU1.F7 JCPU1.F8 JCPU1.F9 JCPU1.F10 JCPU1.F11 JCPU1.F12 JCPU1.F14 JCPU1.F15 JCPU1.F17 JCPU1.F18 JCPU1.F19 JCPU1.F20 JCPU1.F21 JCPU1.F23 JCPU1.F24 JCPU1.F26 JCPU1.F28 JCPU1.F30 JCPU1.F32 JCPU1.F34 JCPU1.G1 JCPU1.G2 JCPU1.G3 JCPU1.G4 JCPU1.G5 JCPU1.G11 JCPU1.G27 JCPU1.G29 JCPU1.G31 JCPU1.G33 JCPU1.G35 JCPU1.H6 JCPU1.H7 JCPU1.H10 JCPU1.H11 JCPU1.H26 JCPU1.J6 JCPU1.J11 JCPU1.J26 JCPU1.J28 JCPU1.J30 JCPU1.J32 JCPU1.J34 JCPU1.K1 JCPU1.K2 JCPU1.K3 JCPU1.K4 JCPU1.K5 JCPU1.K7 JCPU1.K8 JCPU1.K9 JCPU1.K10 JCPU1.K29 JCPU1.K31 JCPU1.K33 JCPU1.K35 JCPU1.L6 JCPU1.L11 JCPU1.L26 JCPU1.M6 JCPU1.M11 JCPU1.M26 JCPU1.M28 JCPU1.M30 JCPU1.M32 JCPU1.M34 JCPU1.N1 JCPU1.N2 JCPU1.N3 JCPU1.N4 JCPU1.N5 JCPU1.N6 JCPU1.N7 JCPU1.N9 JCPU1.N10 JCPU1.N29 JCPU1.N31 JCPU1.N33 JCPU1.N35 JCPU1.P5 JCPU1.P11 JCPU1.P26 JCPU1.R5 JCPU1.R10 JCPU1.R11 JCPU1.R26 JCPU1.R28 JCPU1.R30 JCPU1.R32 JCPU1.R34 JCPU1.T1 JCPU1.T3 JCPU1.T4 JCPU1.T6 JCPU1.T7 JCPU1.T9 JCPU1.T10 JCPU1.T26 JCPU1.T29 JCPU1.T31 JCPU1.T33 JCPU1.T35 JCPU1.U11 JCPU1.U27 JCPU1.V10 JCPU1.V11 JCPU1.V28 JCPU1.V30 JCPU1.V32 JCPU1.V34 JCPU1.W1 JCPU1.W3 JCPU1.W4 JCPU1.W6 JCPU1.W7 JCPU1.W9 JCPU1.W10 JCPU1.W25 JCPU1.W33 JCPU1.W35 JCPU1.Y11 JCR1.4 JCR1.5 JCR1.6 JCRT1.5 JCRT1.6 JCRT1.7 JCRT1.8 JCRT1.10 JCRT1.16 JCRT1.17 JDCIN1.3 JDCIN1.4 JDIMM1.2 JDIMM1.3 JDIMM1.8 JDIMM1.9 JDIMM1.11 JDIMM1.13 JDIMM1.14 JDIMM1.19 JDIMM1.20 JDIMM1.25 JDIMM1.26 JDIMM1.28 JDIMM1.31 JDIMM1.32 JDIMM1.37 JDIMM1.38 JDIMM1.43 JDIMM1.44 JDIMM1.46 JDIMM1.48 JDIMM1.49 JDIMM1.54 JDIMM1.55 JDIMM1.60 JDIMM1.61 JDIMM1.63 JDIMM1.65 JDIMM1.66 JDIMM1.71 JDIMM1.72 JDIMM1.127 JDIMM1.128 JDIMM1.133 JDIMM1.134 JDIMM1.136 JDIMM1.138 JDIMM1.139 JDIMM1.144 JDIMM1.145 JDIMM1.150 JDIMM1.151 JDIMM1.153 JDIMM1.155 JDIMM1.156 JDIMM1.161 JDIMM1.162 JDIMM1.167 JDIMM1.168 JDIMM1.170 JDIMM1.172 JDIMM1.173 JDIMM1.178 JDIMM1.179 JDIMM1.184 JDIMM1.185 JDIMM1.187 JDIMM1.189 JDIMM1.190 JDIMM1.195 JDIMM1.196 JDIMM1.197 JDIMM1.201 JDIMM1.205 JDIMM1.206 JDIMM2.2 JDIMM2.3 JDIMM2.8 JDIMM2.9 JDIMM2.11 JDIMM2.13 JDIMM2.14 JDIMM2.19 JDIMM2.20 JDIMM2.25 JDIMM2.26 JDIMM2.28 JDIMM2.31 JDIMM2.32 JDIMM2.37 JDIMM2.38 JDIMM2.43 JDIMM2.44 JDIMM2.46 JDIMM2.48 JDIMM2.49 JDIMM2.54 JDIMM2.55 JDIMM2.60 JDIMM2.61 JDIMM2.63 JDIMM2.65 JDIMM2.66 JDIMM2.71 JDIMM2.72 JDIMM2.127 JDIMM2.128 JDIMM2.133 JDIMM2.134 JDIMM2.136 JDIMM2.138 JDIMM2.139 JDIMM2.144 JDIMM2.145 JDIMM2.150 JDIMM2.151 JDIMM2.153 JDIMM2.155 JDIMM2.156 JDIMM2.161 JDIMM2.162 JDIMM2.167 JDIMM2.168 JDIMM2.170 JDIMM2.172 JDIMM2.173 JDIMM2.178 JDIMM2.179 JDIMM2.184 JDIMM2.185 JDIMM2.187 JDIMM2.189 JDIMM2.190 JDIMM2.195 JDIMM2.196 JDIMM2.197 JDIMM2.205 JDIMM2.206 JFAN1.4 JFAN1.5 JFAN1.6 JHDD1.1 JHDD1.4 JHDD1.7 JHDD1.11 JHDD1.12 JHDD1.13 JHDD1.17 JHDD1.19 JHDD1.23 JHDD1.24 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JHP1.6 JKB1.27 JKB1.28 JKB1.29 JKB1.30 JKB1.31 JKB1.32 JKB2.25 JKB2.26 JLED1.5 JLED1.10 JLED1.11 JLED1.12 JLVDS1.9 JLVDS1.12 JLVDS1.29 JLVDS1.30 JLVDS1.31 JLVDS1.32 JLVDS1.33 JLVDS1.34 JODD1.1 JODD1.4 JODD1.7 JODD1.12 JODD1.13 JODD1.14 JODD1.15 JODD2.1 JODD2.4 JODD2.11 JODD2.12 JP3.4 JPWRB1.5 JPWRB1.6 JPWRB1.7 JPWRB1.8 JRTC1.2 JRTC1.3 JRTC1.4 JSPK1.5 JSPK1.6 JTP1.7 JTP1.8 JTS1.2 JTS1.5 JTS1.7 JTS1.8 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JUSB3.1 JUSB3.4 JUSB3.7 JUSB3.8 JWLN1.4 JWLN1.9 JWLN1.15 JWLN1.18 JWLN1.21 JWLN1.26 JWLN1.27 JWLN1.29 JWLN1.34 JWLN1.35 JWLN1.37 JWLN1.40 JWLN1.43 JWLN1.50 JWLN1.53 JWLN1.54 L45.1 PC101.2 PC102.2 PC103.2 PC104.2 PC107.2 PC108.2 PC109.2 PC201.2 PC202.2 PC203.2 PC207.2 PC209.2 PC211.2 PC212.2 PC213.2 PC303.1 PC304.1 PC305.2 PC307.1 PC309.2 PC310.1 PC311.1 PC312.2 PC313.1 PC314.2 PC315.1 PC316.1 PC318.1 PC319.1 PC320.2 PC322.2 PC323.2 PC324.2 PC403.2 PC404.2 PC405.2 PC406.2 PC407.2 PC408.2 PC409.2 PC410.2 PC411.2 PC412.2 PC413.2 PC414.2 PC415.2 PC416.2 PC417.2 PC418.2 PC420.2 PC422.2 PC423.2 PC424.2 PC425.2 PC426.2 PC427.2 PC428.2 PC429.2 PC430.2 PC431.2 PC432.2 PC433.2 PC434.2 PC501.2 PC503.2 PC504.2 PC505.2 PC506.2 PC508.2 PC509.2 PC510.2 PC511.2 PC513.2 PC517.2 PC520.2 PC522.2 PC601.2 PC603.2 PC604.2 PC605.2 PC606.2 PC608.2 PC609.2 PC610.2 PC611.2 PC612.2 PC613.2 PC617.2 PC618.2 PC619.2 PC620.2 PC621.2 PC622.2 PC626.2 PC627.2 PC628.2 PC629.2 PC630.2 PC631.2 PC633.2 PC634.2 PC636.2 PC637.2 PC638.1 PC701.2 PC702.2 PC703.1 PC704.1 PC705.1 PC708.2 PC709.2 PC711.2 PC712.2 PC713.2 PC714.2 PC715.2 PC801.2 PC802.2 PC803.2 PC804.2 PC805.1 PC807.2 PC808.2 PC809.2 PC810.2 PC811.2 PC812.2 PC824.2 PC825.2 PC826.2 PC827.2 PC828.2 PC829.2 PC830.2 PC831.2 PC832.2 PC833.2 PC834.2 PC835.2 PC836.2 PC837.2 PC838.2 PC839.2 PC840.2 PC841.2 PC842.2 PC843.2 PC844.2 PC845.2 PC846.2 PC851.2 PC852.2 PC853.2 PC854.2 PC855.2 PC856.2 PC857.2 PC859.2 PC862.1 PC865.2 PC866.2 PC872.2 PC876.2 PC877.2 PC878.2 PC879.2 PC880.2 PC881.2 PC905.2 PC907.1 PC908.2 PC909.1 PC911.2 PC912.1 PC914.2 PC919.2 PC920.2 PC922.2 PC925.2 PC930.2 PC932.2 PC933.2 PC938.2 PC939.2 PC940.2 PC942.2 PC943.2 PC944.2 PC945.2 PC946.2 PC947.2 PC949.2 PC950.2 PC951.2 PC952.2 PC953.2 PC954.2 PC955.2 PC956.2 PC957.2 PC958.2 PC959.2 PC960.2 PC961.2 PC962.2 PC963.2 PC964.2 PC965.2 PC966.2 PC967.2 PC968.2 PC969.2 PC970.2 PC971.2 PC972.2 PC973.2 PC974.2 PC975.2 PC976.2 PC977.2 PC978.2 PC979.2 PC980.2 PC981.2 PC982.2 PC983.2 PC984.2 PC985.2 PC986.2 PC987.2 PC988.2 PC989.1 PC989.2 PD104.2 PD105.2 PD201.2 PD203.2 PH902.1 PQ101.1 PQ101.4 PQ102.4 PQ201.3 PQ202.1 PQ202.4 PQ205.3 PQ209.3 PQ303.3 PQ305.3 PQ306.3 PQ307.1 PQ307.4 PQ308.3 PQ310.1 PQ310.2 PQ310.3 PQ311.3 PQ313.3 PQ314.3 PQ502.1 PQ502.2 PQ502.3 PQ702.1 PQ702.2 PQ702.3 PQ801.8 PQ802.8 PQ902.1 PQ902.2 PQ902.3 PQ904.1 PQ904.2 PQ904.3 PQ906.1 PQ906.2 PQ906.3 PR104.1 PR105.1 PR109.1 PR111.2 PR205.1 PR208.1 PR213.1 PR217.1 PR308.1 PR312.2 PR316.2 PR403.2 PR409.2 PR506.2 PR605.2 PR608.2 PR609.2 PR613.1 PR615.2 PR616.1 PR623.1 PR624.1 PR705.1 PR706.1 PR711.2 PR712.2 PR807.2 PR808.2 PR809.2 PR810.2 PR811.2 PR812.2 PR814.2 PR819.1 PR835.1 PR836.2 PR840.2 PR849.2 PR861.1 PR912.1 PR917.1 PR921.2 PR922.2 PR923.1 PR945.1 PR945.2 PR946.1 PR946.2 PR947.1 PR947.2 PR948.1 PR948.2 PU101.4 PU201.4 PU202.2 PU301.14 PU301.21 PU401.9 PU402.9 PU501.1 PU501.3 PU501.14 PU501.21 PU601.9 PU603.2 PU604.9 PU701.3 PU701.7 PU701.8 PU701.17 PU801.22 PU801.27 PU801.41 PU901.14 PU901.37 PU902.6 PU902.9 Q1.3 Q6.3 Q37.3 Q95.3 Q100.3 Q107.3 Q108.3 Q110.3 Q111.3 Q113.3 Q116.3 Q117.3 Q118.3 Q120.3 Q124.3 QV1.3 QV2.3 QV6.3 QV7.3 QV9.3 R5.2 R6.2 R7.2 R15.1 R27.1 R36.2 R39.1 R44.2 R45.2 R54.2 R59.2 R62.2 R63.2 R64.1 R66.1 R67.2 R68.2 R84.2 R89.1 R104.1 R110.2 R122.2 R123.2 R124.2 R132.1 R143.2 R156.2 R157.2 R158.2 R168.1 R183.1 R192.1 R193.1 R194.1 R197.1 R199.1 R202.1 R203.1 R205.1 R228.2 R242.2 R247.1 R260.1 R265.1 R267.1 R274.2 R275.2 R279.1 R282.1 R283.2 R288.1 R289.1 R309.1 R312.2 R408.2 R438.1 R488.1 R507.1 R522.2 R608.2 R619.2 R627.2 R650.1 R695.1 R710.1 R716.2 R740.2 R781.2 RA6.2 RA22.2 RL8.2 RL12.1 RP18.1 RP18.4 RP19.2 RP19.3 RP22.2 RP22.3 RP22.4 RP23.2 RP23.3 RP23.4 RT8.1 RT12.1 RV2.2 RV4.2 RV11.2 RV12.1 RV14.2 RV19.1 RV27.2 RV28.2 RV29.2 RV30.2 RV31.1 RV33.2 RV34.2 RV42.1 RV44.2 RV47.1 RV55.2 RV56.2 RV57.1 RV58.2 RV59.2 RV64.2 RV65.2 RV70.2 RV71.2 RV76.2 RV77.2 RV82.2 RV83.2 RV84.2 RV85.2 RV86.2 RV87.2 RV88.2 RV89.2 RV90.2 RV91.2 SW4.3 SW4.4 SW4.5 SW4.6 SW5.3 SW5.4 SW5.5 SW5.6 SW6.3 SW6.4 SW6.5 SW6.6 SW7.3 SW7.4 SW7.5 SW7.6 U1.3 U4.A2 U4.A4 U4.A5 U4.A41 U4.A43 U4.A44 U4.AA4 U4.AA16 U4.AA20 U4.AA22 U4.AA28 U4.AB8 U4.AB12 U4.AB34 U4.AB38 U4.AC2 U4.AC44 U4.AD6 U4.AD8 U4.AD14 U4.AD16 U4.AD18 U4.AD30 U4.AD32 U4.AD40 U4.AE16 U4.AE28 U4.AF8 U4.AF38 U4.AG2 U4.AG16 U4.AG26 U4.AG28 U4.AG44 U4.AJ6 U4.AJ8 U4.AJ16 U4.AJ18 U4.AJ20 U4.AJ22 U4.AJ24 U4.AJ34 U4.AJ38 U4.AK14 U4.AK16 U4.AK24 U4.AK43 U4.AK45 U4.AL2 U4.AL8 U4.AL12 U4.AL34 U4.AL38 U4.AM14 U4.AM16 U4.AM24 U4.AM26 U4.AM28 U4.AM30 U4.AM32 U4.AN8 U4.AN36 U4.AN40 U4.AN42 U4.AP13 U4.AP24 U4.AP31 U4.AP43 U4.AR2 U4.AT10 U4.AT15 U4.AT17 U4.AT20 U4.AT26 U4.AT29 U4.AT36 U4.AT38 U4.AT43 U4.AV6 U4.AV7 U4.AV13 U4.AV22 U4.AV24 U4.AV31 U4.AV33 U4.AV40 U4.AW2 U4.AY7 U4.AY10 U4.AY15 U4.AY20 U4.AY26 U4.AY29 U4.AY36 U4.B1 U4.B2 U4.B7 U4.B11 U4.B15 U4.B19 U4.B23 U4.B27 U4.B31 U4.B35 U4.B39 U4.B44 U4.B45 U4.BA1 U4.BA40 U4.BB25 U4.BB42 U4.BC1 U4.BC16 U4.BC22 U4.BC28 U4.BD1 U4.BD2 U4.BD7 U4.BD11 U4.BD15 U4.BD19 U4.BD31 U4.BD35 U4.BD39 U4.BD44 U4.BD45 U4.BE2 U4.BE3 U4.BE5 U4.BE41 U4.C45 U4.D1 U4.D4 U4.D25 U4.D42 U4.E1 U4.E45 U4.F15 U4.F20 U4.F29 U4.F33 U4.F43 U4.G2 U4.G8 U4.G38 U4.G44 U4.H7 U4.H10 U4.H13 U4.H17 U4.H22 U4.H24 U4.H26 U4.H31 U4.H36 U4.H40 U4.K10 U4.K15 U4.K20 U4.K29 U4.K33 U4.K39 U4.L2 U4.L44 U4.M17 U4.M22 U4.M24 U4.N6 U4.N10 U4.N12 U4.N35 U4.N39 U4.P22 U4.P24 U4.P26 U4.P28 U4.P30 U4.P32 U4.P43 U4.R2 U4.R8 U4.R12 U4.R14 U4.R16 U4.R34 U4.R38 U4.R44 U4.T43 U4.U6 U4.U10 U4.U16 U4.U28 U4.U34 U4.U38 U4.U39 U4.U42 U4.V14 U4.V16 U4.V26 U4.V43 U4.W2 U4.W44 U4.Y8 U4.Y14 U4.Y16 U4.Y24 U4.Y28 U4.Y34 U4.Y36 U4.Y40 U6.3 U8.4 U9.5 U10.6 U31.11 U31.24 U31.35 U31.94 U31.113 U35.1 U36.1 U72.2 U73.2 UA1.41 UL1.27 UL1.41 UT2.4 UT2.33 UV1.A3 UV1.A37 UV1.AA2 UV1.AA6 UV1.AA16 UV1.AA18 UV1.AA21 UV1.AA23 UV1.AA26 UV1.AA28 UV1.AB12 UV1.AB15 UV1.AB17 UV1.AB20 UV1.AB22 UV1.AB24 UV1.AB27 UV1.AB39 UV1.AC2 UV1.AC6 UV1.AC11 UV1.AC13 UV1.AC16 UV1.AC18 UV1.AC21 UV1.AC23 UV1.AC26 UV1.AC28 UV1.AC34 UV1.AD9 UV1.AD15 UV1.AD17 UV1.AD20 UV1.AD22 UV1.AD24 UV1.AD27 UV1.AD35 UV1.AD37 UV1.AE2 UV1.AE6 UV1.AE34 UV1.AE38 UV1.AF10 UV1.AF16 UV1.AF18 UV1.AF21 UV1.AF39 UV1.AG2 UV1.AG6 UV1.AG9 UV1.AG17 UV1.AG20 UV1.AH21 UV1.AH39 UV1.AJ2 UV1.AJ6 UV1.AJ10 UV1.AJ11 UV1.AJ28 UV1.AJ33 UV1.AK7 UV1.AK11 UV1.AK31 UV1.AK39 UV1.AL2 UV1.AL6 UV1.AL8 UV1.AL11 UV1.AL14 UV1.AL17 UV1.AL20 UV1.AL23 UV1.AL26 UV1.AL32 UV1.AL34 UV1.AM9 UV1.AM11 UV1.AM31 UV1.AM35 UV1.AN2 UV1.AN6 UV1.AN8 UV1.AN10 UV1.AN11 UV1.AN17 UV1.AN19 UV1.AN27 UV1.AN29 UV1.AN30 UV1.AN32 UV1.AN34 UV1.AN38 UV1.AP7 UV1.AP9 UV1.AP11 UV1.AP16 UV1.AP17 UV1.AP18 UV1.AP19 UV1.AP27 UV1.AP28 UV1.AP29 UV1.AP30 UV1.AP39 UV1.AR5 UV1.AR18 UV1.AR28 UV1.AR39 UV1.AU37 UV1.AV17 UV1.AV27 UV1.AW14 UV1.AW16 UV1.AW20 UV1.AW22 UV1.AW24 UV1.AW26 UV1.AW30 UV1.AW32 UV1.B7 UV1.B9 UV1.B11 UV1.B13 UV1.B15 UV1.B17 UV1.B19 UV1.B21 UV1.B23 UV1.B25 UV1.B27 UV1.B29 UV1.B31 UV1.B33 UV1.C1 UV1.C39 UV1.E5 UV1.E35 UV1.E39 UV1.F7 UV1.F9 UV1.F11 UV1.F13 UV1.F15 UV1.F17 UV1.F19 UV1.F21 UV1.F23 UV1.F25 UV1.F27 UV1.F29 UV1.F31 UV1.F33 UV1.F34 UV1.F39 UV1.G2 UV1.G6 UV1.G33 UV1.G34 UV1.H9 UV1.H31 UV1.H34 UV1.H39 UV1.J2 UV1.J6 UV1.J8 UV1.J27 UV1.J31 UV1.J34 UV1.K7 UV1.K14 UV1.K31 UV1.K34 UV1.K39 UV1.L2 UV1.L6 UV1.L11 UV1.L17 UV1.L22 UV1.L24 UV1.L31 UV1.L34 UV1.M17 UV1.M22 UV1.M24 UV1.M34 UV1.M39 UV1.N2 UV1.N6 UV1.N16 UV1.N18 UV1.N21 UV1.N23 UV1.N26 UV1.N31 UV1.N34 UV1.P31 UV1.P34 UV1.P39 UV1.R2 UV1.R6 UV1.R15 UV1.R17 UV1.R20 UV1.R22 UV1.R24 UV1.R27 UV1.R34 UV1.T11 UV1.T13 UV1.T16 UV1.T18 UV1.T21 UV1.T23 UV1.T26 UV1.T31 UV1.T34 UV1.T39 UV1.U2 UV1.U6 UV1.U15 UV1.U17 UV1.U20 UV1.U22 UV1.U24 UV1.U27 UV1.U31 UV1.U34 UV1.V11 UV1.V16 UV1.V18 UV1.V21 UV1.V23 UV1.V26 UV1.V34 UV1.V39 UV1.W2 UV1.W6 UV1.W31 UV1.W34 UV1.Y15 UV1.Y17 UV1.Y20 UV1.Y22 UV1.Y24 UV1.Y27 UV1.Y34 UV1.Y39 UV2.3 UV5.A9 UV5.B1 UV5.B3 UV5.B9 UV5.D1 UV5.D8 UV5.E1 UV5.E2 UV5.E8 UV5.F9 UV5.G1 UV5.G8 UV5.G9 UV5.J2 UV5.J8 UV5.M1 UV5.M9 UV5.P1 UV5.P9 UV5.T1 UV5.T9 UV6.A9 UV6.B1 UV6.B3 UV6.B9 UV6.D1 UV6.D8 UV6.E1 UV6.E2 UV6.E8 UV6.F9 UV6.G1 UV6.G8 UV6.G9 UV6.J2 UV6.J8 UV6.M1 UV6.M9 UV6.P1 UV6.P9 UV6.T1 UV6.T9 UV7.A9 UV7.B1 UV7.B3 UV7.B9 UV7.D1 UV7.D8 UV7.E1 UV7.E2 UV7.E8 UV7.F9 UV7.G1 UV7.G8 UV7.G9 UV7.J2 UV7.J8 UV7.M1 UV7.M9 UV7.P1 UV7.P9 UV7.T1 UV7.T9 UV8.A9 UV8.B1 UV8.B3 UV8.B9 UV8.D1 UV8.D8 UV8.E1 UV8.E2 UV8.E8 UV8.F9 UV8.G1 UV8.G8 UV8.G9 UV8.J2 UV8.J8 UV8.M1 UV8.M9 UV8.P1 UV8.P9 UV8.T1 UV8.T9 UV9.A9 UV9.B1 UV9.B3 UV9.B9 UV9.D1 UV9.D8 UV9.E1 UV9.E2 UV9.E8 UV9.F9 UV9.G1 UV9.G8 UV9.G9 UV9.J2 UV9.J8 UV9.M1 UV9.M9 UV9.P1 UV9.P9 UV9.T1 UV9.T9 UV10.A9 UV10.B1 UV10.B3 UV10.B9 UV10.D1 UV10.D8 UV10.E1 UV10.E2 UV10.E8 UV10.F9 UV10.G1 UV10.G8 UV10.G9 UV10.J2 UV10.J8 UV10.M1 UV10.M9 UV10.P1 UV10.P9 UV10.T1 UV10.T9 UV11.A9 UV11.B1 UV11.B3 UV11.B9 UV11.D1 UV11.D8 UV11.E1 UV11.E2 UV11.E8 UV11.F9 UV11.G1 UV11.G8 UV11.G9 UV11.J2 UV11.J8 UV11.M1 UV11.M9 UV11.P1 UV11.P9 UV11.T1 UV11.T9 UV12.A9 UV12.B1 UV12.B3 UV12.B9 UV12.D1 UV12.D8 UV12.E1 UV12.E2 UV12.E8 UV12.F9 UV12.G1 UV12.G8 UV12.G9 UV12.J2 UV12.J8 UV12.M1 UV12.M9 UV12.P1 UV12.P9 UV12.T1 UV12.T9
GNDA: CA1.2 CA2.2 CA3.1 CA4.2 CA18.2 CA20.2 CA42.2 CA44.2 CA64.2 CA65.2 CA66.2 MIC1.2
V1N_CPU: PL902.3 PR939.2
V1N_VGA: PL803.3 PR858.1
V2N_CPU: PL903.3 PR941.2
V2N_VGA: PL802.3 PR829.1
V3N_CPU: PL904.3 PR944.2
VCC_VCORE2: PC919.1 PR933.1 PU902.4
VCCSENSE: JCPU1.AL35 PC903.2 PU901.35 R79.2
VCCSENSE_VGA: PR854.1 UV1.AF28
VDD_VGA: PC876.1 PR848.1 PU801.16
VIN: PC103.1 PC104.1 PL101.2 PL102.2 PQ301.5 PQ301.6 PQ301.7 PQ301.8 PR110.1 PR302.1 PR309.1 PR322.2 PR325.2
VIN_VGA: PC877.1 PR845.1 PU801.17
VSSSENSE: JCPU1.AK35 PC903.1 PC906.1 PR909.1 R84.1
VSSSENSE_VGA: PC849.2 PR847.1 PR860.1 UV1.AH29
24737_SN: PC320.1 PR323.2
81103_PWM: PR922.1 PU901.20 PU902.2
+1.1_AVDDL: CL17.1 CL18.1 CL19.1 CL20.1 CL21.1 LL2.2 LL3.1 UL1.6 UL1.13 UL1.19 UL1.31
+1.1_AVDDL_L: CL4.1 CL5.1 CL6.1 LL2.1 UL1.34
+1.1_DVDDL: CL1.2 CL2.1 CL3.1 CL25.1 CL26.1 LL1.1 LL3.2 UL1.37
+1.7_VDDCT: RL10.1 UL1.5
+2.7_AVDDH: CL22.1 CL23.1 CL24.1 UL1.9 UL1.22
+CHGRTC: PD101.2 PR101.1
+CHGRTC_R: JRTC1.1 PR102.2
+CPU_CORE: JCPU1.AA26 JCPU1.AA28 JCPU1.AA30 JCPU1.AA32 JCPU1.AA34 JCPU1.AB25 JCPU1.AB26 JCPU1.AB27 JCPU1.AB28 JCPU1.AB29 JCPU1.AB30 JCPU1.AB31 JCPU1.AB32 JCPU1.AB33 JCPU1.AB34 JCPU1.AB35 JCPU1.AC26 JCPU1.AC28 JCPU1.AC30 JCPU1.AC32 JCPU1.AC34 JCPU1.AD25 JCPU1.AD26 JCPU1.AD27 JCPU1.AD28 JCPU1.AD29 JCPU1.AD30 JCPU1.AD31 JCPU1.AD32 JCPU1.AD33 JCPU1.AD34 JCPU1.AD35 JCPU1.AE26 JCPU1.AE28 JCPU1.AE30 JCPU1.AE32 JCPU1.AE34 JCPU1.AF25 JCPU1.AF26 JCPU1.AF27 JCPU1.AF28 JCPU1.AF29 JCPU1.AF30 JCPU1.AF31 JCPU1.AF32 JCPU1.AF33 JCPU1.AF34 JCPU1.AF35 JCPU1.AG26 JCPU1.AG28 JCPU1.AG30 JCPU1.AG32 JCPU1.AG34 JCPU1.AH25 JCPU1.AH26 JCPU1.AH27 JCPU1.AH28 JCPU1.AH29 JCPU1.AH30 JCPU1.AH31 JCPU1.AH32 JCPU1.AH33 JCPU1.AH34 JCPU1.AH35 JCPU1.AJ25 JCPU1.AJ26 JCPU1.AJ27 JCPU1.AJ28 JCPU1.AJ29 JCPU1.AJ30 JCPU1.AJ31 JCPU1.AJ32 JCPU1.AJ33 JCPU1.AJ34 JCPU1.AJ35 JCPU1.F25 JCPU1.G25 JCPU1.H25 JCPU1.J25 JCPU1.K25 JCPU1.K26 JCPU1.L25 JCPU1.M25 JCPU1.N25 JCPU1.P25 JCPU1.R25 JCPU1.T25 JCPU1.U25 JCPU1.U26 JCPU1.V25 JCPU1.V26 JCPU1.W26 JCPU1.W27 JCPU1.Y25 JCPU1.Y26 JCPU1.Y27 JCPU1.Y28 JCPU1.Y29 JCPU1.Y30 JCPU1.Y31 JCPU1.Y32 JCPU1.Y33 JCPU1.Y34 JCPU1.Y35 PC946.1 PC947.1 PC949.1 PC950.1 PC951.1 PC952.1 PC953.1 PC954.1 PC955.1 PC956.1 PC957.1 PC958.1 PC959.1 PC960.1 PC961.1 PC962.1 PC963.1 PC964.1 PC965.1 PC966.1 PC967.1 PC968.1 PC969.1 PC970.1 PC971.1 PC972.1 PC973.1 PC974.1 PC975.1 PC976.1 PC977.1 PC978.1 PC979.1 PC980.1 PC981.1 PC982.1 PC983.1 PC984.1 PL902.4 PL903.4 PL904.4 R79.1
+DP_V33: CT1.1 CT2.1 CT3.1 LT1.1 UT2.3
+DP_VDDR: CV57.1 CV58.1 CV59.1 RV43.2 UV1.AF34 UV1.AG34 UV1.AH34 UV1.AJ34 UV1.AL38 UV1.AM32 UV1.AM37
+EC_VCCA: C656.1 C659.1 L44.2 PR226.1 U31.67
+LCDVDD_CONN: C516.1 JLVDS1.22 JLVDS1.23 R553.2 U72.1
+LDO_1.8V: CA24.1 CA25.1 UA1.3
+LDO_OUT_3.3V: CA3.2 CA4.1 UA1.27
+LEDVDD: C541.1 JLVDS1.1 JLVDS1.2 R813.1
+LX: LL1.2 UL1.40
+MICBIASB: RA19.1 RA20.1 UA1.34
+MICBIASC: RA23.1 UA1.35
+MPV18: CV33.1 CV34.1 CV35.1 LV4.2 UV1.H7 UV1.H8
+PCH_DCPRTC: C163.1 U4.P14 U4.P16
+PCH_USB_DCPSUS1: U4.Y12
+PCH_USB_DCPSUS2: U4.Y35
+PCH_USB_DCPSUS3: U4.AJ26 U4.AJ28
+PCH_VCC: C172.1 C174.1 LH2.2 U4.AP45
+PCH_VCCCFUSE: C175.1 R299.1 U4.P18 U4.P20
+PCH_VCCCLK: C176.1 C177.1 C178.1 C179.1 C180.1 R300.2 U4.AA30 U4.AA32 U4.AD34 U4.AD35 U4.AD36 U4.AE30 U4.AE32 U4.AG30 U4.AG32 U4.Y32
+PCH_VCCCLK3_3: C181.1 C182.1 C183.1 C184.1 R302.2 U4.L26 U4.L29 U4.M26 U4.M29 U4.U32 U4.V32
+PCH_VCCDSW: R290.2 U4.U14
+PCH_VCCDSW3_3: C155.1 R307.1 U4.A16
+PCH_VCCDSW_R: C149.1 R290.1
+PCH_VCCSST: C156.1 U4.AA14
+PCH_VPROC: C169.1 C170.1 C171.1 R297.1 U4.AJ12 U4.AJ14
+PCIE_VDDR: CV62.1 CV63.1 CV64.1 CV65.1 LV7.2 UV1.AB37
+RTCBATT: PD101.1 R94.2
+RTCVCC: C110.1 C164.1 C165.1 C166.1 R94.1 R96.1 R97.1 R98.1 R99.1 R134.1 R652.2 U4.A6
+SPLL_VDDC: CV43.1 CV44.1 CV45.1 LV6.2 UV1.AN9
+SPV18: CV38.1 CV39.1 CV40.1 LV5.2 UV1.AM10
+SWR_LX: LT3.2 R551.2 UT2.12
+SWR_V12: CT9.1 CT10.1 CT11.1 CT12.1 LT3.1 R551.1 UT2.7 UT2.11 UT2.27
+SWR_VDD: CT4.1 CT5.1 CT6.1 CT7.1 CT8.1 LT2.1 UT2.13 UT2.18
+TSVDD: CV30.1 CV31.1 CV32.1 LV3.2 UV1.AJ32
+USB3_VCCA: C736.1 JUSB1.1 JUSB2.1 U35.6 U35.7 U35.8
+USB_VCCB: C714.1 JUSB3.5 JUSB3.6 U36.6 U36.7 U36.8
+VCOMP_OUT: JCPU1.F22 R1.1 R60.1
+VGA_B+: PC801.1 PC802.1 PC803.1 PC804.1 PC878.1 PC879.1 PC880.1 PC881.1 PL801.1 PQ801.1 PQ802.1 PR845.2
+VGA_CORE: PC807.1 PC808.1 PC809.1 PC810.1 PC824.1 PC825.1 PC826.1 PC827.1 PC828.1 PC829.1 PC830.1 PC831.1 PC832.1 PC833.1 PC834.1 PC835.1 PC836.1 PC837.1 PC838.1 PC839.1 PC840.1 PC841.1 PC842.1 PC843.1 PC844.1 PC845.1 PC846.1 PC851.1 PC852.1 PC853.1 PC854.1 PC855.1 PC856.1 PC857.1 PL802.4 PL803.4 PR850.1 UV1.AA13 UV1.AA15 UV1.AA17 UV1.AA20 UV1.AA22 UV1.AA24 UV1.AA27 UV1.AB13 UV1.AB16 UV1.AB18 UV1.AB21 UV1.AB23 UV1.AB26 UV1.AB28 UV1.AC12 UV1.AC15 UV1.AC17 UV1.AC20 UV1.AC22 UV1.AC24 UV1.AC27 UV1.AD13 UV1.AD16 UV1.AD18 UV1.AD21 UV1.AD23 UV1.AD26 UV1.AF17 UV1.AF20 UV1.AF22 UV1.AG16 UV1.AG18 UV1.AH22 UV1.AH27 UV1.AH28 UV1.M15 UV1.M16 UV1.M18 UV1.M23 UV1.M26 UV1.N13 UV1.N15 UV1.N17 UV1.N20 UV1.N22 UV1.N24 UV1.R12 UV1.R13 UV1.R16 UV1.R18 UV1.R21 UV1.R23 UV1.R26 UV1.T12 UV1.T15 UV1.T17 UV1.T20 UV1.T22 UV1.T24 UV1.U16 UV1.U18 UV1.U21 UV1.U23 UV1.U26 UV1.V15 UV1.V17 UV1.V20 UV1.V22 UV1.V24 UV1.V27 UV1.Y13 UV1.Y16 UV1.Y18 UV1.Y21 UV1.Y23 UV1.Y26 UV1.Y28
+VREF_1V65: CA1.1 CA2.1 UA1.29
+VREF_CA: C67.1 C68.1 C90.1 C91.1 JDIMM1.126 JDIMM2.126 R40.2 R44.1 R47.2
+VREF_CA_R: C37.1 JCPU1.AM3 R47.1
+VREF_DQ_DIMMA: C65.1 C66.1 JDIMM1.1 R48.2 RP18.7 RP18.8
+VREF_DQ_DIMMA_R: C39.1 JCPU1.F16 R48.1
+VREF_DQ_DIMMB: C88.1 C89.1 JDIMM2.1 R49.2 RP18.5 RP18.6
+VREF_DQ_DIMMB_R: C40.1 JCPU1.F13 R49.1
+VREFC_A0: CV103.1 RV62.2 RV64.1 UV5.H1 UV5.M8
+VREFC_A1: CV104.1 RV63.2 RV65.1 UV6.H1 UV6.M8
+VREFC_A2: CV127.1 RV68.2 RV71.1 UV7.H1 UV7.M8
+VREFC_A3: CV126.1 RV67.2 RV70.1 UV8.H1 UV8.M8
+VREFC_B0: CV149.1 RV74.2 RV76.1 UV9.H1 UV9.M8
+VREFC_B1: CV150.1 RV75.2 RV77.1 UV10.H1 UV10.M8
+VREFC_B2: CV173.1 RV80.2 RV83.1 UV11.H1 UV11.M8
+VREFC_B3: CV172.1 RV78.2 RV82.1 UV12.H1 UV12.M8
+VREFG_GPU: CV23.1 RV13.1 RV14.1 UV1.AH13
+VSB: PJ202.2 R646.1 R647.1 RV41.2
+VTT_REFP: PC506.1 PU501.4
A_BA0: UV1.J17 UV5.M2 UV6.M2 UV7.M2 UV8.M2
A_BA1: UV1.H17 UV5.N8 UV6.N8 UV7.N8 UV8.N8
A_BA2: UV1.H16 UV5.M3 UV6.M3 UV7.M3 UV8.M3
AC_PRESENT_R: D1.2 R173.2 U4.E6
ACIN: C664.1 D1.1 DV1.1 PR314.2 PU101.6 R522.1 U31.110
ACN: PC308.1 PC311.2 PR301.3 PU301.1
ACOFF: PR311.1 U31.27
ACOFF-1: PD302.2 PQ305.2 PQ314.1 PR311.2
ACP: PC307.2 PC308.2 PR301.2 PU301.2
ACPRN: PQ308.2 PR307.2 PU301.5
ADP_65: PQ206.2 U31.21
ADP_90: PQ208.2 U31.68
ADP_135: PQ207.2 U31.85
ADP_I: PC304.2 PR227.2 PU301.7 U31.65
ADP_ID: JDCIN1.5 PC108.1 PC109.1 PQ102.1 U31.66
ADP_ID_CLOSE: PQ102.5 U31.25
ADP_OCP_1: PQ201.2 PR215.1 PR216.2
APDIN: JDCIN1.1 JDCIN1.2 PF101.1
APDIN1: PC101.1 PC102.1 PF101.2 PL101.1 PL102.1
APPLE_MIC: RA16.1 UA1.30
B+: PC310.2 PC318.2 PC985.1 PJ202.1 PL301.1 PL401.1 PL403.1 PL502.2 PL603.1 PL606.1 PL702.2 PL801.2 PL901.1 PQ312.1 PQ312.2 PQ312.3 PR301.4 PR402.1 R813.2
B+_0.95V: PC621.1 PC627.1 PC636.1 PL606.2 PU604.8
B+_1.5V: PC603.1 PC604.1 PC617.1 PL603.2 PU601.8
B_BA0: UV1.Y8 UV9.M2 UV10.M2 UV11.M2 UV12.M2
B_BA1: UV1.AA9 UV9.N8 UV10.N8 UV11.N8 UV12.N8
B_BA2: UV1.AA8 UV9.M3 UV10.M3 UV11.M3 UV12.M3
BATT+: PC203.1 PC322.1 PC323.1 PL201.2 PQ312.5 PQ312.6 PQ312.7 PQ312.8 PR324.4
BATT_CHG_LED#: JLED1.8 LED5.1 U31.90
BATT_LEN#: PQ205.2 PR220.1 U31.38
BATT_LOW_LED#: JLED1.7 LED2.1 U31.93
BATT_OUT: PQ202.6 PQ205.1 PQ306.2 PQ314.2 PR214.1
BATT_TEMP: C663.1 PR207.2 PU101.3 PU201.3 U31.63
BBS_BIT0_R: RP15.3 U4.AU2
BBS_BIT1: R182.1 U4.C10
BEEP#: CA37.1 U31.23
BKOFF#: JLVDS1.7 R716.1 U31.105
BLUE: C527.1 JCRT1.3 L32.2 U10.5
BOOT1_1_VGA: PC858.1 PR852.1
BOOT1_VGA: PR852.2 PU801.19
BOOT2_2_VGA: PC806.1 PR817.1
BOOT2_VGA: PR817.2 PU801.30
BQ24737VCC: PC314.1 PR319.1 PU301.20
BQ24737VDD: PC312.1 PD301.2 PR307.1 PR310.1 PU301.16
BRDID: R694.1 R695.2 U31.75
BST_0.95V: PC632.1 PU604.6
BST_1.5V: PC602.1 PU601.6
BST_1.05VSP: PR713.1 PU701.13
BST_1.05VSP_1: PC707.1 PR713.2
BST_1.35V: PR501.1 PU501.18
BST_1.35V-1: PC512.1 PR501.2
BST_3V: PR421.1 PU401.6
BST_3V_1: PC402.1 PR421.2
BST_5V: PR422.1 PU402.6
BST_5V_1: PC421.1 PR422.2
BST_CHG: PD301.1 PR320.1 PU301.17
BST_CPU_PHASE1: PR925.1 PU901.10
BST_CPU_PHASE1-1: PC915.1 PR925.2
BST_CPU_PHASE3: PR924.1 PU901.19
BST_CPU_PHASE3-2: PC913.1 PR924.2
BSTA2: PR936.1 PU902.1
BSTA2_1: PC923.1 PR936.2
BUF_CPU_RST#: JCPU1.AT26 R37.2
CAPS_LED#: JLED1.9 LED6.1 U31.91
CASA0#: UV1.K20 UV5.K3 UV6.K3
CASA1#: UV1.K17 UV7.K3 UV8.K3
CASB0#: UV1.W10 UV9.K3 UV10.K3
CASB1#: UV1.AA10 UV11.K3 UV12.K3
CFG0: JCPU1.AT20 T16.1(TP-1)
CFG1: JCPU1.AR20 T17.1(TP-1)
CFG2: JCPU1.AP20 R62.1
CFG3: JCPU1.AP22 T18.1(TP-1)
CFG4: JCPU1.AT22 R63.1
CFG5: JCPU1.AN22 R67.1
CFG6: JCPU1.AT25 R68.1
CFG7: JCPU1.AN23
CFG16: JCPU1.AR21 T19.1(TP-1)
CFG_RCOMP: JCPU1.AT31 R309.2
CHASSIS1_GND: CL30.2 CL61.2 CL62.2 CL63.2 CL64.2 DLL1.1 JLAN1.9 JLAN1.10
CHG: PL302.2 PR324.1
CHG_B+: PC313.2 PC315.2 PC316.2 PC319.2 PL301.2 PQ309.5 PQ309.6 PQ309.7 PQ309.8
CKEA0: UV1.K21 UV5.K9 UV6.K9
CKEA1: UV1.J20 UV7.K9 UV8.K9
CKEB0: UV1.U10 UV9.K9 UV10.K9
CKEB1: UV1.AA11 UV11.K9 UV12.K9
CLK_BUF_BCLK: R194.2 U4.AT24
CLK_BUF_BCLK#: R193.2 U4.AR24
CLK_BUF_CKSSCD: R203.2 U4.BC6
CLK_BUF_CKSSCD#: R202.2 U4.BE6
CLK_BUF_DMI: R192.2 U4.AW24
CLK_BUF_DMI#: R183.2 U4.AY24
CLK_BUF_DOT96: R199.2 U4.G33
CLK_BUF_DOT96#: R197.2 U4.H33
CLK_CPU_DMI: JCPU1.E26 U4.AF40
CLK_CPU_DMI#: JCPU1.D26 U4.AF39
CLK_CPU_DPLL: JCPU1.H28 U4.AF36
CLK_CPU_DPLL#: JCPU1.G28 U4.AF35
CLK_CPU_SSC_DPLL: JCPU1.E27 R26.2 U4.AJ39
CLK_CPU_SSC_DPLL#: JCPU1.F27 R27.2 U4.AJ40
CLK_ENABLE#_VGA: PR830.2 PU801.40
CLK_PCH_14M: R205.2 U4.F45
CLK_PCI_DB_R: U4.B42
CLK_PCI_EC: R211.1 R589.1 U31.12
CLK_PCI_EC_R: R211.2 U4.E44
CLK_PCI_LPBACK: R209.1 U4.D17
CLK_PCI_LPBACK_R: R209.2 U4.D44
CLK_PCIE_LAN: R187.1 UL1.33
CLK_PCIE_LAN#: R185.1 UL1.32
CLK_PCIE_LAN#_R: R185.2 U4.AD43
CLK_PCIE_LAN_R: R187.2 U4.AD45
CLK_PCIE_VGA: R188.2 UV1.AB35
CLK_PCIE_VGA#: R186.2 UV1.AA36
CLK_PCIE_VGA#_R: R186.1 U4.AB35
CLK_PCIE_VGA_R: R188.1 U4.AB36
CLK_PCIE_WLAN: JWLN1.13 R189.1
CLK_PCIE_WLAN#: JWLN1.11 R313.1
CLK_PCIE_WLAN#_R: R313.2 U4.AB43
CLK_PCIE_WLAN_R: R189.2 U4.AB45
CLK_REQ_VGA#: R178.2 UV1.AN13
CLKA0: RV60.1 UV1.H27 UV5.J7 UV6.J7
CLKA0#: RV61.1 UV1.G27 UV5.K7 UV6.K7
CLKA1: RV66.1 UV1.J14 UV7.J7 UV8.J7
CLKA1#: RV69.1 UV1.H14 UV7.K7 UV8.K7
CLKB0: RV72.1 UV1.L9 UV9.J7 UV10.J7
CLKB0#: RV73.1 UV1.L8 UV9.K7 UV10.K7
CLKB1: RV79.1 UV1.AD8 UV11.J7 UV12.J7
CLKB1#: RV81.1 UV1.AD7 UV11.K7 UV12.K7
CLKREQ_LAN#: R201.1 RL11.2 U4.T3 UL1.4
CLKREQ_WLAN#: JWLN1.7 R195.1 U4.AF3
CMOS_ON#: R435.1 U31.16
COMP_VGA: PC847.1 PC848.1 PC871.1 PC873.2 PR840.1 PR841.2 PU801.7
CPU_B+: PC920.1 PC925.1 PC932.1 PC933.1 PC938.1 PC939.1 PC942.1 PC943.1 PC944.1 PC945.1 PC986.1 PC988.1 PL901.2 PQ901.5 PQ903.5 PQ905.5 PR907.2
CPU_PLTRST#: R37.1 U4.AU4
CRT_DDC_CLK: R126.2 U4.M43 U10.11
CRT_DDC_CLK_CONN: JCRT1.15 R33.2 U10.12
CRT_DDC_DAT_CONN: JCRT1.12 R31.2 U10.9
CRT_DDC_DATA: R125.2 U4.M45 U10.10
CRT_HSYNC: U4.N42 U10.15
CRT_IREF: R132.2 U4.U40
CRT_VSYNC: U4.N44 U10.13
CSA0#_0: UV1.K24 UV5.L2 UV6.L2
CSA1#_0: UV1.M13 UV7.L2 UV8.L2
CSB0#_0: UV1.P10 UV9.L2 UV10.L2
CSB1#_0: UV1.AD10 UV11.L2 UV12.L2
CSCOMP: PC901.1 PC910.1 PH901.2 PR901.1 PR913.2 PU901.27
CSP1: PC918.2 PR928.1 PR931.2 PU901.22
CSP2: PC917.2 PR927.1 PR930.2 PR932.2 PU901.23
CSP3: PC916.2 PR926.1 PR929.2 PU901.24
CSREF: PC911.1 PC916.1 PC917.1 PC918.1 PR926.2 PR927.2 PR928.2 PR939.1 PR941.1 PR944.1 PU901.25
CSSUM: PC901.2 PC910.2 PR911.2 PR918.1 PR919.1 PR920.1 PU901.26
DAC_BLU: C524.1 L32.1 RP22.5 RP23.5 U4.T45
DAC_GRN: C523.1 L31.1 RP22.6 RP23.6 U4.U44
DAC_RED: C522.1 L30.1 RP22.7 RP23.7 U4.V45
DDR3_DRAMRST#: JDIMM1.30 JDIMM2.30 R46.2
DDR_A_BS0: JCPU1.V5 JDIMM1.109
DDR_A_BS1: JCPU1.U5 JDIMM1.108
DDR_A_BS2: JCPU1.AD1 JDIMM1.79
DDR_A_CAS#: JCPU1.U8 JDIMM1.115
DDR_A_D0: JCPU1.AR15 JDIMM1.5
DDR_A_D1: JCPU1.AT14 JDIMM1.7
DDR_A_D2: JCPU1.AM14 JDIMM1.15
DDR_A_D3: JCPU1.AN14 JDIMM1.17
DDR_A_D4: JCPU1.AT15 JDIMM1.4
DDR_A_D5: JCPU1.AR14 JDIMM1.6
DDR_A_D6: JCPU1.AN15 JDIMM1.16
DDR_A_D7: JCPU1.AM15 JDIMM1.18
DDR_A_D8: JCPU1.AM9 JDIMM1.21
DDR_A_D9: JCPU1.AN9 JDIMM1.23
DDR_A_D10: JCPU1.AM8 JDIMM1.33
DDR_A_D11: JCPU1.AN8 JDIMM1.35
DDR_A_D12: JCPU1.AR9 JDIMM1.22
DDR_A_D13: JCPU1.AT9 JDIMM1.24
DDR_A_D14: JCPU1.AR8 JDIMM1.34
DDR_A_D15: JCPU1.AT8 JDIMM1.36
DDR_A_D16: JCPU1.AJ9 JDIMM1.39
DDR_A_D17: JCPU1.AK9 JDIMM1.41
DDR_A_D18: JCPU1.AJ6 JDIMM1.51
DDR_A_D19: JCPU1.AK6 JDIMM1.53
DDR_A_D20: JCPU1.AJ10 JDIMM1.40
DDR_A_D21: JCPU1.AK10 JDIMM1.42
DDR_A_D22: JCPU1.AJ7 JDIMM1.50
DDR_A_D23: JCPU1.AK7 JDIMM1.52
DDR_A_D24: JCPU1.AF4 JDIMM1.57
DDR_A_D25: JCPU1.AF5 JDIMM1.59
DDR_A_D26: JCPU1.AF1 JDIMM1.67
DDR_A_D27: JCPU1.AF2 JDIMM1.69
DDR_A_D28: JCPU1.AG4 JDIMM1.56
DDR_A_D29: JCPU1.AG5 JDIMM1.58
DDR_A_D30: JCPU1.AG1 JDIMM1.68
DDR_A_D31: JCPU1.AG2 JDIMM1.70
DDR_A_D32: JCPU1.J1 JDIMM1.129
DDR_A_D33: JCPU1.J2 JDIMM1.131
DDR_A_D34: JCPU1.J5 JDIMM1.141
DDR_A_D35: JCPU1.H5 JDIMM1.143
DDR_A_D36: JCPU1.H2 JDIMM1.130
DDR_A_D37: JCPU1.H1 JDIMM1.132
DDR_A_D38: JCPU1.J4 JDIMM1.140
DDR_A_D39: JCPU1.H4 JDIMM1.142
DDR_A_D40: JCPU1.F2 JDIMM1.147
DDR_A_D41: JCPU1.F1 JDIMM1.149
DDR_A_D42: JCPU1.D2 JDIMM1.157
DDR_A_D43: JCPU1.D3 JDIMM1.159
DDR_A_D44: JCPU1.D1 JDIMM1.146
DDR_A_D45: JCPU1.F3 JDIMM1.148
DDR_A_D46: JCPU1.C3 JDIMM1.158
DDR_A_D47: JCPU1.B3 JDIMM1.160
DDR_A_D48: JCPU1.B5 JDIMM1.163
DDR_A_D49: JCPU1.E6 JDIMM1.165
DDR_A_D50: JCPU1.A5 JDIMM1.175
DDR_A_D51: JCPU1.D6 JDIMM1.177
DDR_A_D52: JCPU1.D5 JDIMM1.164
DDR_A_D53: JCPU1.E5 JDIMM1.166
DDR_A_D54: JCPU1.B6 JDIMM1.174
DDR_A_D55: JCPU1.A6 JDIMM1.176
