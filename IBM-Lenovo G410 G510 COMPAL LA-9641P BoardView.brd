# Allegro board IBM-Lenovo G410 G510 COMPAL LA-9641P BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HG3: length 13.3
  TOP w0.102: v1(28.96,118.32) 28.89,118.39 v4(28.23,118.39)
  IN2 w1.016: 26.34,106.18 26.34,107.77 28.87,110.3 28.87,117.62
  vias: v4(25.37,106.51) v4(25.36,105.85) v4(27.55,118.39)
HGNDA: length 182.6
  TOP w0.203: UA1.25 153.19,49.27 152.23,50.23 v2(151.84,50.23)
  IN1 w1.016: 146.29,55.04 144.34,56.99 142.4,56.99 141.38,55.97 135.54,55.97 131.76,52.19 131.76,48.67 129.63,46.54 126.11,46.54 123.45,43.89 123.45,26.89 121.05,24.49 120.82,24.49
  IN2 w1.016: 16.43,15.75 16.43,15.14 15.71,14.42 15.71,2.67 14.7,1.66 6.73,1.66 4.93,3.46 JHP1.3
  BOTTOM w1.016: 23.9,16.41 24.81,17.32 41.32,17.32 50.52,26.51 89.95,26.51 93.94,22.53 118.74,22.53 119.02,22.8
  vias: v2(17.32,16.09) v2(17.31,15.51) v2(119.85,23.14) v2(120.32,23.61) v2(151.2,50.21)
HGNDB: length 188.3
  TOP w0.102: v2(17.28,13.54) v3(17.87,13.54)
  TOP w0.203: UA1.26 152.85,48.87 152.34,49.38 v2(152.01,49.38)
  IN1 w1.016: 16.12,13.62 16.12,13.62 16.12,5.18 14,3.05 3.33,3.05 2.5,3.88 JHP1.4 ; 121.59,23.04 124.72,26.17 124.72,43.36 126.6,45.24 130.12,45.24 133.03,48.14 133.03,51.67 136.06,54.7 143.91,54.7 146.22,52.4 146.22,49.36 146.96,48.62 150.38,48.62
  BOTTOM w1.016: 24.12,13.41 26.77,16.05 45.19,16.05 54.03,24.89 89,24.89 93.24,20.65 119.39,20.65 119.84,21.1
  vias: v2(17.25,14.13) v2(120.37,21.79) v2(120.85,22.25) v2(151.31,49.39)
HP_L: length 12
  TOP w0.203: v2(153.13,51.57) 153.13,50.79 153.45,50.47 UA1.22
  TOP w0.254: CA36.2 RA20.2 147.57,52.51 RA13.1 147.57,53.5 148.05,53.98 v2(148.09,53.98)
  IN2 w0.254: v2(153.13,51.57) 153.13,51.93 152.66,52.4 151.88,52.4 151.27,51.79 148.89,51.79 148.09,52.59 v2(148.09,53.98)
HP_R: length 11.1
  TOP w0.203: v2(152.51,51.66) 152.51,51.53 152.78,51.27 v1(152.78,51.15) 152.78,50.71 153.41,50.07 UA1.23
  TOP w0.254: v2(147.31,49.87) 147.31,50.34 RA14.1 147.56,50.59 RA19.2 CA46.2
  IN2 w0.254: v2(147.31,49.87) 148.46,51.02 151.84,51.02 152.48,51.66 v2(152.51,51.66)
HPOUT_L: length 184.2
  TOP w0.254: RA13.2 146.65,53.79 v2(146.95,54.09)
  IN2 w0.254: JHP1.1 10.5,4.1 11.02,3.58 14,3.58 14.37,3.95 14.37,12.19 v2(14.37,12.19)
  BOTTOM w0.254: v2(146.95,54.09) 146.31,54.72 139.38,54.72 138.9,54.25 133.71,54.25 125.37,45.9 125.37,23.39 120.06,18.08 107.13,18.08 106.51,18.7 92.11,18.7 87.74,23.07 54.63,23.07 45.96,14.4 28.39,14.4 24.38,10.39 CA34.1 21.5,10.39 20.98,9.87 DA2.2 16.7,9.87 v2(14.37,12.19)
HPOUT_R: length 184.9
  TOP w0.102: v1(147.78,49.43) 148.1,49.74 v2(148.1,49.84)
  TOP w0.254: v2(148.1,49.84) 148.1,50.07 148.46,50.43 RA14.2
  BOTTOM w0.254: v2(148.1,49.84) 148.1,52.38 147.48,53 147.48,54.96 146.96,55.48 139.06,55.48 138.59,55.01 133.4,55.01 124.6,46.22 124.6,23.7 119.74,18.84 107.45,18.84 106.83,19.47 92.43,19.47 88.06,23.84 54.31,23.84 45.64,15.16 28.08,15.16 24.2,11.28 CA33.1 21.37,11.28 20.86,11.8 DA2.3 16.35,11.8 14.18,13.97 14.18,17.67 13.89,17.96 11.3,17.96 JHP1.2
HSYNC: length 4.4
  BOTTOM w0.102: T4.1 139.09,124.49 139.09,127.95 138.65,128.39 UV1.AC36
ILMT_0.95V: length 5.5
  TOP w0.102: PR609.1 173.97,131.5 v1(174.23,131.76)
  TOP w0.254: PU604.3 171.78,129.24 171.18,129.84 171.18,130.31 171.79,130.92 171.79,131.05 172.17,131.43 PR618.2 PR609.1
ILMT_1.5V: length 3.9
  TOP w0.102: PR605.1 v1(196.6,13.26)
  TOP w0.254: PR605.1 198.66,13.26 PR604.2 198.66,12.94 198.16,12.44 v2(198.16,12.43)
  BOTTOM w0.254: PU601.3 v2(198.16,12.43)
IMVP_IMON: length 198.4
  TOP w0.102: U31.73 159.95,85.76 v1(159.16,84.97) 159.04,84.85 155.73,84.85 154.81,85.77 154.81,87.99 154.2,88.59 154.2,91.34 154.59,91.73 v2(154.59,92.17)
  IN2 w0.127: v2(19.46,118.75) 19.62,118.75 20.43,119.57 20.43,122.34 21.68,123.6 26.63,123.6 27.11,124.08 30.05,124.08 32.77,126.79 45.1,126.79 46.11,125.78 46.11,121.44 50.33,117.22 51.13,117.22 52.42,115.92 67.71,115.92 71.92,120.13 77.16,120.13 79.9,117.39 100.07,117.39 100.75,118.07 101.42,118.07 102.51,116.98 106.11,116.98 107.9,118.76 129.32,118.76 132.08,116 141.45,116 141.96,115.49 152.42,115.49 152.89,115.96 v2(157.2,115.96)
  BOTTOM w0.102: v2(157.2,115.96) 157.2,98.42 154.85,96.07 154.85,92.43 v2(154.59,92.17)
  BOTTOM w0.203: PC908.1 19.2,118.49 v2(19.46,118.75) 19.72,118.75 19.98,119.02 19.98,119.67 20.43,120.12 PU901.29
  BOTTOM w0.254: PR912.2 18.56,117.6 PC908.1
INTEL_BT_OFF#: length 153.6
  TOP w0.089: U4.AN6 121.54,92.19 v2(121.3,91.96)
  TOP w0.102: v2(196.56,162.72) 198.41,164.56 R405.1 ; RP15.7 116.69,103.52 v2(116.45,103.76) 116.45,104.31 v1(116.2,104.56)
  IN1 w0.089: v2(121.3,91.96) 120.92,92.34 120.92,93.04 120.3,93.66 120.3,94.79
  IN1 w0.127: 120.3,94.79 120.3,96.44 119.25,97.49 119.25,99.8 116.45,102.6 v2(116.45,103.76)
  IN2 w0.127: v2(116.45,103.76) 116.46,103.76 118.36,105.65 123.5,105.65 125.15,107.31 125.38,107.31 126.89,108.81 130.21,108.81 130.83,109.43 139.66,109.43 140.41,110.18 156.59,110.18 158.93,107.85 184.11,107.85 192.03,115.76 192.03,117.02 197.9,122.89 197.9,130.33 196.59,131.63 196.59,149.82 198.04,151.27 198.04,159.06 196.56,160.54 v2(196.56,162.72)
INVT_PWM: length 3.3
  TOP w0.102: v1(99.27,148.05) 99.78,148.56 R441.2 98.96,149.37 JLVDS1.8
ISEN1_VGA: length 15.4
  TOP w0.102: v1(183.55,147.58) 183.74,147.77 v2(184.03,147.77)
  TOP w0.203: PU801.11 189.02,141.16 189.17,141.3 190.69,141.3 v2(190.77,141.21)
  TOP w0.254: PR864.2 191.22,141.67 v2(190.77,141.21)
  IN2 w0.254: v2(184.03,147.77) 184.25,147.77 185.33,146.69 186,146.69 189.61,143.08 189.61,142.29 190.69,141.21 v2(190.77,141.21)
  BOTTOM w0.254: PR857.2 v2(184.03,147.77) ; v2(190.77,141.21) 190.96,141.4 PC875.1
ISEN2_VGA: length 14.9
  TOP w0.102: v1(193.94,142.64) 193,141.7 PR863.1
  TOP w0.203: v2(190.86,140.37) 190.47,140.37 190.15,140.06 PU801.10
  TOP w0.254: v2(190.86,140.37) 191.24,140.75 PR864.1 191.92,140.75 192.83,141.67 PR863.1
  IN1 w0.254: v2(184.13,143.64) 185.38,143.64 186.55,142.46 187.39,142.46 189.48,140.37 v2(190.86,140.37)
  BOTTOM w0.254: PR828.2 184.01,143.53 v2(184.13,143.64) ; PC850.1 191,140.51 v2(190.86,140.37)
ISEN3_VGA: length 2.2
  TOP w0.203: PU801.9 190.24,139.66 190.44,139.85 v1(190.81,139.85) 191.76,139.85 PC871.2
ISUM-_VGA: length 5.6
  TOP w0.203: v2(188.12,142.65) 188.12,141.82 187.82,141.52 PU801.14
  BOTTOM w0.254: PC864.2 185.63,142.81 185.63,142.38 PR862.1 185.97,142.16 186.42,142.6 186.48,142.54 186.88,142.54 187,142.65 v1(187.28,142.65) v2(188.12,142.65)
JSENSE: length 7.2
  TOP w0.203: UA1.38 157.45,46.1 157.57,45.98 157.57,45.6 158.24,44.93 158.53,44.93 v1(159.31,44.15) 159.57,43.89 RA5.1
  TOP w0.254: RA5.1 161.17,43.89 RA8.1 RA7.1 RA6.1
JTAG_TCK: length 2
  TOP w0.102: v3(145.37,139.04) 144.67,139.04 v2(144.24,139.47)
  BOTTOM w0.102: v2(144.24,139.47) 144.45,139.26 UV1.AK23
JTAG_TDI: length 2.3
  TOP w0.102: v3(148.56,137.69) 148,138.25 v2(147.28,138.25)
  BOTTOM w0.102: UV1.AN23 146.85,138.68 v2(147.28,138.25)
JTAG_TDO: length 1.9
  TOP w0.102: v2(146.67,138.29) 146.68,138.29 v3(147.42,139.02)
  BOTTOM w0.102: v2(146.67,138.29) 146.05,137.67 UV1.AM24
JTAG_TMS: length 2
  TOP w0.102: v2(145.27,138.33) 145.27,137.88 144.76,137.37 v3(144.76,137.25)
  BOTTOM w0.102: v2(145.27,138.33) 145.25,138.31 UV1.AL24
JTAG_TRSTB: length 1.9
  TOP w0.102: v3(146.79,137.37) 146.79,137.53 146.03,138.29 v2(145.96,138.29)
  BOTTOM w0.102: v2(145.96,138.29) 146.05,138.38 UV1.AM23
JVGA_HS: length 3.2
  BOTTOM w0.102: U10.16 R412.1 14.03,122.25 v1(13.62,122.65)
JVGA_HS_R: length 11.1
  TOP w0.102: v2(14.46,123.85) v1(14.46,123.33)
  IN2 w0.127: JCRT1.13 7.71,118.91 8.54,118.91 13.48,123.85 v2(14.46,123.85)
  BOTTOM w0.102: R412.2 14.59,123.72 v2(14.46,123.85) 14.59,123.97 C412.1
JVGA_VS: length 3.9
  BOTTOM w0.102: U10.14 13.32,121.5 R411.1 12.15,122.21 11.53,122.83 v1(11.53,123.09)
JVGA_VS_R: length 8.8
  IN2 w0.127: v2(12.61,123.83) 9.71,120.94 JCRT1.14
  BOTTOM w0.102: R411.2 v2(12.61,123.83) C411.1 v1(11.48,124.44)
KBRST#: length 122
  TOP w0.089: U4.AT6 120.67,92.19 v2(120.34,91.87)
  TOP w0.102: v2(112.76,101.9) 112.95,102.09 112.95,103.68 113.31,104.05 114.84,104.05 115.39,103.5 RP15.9 ; v2(173.93,77.39) 174.49,77.39 174.93,76.96 U31.2
  IN1 w0.089: 117.66,94.79 117.66,94.27 118.22,93.71 119.49,93.71 120.34,92.86 v2(120.34,91.87)
  IN1 w0.127: 117.66,94.79 117.66,95.62 117.3,95.98 117.3,98.73 114.71,101.32 114.08,101.32 113.49,101.9 v2(112.76,101.9)
  IN2 w0.127: v2(167.47,109.95) 167.47,110.16 166.17,111.45 159.04,111.45 158.3,112.19 138.23,112.19 137.49,111.45 132.97,111.45 132.22,110.7 130.27,110.7 129.65,110.09 126.35,110.09 124.88,108.62 124.6,108.62 122.91,106.92 115.08,106.92 112.49,104.33 112.49,102.17 v2(112.76,101.9)
  BOTTOM w0.102: v2(173.93,77.39) 173.93,77.67 172.16,79.45 172.16,80.69 170.67,82.18 170.67,84.55 171.55,85.43 171.55,86.8 170.61,87.74 v1(170.61,90.43) 170.61,91.22 171.09,91.7 171.09,93.06 170.96,93.19 170.96,94.35 171.03,94.41 171.03,97.3 167.32,101.01 167.32,109.46 167.47,109.61 v2(167.47,109.95)
KSI0: length 29.5
  TOP w0.102: v2(166.49,92.8) 166.49,92.61 v1(166.02,92.14) 165.99,92.1 U31.55 ; JKB2.13 164.04,101.86 164.54,101.36 165.86,101.36 166.33,100.89 168.04,100.89 169.3,99.63 172.69,99.63 173.2,99.11 JKB1.12 173.2,96.54 173.38,96.37 v2(173.67,96.37)
  IN2 w0.127: v2(173.67,96.37) 173.03,95.73 173.03,93.74 173.38,93.39 173.38,91.89 173.13,91.64 167.2,91.64 166.49,92.35 v2(166.49,92.8)
KSI1: length 37.4
  TOP w0.102: v1(166.26,93.52) 166.26,93.22 v2(165.59,92.54) U31.56 ; v2(174.04,104.58) 174.47,104.58 175.04,104.01 JKB2.24 175.04,102.3 175.19,102.14 176.76,102.14 178.55,100.35 183.27,100.35 184.2,99.42 JKB1.1
  IN1 w0.127: v2(165.59,92.54) 166.25,93.2 166.25,94.11 165.85,94.51 165.85,101.29 167.89,103.33 171.96,103.33 173.22,104.58 v2(174.04,104.58)
KSI2: length 30.8
  TOP w0.102: v2(165.58,93.13) 165.18,92.73 165.18,91.6 165.19,91.6 U31.57 ; v2(167.85,103.98) 168.04,103.8 JKB2.17 168.04,102.18 169.68,100.54 176.09,100.54 177.2,99.43 JKB1.8 177.2,96.24 v1(176.82,95.86)
  IN1 w0.127: v2(165.58,93.13) 165.59,93.13 166,93.54 166,93.98 165.59,94.39 165.59,101.72 v2(167.85,103.98)
KSI3: length 29.3
  TOP w0.102: JKB1.9 176.2,99.61 175.5,100.31 169.58,100.31 168.33,101.57 167.72,101.57 167.04,102.26 JKB2.16 167.04,103.87 v2(166.91,104) ; v2(165.58,93.71) 165.02,93.71 164.95,93.65 v1(164.95,93.18) 164.95,92.3 164.79,92.14 U31.58
  IN1 w0.127: v2(166.91,104) 165.32,102.41 165.32,93.97 v2(165.58,93.71)
KSI4: length 36.1
  TOP w0.102: v2(164.45,92.53) 164.39,92.46 U31.59 ; v2(171.15,103.93) 171.04,103.82 JKB2.20 171.04,102.02 171.83,101.23 176.38,101.23 178.17,99.44 179.25,99.44 180.2,98.49 JKB1.5 180.2,95.56 v3(180.72,95.04)
  IN1 w0.127: v2(171.15,103.93) 170.67,104.42 165.93,104.42 165.06,103.55 165.06,93.14 v2(164.45,92.53)
KSI5: length 38.8
  TOP w0.102: v2(171.15,104.57) 170.04,103.45 JKB2.19 170.04,101.71 170.75,101 176.28,101 179.2,98.08 JKB1.6 179.2,96.77 179.66,96.31 179.66,94.23 v3(179.31,93.88) ; v2(164.44,93.11) 163.99,92.66 U31.60
  IN1 w0.127: v2(164.44,93.11) 164.81,93.48 164.81,103.66 165.82,104.67 171.05,104.67 v2(171.15,104.57)
KSI6: length 39.4
  TOP w0.102: U31.61 163.59,91.47 163.75,91.63 163.75,93.05 v2(164.39,93.7) ; v3(182.47,95.64) 182.2,95.91 JKB1.3 182.2,99.06 181.37,99.9 178.36,99.9 176.57,101.69 173.57,101.69 173.04,102.21 JKB2.22 173.04,103.98 172.44,104.58 v2(172,104.58)
  IN1 w0.127: v2(172,104.58) 171.6,104.99 165.78,104.99 163.58,102.79 163.58,95.3 164.39,94.48 v2(164.39,93.7)
KSI7: length 42.6
  TOP w0.102: v2(163.28,92.17) 163.19,92.08 U31.62 ; v3(182.29,93.2) 182.29,94.02 183.2,94.93 JKB1.2 183.2,99.4 182.48,100.12 178.45,100.12 176.66,101.91 174.45,101.91 174.04,102.33 JKB2.23 v2(174.04,104)
  IN1 w0.127: v2(174.04,104) 173.23,104 172.2,102.97 168.04,102.97 166.18,101.11 166.18,94.8 167.19,93.79 167.19,92.55 166.5,91.86 163.6,91.86 v2(163.28,92.17)
KSO0: length 31.1
  TOP w0.102: v2(172.96,92.06) 172.39,91.49 U31.39 ; v1(178.61,95.84) 178.2,96.25 JKB1.7 178.2,98.76 176.19,100.77 169.77,100.77 169.04,101.51 JKB2.18 v2(169.04,104)
  BOTTOM w0.102: v2(169.04,104) 169.04,100.92 172.33,97.62 172.33,92.68 v2(172.96,92.06)
KSO1: length 22.8
  TOP w0.102: v2(172.32,92.06) 171.99,91.73 U31.40 ; JKB2.14 165.04,102.07 165.53,101.58 165.95,101.58 166.42,101.11 168.14,101.11 169.4,99.86 173.42,99.86 174.2,99.07 JKB1.11 174.2,96.53 174.35,96.38 v2(174.73,96.38) 175.08,96.04 v1(175.08,95.79)
  IN1 w0.127: v2(172.32,92.06) 172.32,95.31 172.94,95.92 174.27,95.92 v2(174.73,96.38)
KSO2: length 22
  TOP w0.102: v2(171.69,92.06) 171.59,91.96 U31.41 ; JKB2.12 163.04,101.78 163.69,101.13 165.76,101.13 166.23,100.66 167.95,100.66 169.21,99.4 171.7,99.4 172.2,98.9 JKB1.13 172.2,96.87 v2(171.7,96.37) 171.89,96.17 172.98,96.17 v1(173.24,95.92)
  IN1 w0.127: v2(171.7,96.37) 171.94,96.13 171.94,92.31 v2(171.69,92.06)
KSO3: length 24.8
  TOP w0.102: U31.42 171.19,91.49 171.28,91.58 171.28,92.41 v2(171.5,92.63) ; JKB2.7 158.04,101.15 158.27,100.92 159.89,100.92 160.83,99.98 165.29,99.98 167.2,98.07 JKB1.18 167.2,96.52 167.34,96.38 v2(167.75,96.38) 167.75,95.91 v3(167.6,95.76)
  IN1 w0.127: v2(167.75,96.38) 167.75,95.75 169.32,94.18 169.32,92.2 169.71,91.81 170.68,91.81 v2(171.5,92.63)
KSO4: length 21.3
  TOP w0.102: JKB2.11 162.04,101.33 162.47,100.9 165.67,100.9 166.14,100.43 167.85,100.43 169.11,99.17 170.59,99.17 171.2,98.56 JKB1.14 171.2,96.67 170.78,96.24 v2(170.62,96.24) ; v2(171.47,93.22) 171.36,93.22 170.95,92.8 v1(170.95,92.12) 170.95,91.6 170.79,91.44 U31.43
  IN1 w0.127: v2(171.47,93.22) 171.13,93.22 170.96,93.39 170.96,94.03 171.15,94.23 171.15,95.71 v2(170.62,96.24)
KSO5: length 35.5
  TOP w0.102: v2(171.45,93.8) 171.44,93.79 170.91,93.79 v1(170.83,93.7) 170.61,93.48 170.61,91.63 170.39,91.42 U31.44 ; v2(169.02,105.41) 166.94,105.41 166.04,104.51 JKB2.15 166.04,102.19 166.89,101.34 168.23,101.34 169.49,100.09 174.33,100.09 175.2,99.21 JKB1.10
  BOTTOM w0.102: v2(169.02,105.41) 168.63,105.02 168.63,100.56 172.11,97.09 172.11,94.45 v2(171.45,93.8)
KSO6: length 21.9
  TOP w0.102: v1(169.31,95.69) 168.43,95.69 v2(168.25,95.88) 168.2,95.92 JKB1.17 168.2,99.11 167.57,99.74 165.85,99.74 165.38,100.21 160.92,100.21 159.04,102.1 JKB2.8 ; U31.45 169.99,92.07 v2(170.15,92.23)
  IN1 w0.127: v2(168.25,95.88) 169.58,94.55 169.58,92.54 169.89,92.23 v2(170.15,92.23)
KSO7: length 22.6
  TOP w0.102: v2(170.04,92.81) 170.04,92.79 169.74,92.5 169.74,91.58 169.59,91.43 U31.46 ; v1(171.19,95.83) 171.01,95.65 170.1,95.65 169.79,95.97 v2(169.79,96.27) 170.08,96.27 170.2,96.4 JKB1.15 170.2,98.58 169.84,98.94 169.02,98.94 167.76,100.2 166.04,100.2 165.57,100.67 162.37,100.67 161.04,102 JKB2.10
  IN1 w0.127: v2(170.04,92.81) 170.2,92.97 170.33,92.97 170.58,93.22 170.58,93.57 170.17,93.98 170.17,95.88 v2(169.79,96.27)
KSO8: length 21.7
  TOP w0.102: v2(168.73,96.2) 168.97,96.2 169.2,96.43 JKB1.16 169.2,98.43 167.66,99.97 165.95,99.97 165.48,100.44 161.84,100.44 160.04,102.25 JKB2.9 ; U31.47 169.19,91.4 169.45,91.67 169.45,92.65 v1(169.32,92.78) 169.32,93.63 169.48,93.8 169.96,93.8 170.03,93.73 v2(170.03,93.4)
  IN1 w0.127: v2(170.03,93.4) 169.87,93.56 169.87,95.07 v2(168.73,96.2)
KSO9: length 33.9
  TOP w0.102: v2(168.9,92.19) 168.8,92.09 168.8,90.6 U31.48 ; JKB2.21 172.04,102.26 172.84,101.46 176.47,101.46 178.26,99.67 179.97,99.67 181.2,98.43 JKB1.4 181.2,96.44 181.76,95.88 181.76,93.4 181.01,92.66 v1(180.5,92.66) 179.92,92.66 178.7,93.88 v2(178.7,94.28)
  IN1 w0.127: v2(178.7,94.28) 177.22,94.28 174.43,91.49 169.6,91.49 v2(168.9,92.19)
KSO10: length 24.6
  TOP w0.102: U31.49 168.39,91.51 168.47,91.59 168.47,92.35 168.81,92.69 v2(168.81,92.77) ; JKB2.2 153.04,102.18 153.17,102.04 153.83,102.04 154.3,101.57 155.36,101.57 158.09,98.84 161.65,98.84 162.2,98.29 JKB1.23 162.2,96.53 162.34,96.4 162.96,96.4 163.8,95.55 164.17,95.55 v2(164.37,95.35) 164.64,95.08 v1(164.64,94.88)
  IN2 w0.127: v2(164.37,95.35) 165.28,95.35 166.59,94.03 167.81,94.03 168.05,93.79 168.35,93.49 168.35,93.2 168.78,92.77 v2(168.81,92.77)
KSO11: length 23.6
  TOP w0.102: v2(164.38,95.95) 163.93,95.95 163.89,96 v1(163.85,96) 163.82,96 163.2,96.62 JKB1.22 163.2,98.69 162.82,99.07 158.19,99.07 155.45,101.8 154.39,101.8 154.04,102.16 JKB2.3 ; v2(168.79,93.36) 168.4,92.97 168.4,92.61 168.24,92.45 168.24,91.73 167.99,91.48 U31.50
  IN2 w0.127: v2(164.38,95.95) 165.14,95.95 166.63,94.46 167.86,94.46 168.79,93.54 v2(168.79,93.36)
KSO12: length 23.2
  TOP w0.102: JKB2.6 157.04,101.54 157.88,100.7 159.79,100.7 160.73,99.76 165.19,99.76 166.2,98.75 JKB1.19 166.2,96.53 166.35,96.38 v2(166.73,96.38) ; v1(167.96,93.9) 168.13,93.74 168.13,92.67 167.98,92.52 167.98,92.43 167.79,92.24 v2(167.79,92.19) 167.59,91.98 U31.51
  IN1 w0.127: v2(167.79,92.19) 168.31,92.71 168.31,94.8 v2(166.73,96.38)
KSO13: length 21.8
  TOP w0.102: v2(166.73,95.74) 166.47,96.01 v1(165.64,96.01) 165.62,96.01 165.2,96.42 JKB1.20 165.2,99.02 164.7,99.53 160.64,99.53 159.81,100.35 157.78,100.35 156.04,102.09 JKB2.5 ; v2(167.64,92.77) 167.36,92.49 167.36,92.18 167.19,92.01 U31.52
  IN1 w0.127: v2(167.64,92.77) 168.06,93.19 168.06,94.41 v2(166.73,95.74)
KSO14: length 22.4
  TOP w0.102: v2(167.64,93.41) 167.13,92.9 167.13,92.32 166.79,91.98 U31.53 ; v2(166.73,95.15) 166.44,94.85 v1(166.25,94.85) 165.82,94.85 164.96,95.72 164.96,96.03 164.2,96.79 JKB1.21 164.2,99.02 163.92,99.3 158.28,99.3 155.55,102.03 155.15,102.03 155.04,102.14 JKB2.4
  IN1 w0.127: v2(166.73,95.15) 167.64,94.24 v2(167.64,93.41)
KSO15: length 26.9
  TOP w0.102: v2(162.99,95.76) 162.61,96.14 162.17,96.14 161.78,95.76 v1(161.41,95.76) 161.32,95.76 161.2,95.88 JKB1.24 161.2,98.19 160.78,98.61 158,98.61 155.26,101.35 154.2,101.35 153.73,101.81 152.29,101.81 152.04,102.07 JKB2.1 ; v2(166.77,93.32) 166.9,93.19 166.9,92.51 166.39,92 U31.54
  IN1 w0.127: v2(162.99,95.76) 162.99,95.49 163.97,94.51 163.97,92.41 164.27,92.11 166.4,92.11 166.91,92.63 166.91,93.18 v2(166.77,93.32)
KSO16: length 26.3
  TOP w0.102: JKB1.25 160.2,96.09 160.88,95.41 162.04,95.41 v2(162.37,95.74) ; v1(157.45,82.41) 159.28,82.41 159.43,82.56 U31.81 164.83,82.56 v2(165.1,82.83)
  BOTTOM w0.102: v2(162.37,95.74) 162.37,95.73 162.08,95.45 162.08,91.18 163.8,89.47 163.8,87.6 164.94,86.46 164.99,86.46 165.22,86.23 165.22,84.87 165.6,84.49 165.6,83.33 v2(165.1,82.83)
KSO17: length 24.5
  TOP w0.102: U31.82 165.06,82.16 v2(165.73,82.83) ; JKB1.26 159.2,95.63 v1(159.38,95.44) 159.65,95.18 v2(162.64,95.18)
  BOTTOM w0.102: v2(162.64,95.18) 162.36,94.9 162.36,91.23 165.45,88.14 165.45,84.96 165.89,84.53 165.89,82.99 v2(165.73,82.83)
LAN_PWR_ON#: length 168
  TOP w0.102: U31.89 159.08,79.36 v2(158.85,79.12) ; RL3.2 42.63,17.07 42.53,16.96 v2(42.35,16.96)
  IN1 w0.127: v2(130.72,53.77) 131.25,53.77 143.19,65.71 157.53,65.71 v2(158.92,67.1)
  BOTTOM w0.102: v2(158.85,79.12) 158.48,78.75 v1(158.48,71) 158.48,70.27 158.92,69.83 v2(158.92,67.1) ; v2(130.72,53.77) 123.92,46.97 123.92,26.4 119.12,21.6 93.71,21.6 89.61,25.7 51.09,25.7 v2(42.35,16.96)
LAN_RBIAS: length 5
  TOP w0.203: UL1.10 34.84,28.86 35.06,29.08 35.06,30.55 35.45,30.95 v1(35.45,31.28) 35.45,31.82 35.83,32.2 RL8.1
LAN_WAKE#: length 195.5
  TOP w0.102: RL7.1 43.16,26.01 v2(43.23,25.94) ; U31.29 177.55,87.76 v2(177.71,87.92) 177.78,87.99 R606.1
  IN2 w0.127: v2(156.25,58.52) 156.25,58.53 v2(177.21,58.53)
  BOTTOM w0.102: v2(177.21,58.53) 177.02,58.72 177.02,68.54 177.26,68.78 177.26,83.91 177.02,84.15 177.02,87.23 v2(177.71,87.92) ; v2(43.23,25.94) 45.66,25.94 48.37,28.65 91.89,28.65 95.85,24.69 116.71,24.69 120.72,28.7 120.72,47.82 131.42,58.52 v1(132,58.52) v2(156.25,58.52)
LAN_XTALI: length 12.2
  TOP w0.102: UL1.8 35.04,28.06 35.71,28.72 36.14,28.72 37.03,29.62 37.03,30.18 CL28.1 37.91,30.14 39.1,30.14 39.1,30.14 YL1.1 40.14,31.13 41.13,30.15 43.13,30.15 v1(43.13,31.16)
LAN_XTALO: length 8.9
  TOP w0.102: YL1.3 41.84,29.05 40.88,30.02 39.4,30.02 39.3,29.91 38,29.91 CL29.1 37.2,29.39 36.2,28.39 35.9,28.39 v1(35.82,28.31) 35.16,27.66 UL1.7
LF1_VGA: length 20.7
  TOP w0.102: v1(181.02,147.89) 181.14,147.77 v2(181.89,147.77)
  IN2 w0.254: v2(181.89,147.77) 180.94,148.72 166.76,148.72 v2(165.91,147.88)
  BOTTOM w0.254: v2(181.89,147.77) PR857.1 182.5,146.86 PR856.1 ; PL803.2 v2(165.91,147.88)
LF2_VGA: length 30.8
  IN1 w0.254: v2(181.26,143.04) 180.66,143.04 180.17,142.55 164.6,142.55 163.84,141.78 163.84,135.61 v2(163.94,135.51)
  BOTTOM w0.102: v2(181.26,143.04) 180.53,143.04 v1(180.47,143.09)
  BOTTOM w0.254: PR827.1 182.51,142.61 PR828.1 181.75,143.53 v2(181.26,143.04) ; PL802.2 v2(163.94,135.51)
LG1:
  vias: v1(28.09,121.84) v4(28.88,121.72) v4(29.58,121.71)
LG2: length 4.5
  TOP w1.016: 33.53,91.02 33.99,91.49 34.34,91.49 36.75,93.9 36.75,94.03
  vias: v1(32.62,90.5)
LG3: length 22.4
  TOP w0.102: v1(28.98,119.72) 28.87,119.83 v4(28.2,119.83)
  IN2 w1.016: 29.41,119.57 31.07,117.91 31.07,108.1 29.15,106.19 29.15,104.12 25.88,100.85
  vias: v4(25.03,101.79) v4(25.03,101.12) v4(27.55,119.83)
LG_1.35V:
  vias: v1(35.06,6.11) v4(34.15,6.15) v4(34.17,5.51)
LGATE1_VGA: length 10.9
  IN2 w1.016: 172.14,144.64 172.15,144.63 172.98,144.63 174.91,142.7 177.94,142.7 180.7,139.94 181.13,139.94
  vias: v1(170.84,144.54) v4(170.5,145.16) v4(171.17,145.15) v4(182.69,139.61) v4(183.33,139.61)
LGATE2_VGA: length 10.8
  TOP w0.102: v4(171.05,137.34) 171.05,137.7 171.17,137.82 v1(171.17,137.91)
  IN2 w1.016: 181.72,137.99 180.4,137.99 179.37,136.95 172.02,136.95 172.01,136.94
  vias: v4(171.06,136.7) v4(182.78,138.22) v4(183.42,138.23)
LID_SW#: length 172
  TOP w0.102: v2(178.24,47.25) JLED1.4 181.98,47.25 v1(182.34,46.89) ; v2(97.34,123.14) 98.1,123.89 JPWRB1.2 ; v2(169.7,76.32) 169.59,76.21 U31.115
  IN1 w0.127: v2(166.1,116.92) 163.65,114.48 157.54,114.48 156.89,113.83 151.42,113.83 150.79,114.45 138.54,114.45 138.11,114.88 130.68,114.88 129.44,113.64 117.94,113.64 116.7,114.88 112.15,114.88 111.44,115.58 102.56,115.58 100.35,113.37 98.42,113.37 97.31,114.48 97.31,123.11 v2(97.34,123.14)
  BOTTOM w0.102: v2(178.24,47.25) 177.88,47.6 177.88,53.3 177.81,53.37 174.68,56.5 170.04,56.5 169.28,57.26 169.28,60.45 167.79,61.94 167.79,71.59 169.37,73.17 169.37,75.99 v2(169.7,76.32) 169.81,76.43 R601.2 168.38,79.37 168.38,86.87 167.59,87.66 167.59,89.02 167.18,89.43 167.18,93.91 165.75,95.34 165.75,107.97 165.55,108.17 165.55,116.37 v2(166.1,116.92)
LPC_AD0: length 46.9
  TOP w0.089: v2(137.03,85.54) 136.69,85.87 135.47,85.87 135.31,86.03 U4.A20
  TOP w0.102: U31.10 175.58,80.16 175.31,79.88 174.72,79.88 173.94,80.67 173.94,82.3 174.25,82.61 174.25,83.16 v2(174.15,83.26)
  IN2 w0.127: v2(174.15,83.26) 173.65,83.75 163.99,83.75 162.92,84.82 144.75,84.82 143.64,83.72 140.79,83.72 140.31,84.2 137.9,84.2 137.03,85.07 v2(137.03,85.54)
LPC_AD1: length 50.8
  TOP w0.089: v2(135.75,86.24) 135.65,86.33 135.14,86.33 134.84,86.04 U4.C20
  TOP w0.102: v2(173.72,82.84) 173.53,82.65 173.53,80.59 174.76,79.36 U31.8
  IN2 w0.089: 136.76,84.01 136,84.01 135.59,84.41 135.59,86.08 v2(135.75,86.24)
  IN2 w0.127: 136.76,84.01 136.91,84.01 137.23,83.69 140.1,83.69 140.58,83.21 143.85,83.21 144.96,84.31 146.66,84.31 147.25,83.73 158.75,83.73 158.95,83.93 160.13,83.93 161.14,82.92 164.05,82.92 164.38,83.25 165.9,83.25 166.23,82.92 173.64,82.92 v2(173.72,82.84)
  BOTTOM w0.102: v2(173.72,82.84) 173.72,82.69 174.67,81.73 v1(174.67,81.72)
LPC_AD2: length 47.6
  TOP w0.089: U4.A18 135.36,86.9 136.37,86.9 v2(136.91,86.36)
  TOP w0.102: U31.7 174.6,78.96 173.13,80.43 173.13,84.08 v2(173.46,84.41)
  IN2 w0.127: v2(136.91,86.36) 137.32,85.95 137.94,85.95 138.38,86.39 140.7,86.39 141.97,85.13 165.69,85.13 166.25,84.57 173.31,84.57 v2(173.46,84.41)
LPC_AD3: length 55.6
  TOP w0.089: v2(133.63,86.58) 133.89,86.85 U4.C18
  TOP w0.102: U31.5 175.08,78.16 172.76,80.48 172.76,87.37 v2(172.04,88.08)
  IN2 w0.089: 136.76,88.93 136.73,88.9 135.38,88.9 135.14,88.66 135.14,88.09 v2(133.63,86.58)
  IN2 w0.127: 136.76,88.93 137.52,89.68 139.01,89.68 139.3,89.39 144.5,89.39 145.58,90.47 152.86,90.47 153.64,89.7 157.55,89.7 158.33,90.47 159.32,90.47 160.77,89.02 170.28,89.02 171.22,88.08 v2(172.04,88.08)
LPC_FRAME#: length 47.6
  TOP w0.089: U4.B21 134.92,85.55 136.41,85.55 v2(136.45,85.51)
  TOP w0.102: v2(172.03,83.33) 172.03,80.88 175.16,77.76 U31.4
  IN2 w0.089: v2(136.45,85.51) 136.45,85.3 136.76,84.98
  IN2 w0.127: 136.76,84.98 137.8,83.94 140.2,83.94 140.68,83.46 143.75,83.46 144.85,84.57 159.85,84.57 161.25,83.17 163.95,83.17 164.28,83.5 166,83.5 166.17,83.33 v2(172.03,83.33)
LVDS_A0: length 27.2
  TOP w0.102: UT2.25 87.5,133.61 87.71,133.82 90.45,133.82 90.61,133.66 90.61,132.77 90.89,132.48 91.49,132.48 91.78,132.77 91.78,134.33 91.93,134.49 92.45,134.49 v4(93.27,135.3) 95.73,137.77 95.73,140.3 95.48,140.56 94.17,140.56 94.04,140.69 94.04,140.94 94.17,141.07 95.48,141.07 95.73,141.32 95.73,141.85 95.48,142.11 95.04,142.11 94.92,142.23 94.92,142.49 95.04,142.62 95.48,142.62 95.73,142.87 95.73,143.57 96.59,144.42 96.59,145.41 96.19,145.82 96,145.82 JLVDS1.17
LVDS_A0#: length 27.2
  TOP w0.102: UT2.26 87,133.37 87.23,133.61 87.23,133.72 87.6,134.08 90.56,134.08 90.88,133.77 90.88,132.88 91,132.75 91.38,132.75 91.51,132.88 91.51,134.44 91.82,134.75 92.34,134.75 95.47,137.88 v4(95.47,139.25) 95.47,140.19 95.37,140.29 94.06,140.29 93.77,140.57 93.77,141.05 94.06,141.33 95.37,141.33 95.47,141.43 95.47,141.74 95.37,141.84 94.93,141.84 94.65,142.12 94.65,142.6 94.93,142.88 95.37,142.88 95.47,142.98 95.47,143.68 96.33,144.53 96.33,145.3 96.08,145.55 95.87,145.55 95.76,145.45 95.76,145.44 95.72,145.43 95.68,145.43 JLVDS1.18
LVDS_A1: length 27.5
  TOP w0.102: UT2.23 91.55,131.48 93.22,133.15 93.22,133.52 92.95,133.78 92.95,133.93 93.17,134.14 93.31,134.14 93.58,133.87 93.95,133.87 94.45,134.38 94.45,134.75 94.19,135.02 94.19,135.16 94.4,135.37 94.55,135.37 94.81,135.11 95.18,135.11 95.55,135.48 95.55,135.85 95.28,136.11 95.28,136.26 95.5,136.47 95.64,136.47 95.91,136.2 96.28,136.2 96.74,136.67 96.74,137.33 96.84,137.43 97.45,137.43 97.73,137.71 97.73,138.19 97.45,138.47 96.84,138.47 96.74,138.57 96.74,138.88 96.84,138.98 97.03,138.98 97.29,139.24 97.29,139.76 97.03,140.02 96.84,140.02 96.74,140.12 v4(96.74,141.08) 96.74,143.51 97.34,144.11 97.34,145.93 96.64,146.62 96.6,146.62 96.56,146.65 JLVDS1.15
LVDS_A1#: length 27.4
  TOP w0.102: UT2.24 88.88,131.98 88.96,131.91 88.96,131.81 89.02,131.75 89.22,131.75 89.31,131.84 89.48,131.84 89.57,131.75 89.76,131.75 89.86,131.85 90.01,131.85 90.11,131.75 90.31,131.75 90.41,131.84 90.57,131.84 90.67,131.75 90.84,131.75 90.93,131.84 91.11,131.84 91.21,131.75 91.44,131.75 92.96,133.26 92.96,133.4 92.69,133.67 92.69,134.04 93.06,134.41 93.42,134.41 93.69,134.14 93.84,134.14 94.19,134.49 94.19,134.64 93.92,134.9 93.92,135.27 94.29,135.64 94.66,135.64 94.92,135.37 95.07,135.37 95.29,135.59 95.29,135.73 95.02,136 95.02,136.37 95.39,136.74 95.75,136.74 96.02,136.47 96.17,136.47 96.48,136.78 96.48,137.44 96.73,137.7 97.34,137.7 97.46,137.82 97.46,138.08 97.34,138.2 96.73,138.2 96.48,138.46 96.48,138.99 96.73,139.25 96.92,139.25 97.03,139.35 97.03,139.65 96.92,139.75 96.73,139.75 96.48,140.01 v4(96.48,142.9) 96.48,143.62 97.08,144.22 97.08,145.81 96.49,146.4 96.4,146.4 96.31,146.31 96.17,146.31 96.15,146.33 JLVDS1.16
LVDS_A2: length 27.4
  TOP w0.102: UT2.21 91.63,130.48 98.61,137.46 v4(98.61,139.23) 98.61,140.67 98.35,140.93 97.88,140.93 97.75,141.06 97.75,141.31 97.88,141.44 98.35,141.44 98.61,141.7 98.61,142.22 98.35,142.48 97.97,142.48 97.84,142.61 97.84,142.86 97.97,142.99 98.35,142.99 98.61,143.25 98.61,146.39 97.39,147.61 96.9,147.61 JLVDS1.13
LVDS_A2#: length 27.4
  TOP w0.102: UT2.22 88.92,130.98 88.98,130.92 88.98,130.8 89.03,130.75 89.2,130.75 89.27,130.82 89.49,130.82 89.57,130.75 89.74,130.75 89.82,130.82 90.03,130.82 90.11,130.75 90.34,130.75 90.41,130.82 90.64,130.82 90.71,130.75 91.52,130.75 v4(95.34,134.57) 98.34,137.57 98.34,140.56 98.24,140.66 97.77,140.66 97.49,140.95 97.49,141.42 97.77,141.71 98.24,141.71 98.34,141.81 98.34,142.11 98.24,142.21 97.86,142.21 97.58,142.5 97.58,142.97 97.86,143.26 98.24,143.26 98.34,143.36 98.34,146.27 97.27,147.35 97.08,147.35 96.98,147.26 96.98,147.15 96.92,147.08 96.79,147.08 96.67,147.21 96.63,147.21 JLVDS1.14
LVDS_ACLK: length 27.6
  TOP w0.102: JLVDS1.10 97.82,148.82 98.13,148.82 98.68,148.26 98.68,147.43 99.51,146.61 v4(99.51,145.5) 99.51,137.28 91.7,129.48 UT2.19
LVDS_ACLK#: length 27.6
  TOP w0.102: UT2.20 88.75,129.98 88.83,129.9 88.83,129.82 88.9,129.75 89.05,129.75 89.15,129.85 89.31,129.85 89.42,129.75 89.57,129.75 89.68,129.85 89.87,129.85 89.98,129.75 90.14,129.75 90.25,129.85 90.4,129.85 90.5,129.75 91.59,129.75 99.24,137.39 v4(99.24,142.58) 99.24,146.5 98.42,147.32 98.42,148.15 98.01,148.55 97.88,148.55 97.81,148.48 97.81,148.39 97.74,148.33 97.66,148.33 JLVDS1.11
LX_0.95V:
  vias: v1(167,123.7) v4(168.64,127.23) v4(168.64,126.53) v4(168.59,125.9) v4(169.29,127.25) v4(169.29,126.55) v4(169.28,125.9) v4(169.98,127.26) v4(169.98,126.57)
LX_1.5V:
  vias: v1(200.06,9.69) v4(200.08,8.07) v4(200.07,7.39) v4(200.72,8.07) v4(200.76,7.39) v4(201.42,8.05) v4(201.43,7.37) v4(202.12,9.46) v4(202.1,8.78) v4(202.09,8.12) v4(202.07,7.39)
LX_1.05VSP: length 9.7
  IN2 w0.762: v4(108.81,38.56) 107.86,38.56 107.59,38.83 103.64,38.83 102.12,37.31 v4(102.12,35.09)
  vias: v1(109.67,45.12) v2(102.12,34.33) v4(108.93,40.72) v4(108.93,39.35) v4(108.96,40.04) v4(109.61,40.71) v4(109.63,40.04) v4(109.61,39.34) v4(109.59,38.65) v4(110.32,40.72) v4(110.35,40.04) v4(110.32,39.32) v4(110.3,38.65)
LX_1.35V:
  vias: v1(36.3,5.83) v4(40.12,10.49) v4(40.12,9.8) v4(40.82,10.47) v4(40.82,9.78) v4(41.48,10.46) v4(41.48,9.77) v4(42.17,10.47) v4(42.17,9.78) v4(42.87,10.47) v4(42.87,9.78) v4(43.53,10.47) v4(43.53,9.78) v4(44.22,10.46) v4(44.22,9.77) v4(44.88,10.45) v4(44.88,9.76) v4(44.9,9.07) v4(44.91,8.41) v4(45.55,8.4) v4(45.57,10.41) v4(45.59,9.75) v4(45.55,9.05)
LX_3V:
  vias: v1(71.36,3.91)
LX_5V: length 5.3
  TOP w0.508: v2(102.94,11.81) 100.35,11.81 99,10.46 PC421.2
  vias: v1(104.54,6.64) v4(105.43,6.21) v4(105.44,5.51) v4(106.14,6.19) v4(106.14,5.48)
LX_CHG: length 17.9
  IN1 w1.016: 183.95,165.72 183.95,164.59 183.41,164.04 179.74,164.04 177.55,161.86 174.84,161.86 173.22,160.24 173.22,157.88
  BOTTOM w0.102: v1(171.65,152.71) PR323.1
  vias: v4(170.67,155.33) v4(170.67,154.7) v4(170.7,154.04) v4(171.09,157.31) v4(171.09,156.68) v4(171.11,156.02) v4(171.75,157.31) v4(171.75,156.68) v4(171.78,156.02) v4(184.94,165.5) v4(185.34,166.02)
M_CLK_DDR0: length 53.3
  IN1 w0.089: v2(68.04,82.41) 68.04,82.88 68.56,83.41 68.95,83.41 69.65,82.7 69.65,82.03 69.4,81.77 68.82,81.77 68.64,81.59 68.64,79.85 68.51,79.72 68.11,79.72 68.02,79.63 68.02,79.5 68.11,79.41 68.51,79.41 68.75,79.18 68.75,78.84 68.51,78.6 68.27,78.6 68.16,78.49 68.16,78.34 68.48,78.02 68.62,78.02 69.62,79.01 69.98,79.01 70.26,78.73 70.26,78.38 69.56,77.68 69.56,77.57 69.62,77.51 69.62,77.18 69.59,77.15 69.59,77.14
  IN1 w0.127: 69.59,77.14 69.59,66.7 69.32,66.43 68.56,66.43 68.43,66.3 68.43,66 68.56,65.87 69.32,65.87 69.59,65.6 69.59,65 69.32,64.73 68.18,64.73 68.05,64.6 68.05,64.22 68.18,64.09 69.32,64.09 69.59,63.82 69.59,63.23 69.32,62.95 68.18,62.95 68.05,62.82 68.05,62.44 68.18,62.32 69.32,62.32 69.59,62.04 69.59,61.44 69.32,61.16 68.18,61.16 68.05,61.04 68.05,60.66 68.18,60.53 69.32,60.53 69.59,60.25 69.59,59.49 69.32,59.21 68.18,59.21 68.05,59.09 68.05,58.82 68.18,58.69 68.68,58.69 68.95,58.42 68.95,57.84 68.68,57.57 68.18,57.57 68.05,57.44 68.05,56.94 68.18,56.81 68.28,56.81 68.54,56.56 68.54,55.53 68.16,55.14 68.16,54.97 67.83,54.65 v2(67.83,54.65)
  BOTTOM w0.089: JCPU1.V4 68.51,82.88 v2(68.04,82.41)
  BOTTOM w0.102: JDIMM1.101 66.92,55.33 67.41,54.84 67.64,54.84 v2(67.83,54.65)
M_CLK_DDR1: length 52
  IN1 w0.089: 70.12,77.14 70.12,77.26 70.15,77.29 70.15,77.42 70.44,77.71 70.44,79.74 70.31,79.87 69.75,79.87 69.44,80.18 69.44,81 v2(69.04,81.4)
  IN1 w0.127: 70.12,77.14 70.12,58.8 69.49,58.17 69.49,56.51 69.07,56.09 69.07,53.93 68.94,53.8 68.34,53.8 68.06,53.53 68.06,53.06 68.34,52.79 68.92,52.79 69.05,52.66 69.05,52.28 68.92,52.16 68.08,52.16 67.8,51.88 67.8,51.29 68.08,51.01 69.11,51.01 69.24,50.89 69.24,50.5 69.11,50.38 67.46,50.38 67.19,50.1 67.19,49.51 67.46,49.23 70.38,49.23 70.51,49.11 70.51,48.77 70.38,48.64 68.13,48.64 67.72,48.23 67.72,47.11 67.95,46.88 68.26,46.88 v2(68.46,46.68)
  BOTTOM w0.089: v2(69.04,81.4) 68.51,81.93 JCPU1.V3
  BOTTOM w0.102: v2(68.46,46.68) 68.25,46.89 67.82,46.89 67.6,47.11 67.6,48.12 67.22,48.5 JDIMM1.102
M_CLK_DDR2: length 68.2
  IN2 w0.089: 66.71,77.14 66.71,77.86 65.4,79.17 65.4,81.65 65.78,82.03 66.34,82.03 66.48,82.16 66.48,82.64 66.37,82.75 66.16,82.75 66.04,82.62 v2(66.04,82.44)
  IN2 w0.127: 66.71,77.14 66.71,70.47 67.09,70.09 68.54,70.09 68.66,69.96 68.66,69.53 68.54,69.41 66.85,69.41 66.57,69.13 66.57,68.54 66.85,68.26 69.66,68.26 69.78,68.14 69.78,67.75 69.66,67.63 66.85,67.63 66.57,67.35 66.57,66.76 66.85,66.48 69.66,66.48 69.78,66.36 69.78,65.98 69.66,65.85 66.85,65.85 66.57,65.57 66.57,64.98 66.85,64.71 69.66,64.71 69.78,64.58 69.78,59.05 68.38,57.65 66.97,57.65 66.36,57.04 66.36,44.76 66.82,44.31 66.82,42.31 66.72,42.2 66.51,42.2 v2(66.28,42.43)
  BOTTOM w0.089: JCPU1.AA4 65.53,82.94 v2(66.04,82.44)
  BOTTOM w0.102: JDIMM2.101 66.92,43.6 67.11,43.4 67.11,42.29 66.86,42.04 66.47,42.04 66.28,42.22 v2(66.28,42.43)
M_CLK_DDR3: length 66.9
  IN2 w0.089: v2(66.04,81.41) 66.44,81.01 66.44,78.93 67.03,78.34
  IN2 w0.127: v2(67.92,33.32) 67.67,33.56 67.19,33.56 66.89,33.87 66.89,35.7 67.17,35.98 68.27,35.98 68.4,36.11 68.4,36.53 68.27,36.66 66.35,36.66 66.07,36.94 66.07,37.5 66.35,37.77 67.85,37.77 67.98,37.9 67.98,38.28 67.85,38.41 66.33,38.41 66.06,38.68 66.06,39.28 66.33,39.55 67.55,39.55 67.68,39.68 67.68,40.08 67.55,40.21 66.98,40.21 66.7,40.49 66.7,41.08 66.98,41.35 67.56,41.35 67.68,41.48 67.68,47.81 67.15,48.34 67.15,56.48 67.53,56.86 68.71,56.86 70.57,58.72 70.57,69.17 67.62,72.12 67.62,77.74 67.03,78.34
  BOTTOM w0.089: JCPU1.AA3 65.51,81.94 v2(66.04,81.41)
  BOTTOM w0.102: v2(67.92,33.32) 67.61,33.63 67.46,33.63 67.22,33.87 67.22,35.03 67.36,35.17 67.36,35.37 67.22,35.51 JDIMM2.102
M_CLK_DDR#0: length 53.2
  IN1 w0.089: v2(69.04,82.41) 69.04,82.31 68.92,82.19 68.53,82.19 68.45,82.27 68.45,82.52 68.26,82.71 68.26,82.79 68.65,83.19 68.86,83.19 69.44,82.61 69.44,82.12 69.31,81.99 68.73,81.99 68.42,81.68 68.42,79.94 68.02,79.94 67.8,79.72 67.8,79.41 68.02,79.2 68.42,79.2 68.54,79.09 68.54,78.93 68.42,78.81 68.18,78.81 67.94,78.58 67.94,78.25 68.39,77.81 68.71,77.81 69.71,78.8 69.89,78.8 70.04,78.64 70.04,78.46 69.34,77.77 69.34,77.48 69.4,77.42 69.4,77.27 69.34,77.2 69.34,77.14
  IN1 w0.127: v2(67.83,55.41) 68.06,55.41 68.28,55.63 68.28,56.46 68.18,56.56 68.08,56.56 67.8,56.84 67.8,57.55 68.08,57.82 68.57,57.82 68.7,57.95 68.7,58.31 68.57,58.44 68.08,58.44 67.8,58.72 67.8,59.19 68.08,59.47 69.21,59.47 69.34,59.6 69.34,60.15 69.21,60.28 68.08,60.28 67.8,60.55 67.8,61.14 68.08,61.42 69.21,61.42 69.34,61.55 69.34,61.93 69.21,62.06 68.08,62.06 67.8,62.34 67.8,62.93 68.08,63.2 69.21,63.2 69.34,63.33 69.34,63.71 69.21,63.84 68.08,63.84 67.8,64.11 67.8,64.71 68.08,64.98 69.21,64.98 69.34,65.11 69.34,65.49 69.21,65.62 68.46,65.62 68.18,65.89 68.18,66.4 68.46,66.68 69.21,66.68 69.34,66.81 69.34,77.14
  BOTTOM w0.089: JCPU1.U4 69.51,82.88 v2(69.04,82.41)
  BOTTOM w0.102: v2(67.83,55.41) 67.93,55.31 67.93,55.17 67.82,55.06 67.5,55.06 67.13,55.42 67.13,55.77 67.22,55.86 67.22,56.15 67.13,56.23 67.13,56.43 67.23,56.53 67.44,56.53 67.51,56.6 JDIMM1.103
M_CLK_DDR#1: length 52
  IN1 w0.089: 70.38,77.14 70.38,77.15 70.37,77.16 70.37,77.33 70.66,77.62 70.66,79.83 70.4,80.08 69.84,80.08 69.66,80.27 69.66,81.09 69.64,81.11 69.64,81.7 69.76,81.82 69.91,81.82 70.04,81.7 v2(70.04,81.4)
  IN1 w0.127: v2(68.46,47.32) 68.27,47.13 68.05,47.13 67.97,47.21 67.97,48.13 68.23,48.39 70.49,48.39 70.76,48.66 70.76,49.21 70.49,49.49 67.57,49.49 67.44,49.62 67.44,50 67.57,50.12 69.22,50.12 69.49,50.4 69.49,50.99 69.22,51.27 68.18,51.27 68.05,51.39 68.05,51.77 68.18,51.9 69.03,51.9 69.3,52.18 69.3,52.77 69.03,53.04 68.44,53.04 68.32,53.17 68.32,53.42 68.44,53.55 69.05,53.55 69.32,53.82 69.32,55.99 69.74,56.4 69.74,58.06 70.38,58.7 70.38,77.14
  BOTTOM w0.089: v2(70.04,81.4) 69.51,81.93 JCPU1.U3
  BOTTOM w0.102: v2(68.46,47.32) 68.24,47.1 67.91,47.1 67.81,47.2 JDIMM1.104
M_CLK_DDR#2: length 68.1
  IN2 w0.089: v2(67.04,82.41) 66.81,82.41 66.69,82.29 66.69,82.07 66.43,81.81 65.87,81.81 65.62,81.56 65.62,79.26 66.96,77.91 66.96,77.14
  IN2 w0.127: v2(66.28,41.67) 66.56,41.95 66.82,41.95 67.08,42.2 67.08,44.41 66.62,44.87 66.62,56.93 67.08,57.39 68.49,57.39 70.04,58.94 70.04,64.68 69.76,64.96 66.95,64.96 66.82,65.09 66.82,65.47 66.95,65.6 69.76,65.6 70.04,65.87 70.04,66.46 69.76,66.74 66.95,66.74 66.82,66.87 66.82,67.25 66.95,67.37 69.76,67.37 70.04,67.65 70.04,68.24 69.76,68.52 66.95,68.52 66.82,68.64 66.82,69.02 66.95,69.15 68.64,69.15 68.92,69.43 68.92,70.07 68.64,70.34 67.19,70.34 66.96,70.57 66.96,77.14
  BOTTOM w0.089: JCPU1.Y4 66.51,82.94 v2(67.04,82.41)
  BOTTOM w0.102: JDIMM2.103 67.51,43.43 67.33,43.24 67.33,42.2 66.95,41.82 66.44,41.82 v2(66.28,41.67)
M_CLK_DDR#3: length 66.9
  IN2 w0.089: 67.21,78.52 67.21,78.52 66.65,79.07 66.65,81.1 66.51,81.25 66.51,81.51 66.63,81.63 66.92,81.63 67.04,81.51 v2(67.04,81.38)
  IN2 w0.127: v2(67.92,34.08) 67.65,33.82 67.29,33.82 67.14,33.97 67.14,35.59 67.27,35.72 68.38,35.72 68.65,36 68.65,36.64 68.38,36.91 66.45,36.91 66.33,37.04 66.33,37.39 66.45,37.52 67.95,37.52 68.23,37.8 68.23,38.39 67.95,38.66 66.44,38.66 66.31,38.79 66.31,39.17 66.44,39.3 67.66,39.3 67.93,39.57 67.93,40.19 67.66,40.47 67.08,40.47 66.96,40.59 66.96,40.97 67.08,41.1 67.66,41.1 67.94,41.38 67.94,47.91 67.41,48.44 67.41,56.38 67.63,56.6 68.81,56.6 70.83,58.62 70.83,69.27 67.88,72.22 67.88,77.85 67.21,78.52
  BOTTOM w0.089: v2(67.04,81.38) 66.51,81.91 JCPU1.Y3
  BOTTOM w0.102: v2(67.92,34.08) 67.68,33.85 67.55,33.85 67.43,33.96 67.43,34.94 67.57,35.08 67.57,35.27 67.81,35.51 JDIMM2.104
M_ODT0: length 57.7
  IN1 w0.089: v2(75.04,86.38) 75.04,86.95 74.92,87.07 74.74,87.07 74.62,86.95 74.62,85.19 74.81,85 75.28,85 75.64,84.64 75.64,79.3 76.72,78.22 76.72,77.14
  IN1 w0.208: v2(72.59,47.26) 72.59,47.26 73.24,47.26 73.37,47.38 73.37,48.8 73.24,48.93 72.37,48.93 72.25,49.05 72.25,49.73 72.37,49.86 74.62,49.86 74.75,49.73 74.75,48.97 74.88,48.84 75.48,48.84 75.61,48.97 75.61,56.13 75.92,56.44 75.92,60.69 81.43,66.2 81.43,67.27 82.22,68.06 82.22,70.71 81.63,71.31 80.64,71.31 80.51,71.43 80.51,72.58 76.72,76.37 76.72,77.14
  BOTTOM w0.089: v2(75.04,86.38) 74.51,86.91 JCPU1.M8
  BOTTOM w0.165: JDIMM1.116 71.42,48.43 v2(72.59,47.26)
M_ODT1: length 56.6
  IN1 w0.089: v2(76.04,86.38) 76.64,85.78 76.64,79.3 77.94,78 77.94,77.21 77.95,77.2 77.95,77.14
  IN1 w0.208: v2(74.59,46.82) 75.85,46.82 75.97,46.69 75.97,44.46 76.1,44.33 76.71,44.33 76.84,44.46 76.84,55.63 77.16,55.94 77.16,60.19 83.45,66.49 83.45,71.37 77.95,76.88 77.95,77.14
  BOTTOM w0.089: JCPU1.L7 75.6,85.94 v2(76.04,86.38)
  BOTTOM w0.165: JDIMM1.120 72.62,48.53 74.32,46.82 v2(74.59,46.82)
M_ODT2: length 70.1
  IN2 w0.089: v2(72.04,82.41) 71.56,82.41 71.43,82.28 71.43,81.89 71.32,81.79 71.17,81.79 71.06,81.89 71.06,82.42 70.93,82.55 70.75,82.55 70.62,82.42 70.62,79.19 72.16,77.65
  IN2 w0.208: v2(71.98,39.38) 71.48,38.89 71.48,34.67 71.61,34.54 72.61,34.54 72.74,34.67 72.74,40.8 73.22,41.28 73.22,44 75.06,45.85 75.06,48.08 74.83,48.31 74.41,48.31 74.29,48.44 74.29,49 74.41,49.12 74.94,49.12 75.06,49.25 75.06,49.83 74.94,49.96 74.5,49.96 74.29,50.17 74.29,55.61 77.16,58.48 77.16,59.95 77.43,60.21 78.89,60.21 79.54,60.86 79.54,69.5 72.16,76.87 72.16,77.65
  BOTTOM w0.089: JCPU1.R4 71.51,82.94 v2(72.04,82.41)
  BOTTOM w0.165: v2(71.98,39.38) 71.42,38.82 JDIMM2.116
M_ODT3: length 67.3
  IN2 w0.089: v2(72.04,81.41) 72.04,80.5 74.01,78.54 74.01,77.64 74.51,77.14
  IN2 w0.208: 74.51,77.14 76.86,74.79 78.07,74.79 83.15,69.71 83.15,62.65 81.7,61.21 81.7,60.41 76.92,55.63 76.92,45.09 75.72,43.9 75.72,37.49 75.51,37.29 75.09,37.29 74.96,37.16 74.96,36.67 75.09,36.54 75.6,36.54 75.72,36.41 75.72,35.86 75.6,35.74 75.25,35.74 75.13,35.61 75.13,32.69 75,32.56 74.58,32.56 74.45,32.69 74.45,33.19 74.32,33.32 73.92,33.32 73.79,33.19 73.79,32.69 73.66,32.56 73.24,32.56 73.11,32.69 73.11,33.19 72.99,33.32 v2(72.66,33.32)
  BOTTOM w0.089: JCPU1.R3 71.51,81.94 v2(72.04,81.41)
  BOTTOM w0.165: JDIMM2.120 72.62,35.17 72.12,34.67 72.12,33.86 v2(72.66,33.32)
MAA0: length 47.4
  TOP w0.102: UV5.N3 111.45,135.65 111.58,135.77 111.58,135.94 111.45,136.07 110.57,136.07 110.44,136.19 110.44,136.61 110.31,136.73 v2(110.16,136.73) ; v2(109.05,147.63) 107.98,148.7 UV7.N3 ; v2(125.74,138.35) 125.78,138.35 125.9,138.47 125.9,138.76 125.78,138.89 125.14,138.89 124.8,139.23 124.8,139.85 124.66,139.99 124.52,139.99 124.29,139.76 121.74,139.76 121.64,139.65 121.64,139.28 121.54,139.18 121.34,139.18 121.24,139.28 121.24,139.65 121.13,139.76 120.81,139.76
  TOP w0.203: v2(112.99,141.35) 113.08,141.44 113.9,141.44 114.03,141.31 114.03,141 113.71,140.68 113.71,140.5 114.05,140.16 114.23,140.16 114.72,140.65 116.91,140.65 117.1,140.47 117.31,140.47 118.23,139.55 118.23,139 118.43,138.8 118.84,138.8 119.04,139 119.04,139.75 119.17,139.88 119.64,139.88 119.77,139.75 v1(119.77,139.44) 119.77,139.05 119.9,138.92 120.45,138.92 120.58,139.05 120.58,139.63 120.71,139.76 120.81,139.76
  IN1 w0.127: v2(110.16,136.73) 110.47,136.73 110.57,136.84 110.57,137.51 111.11,138.05 111.11,138.23 110.87,138.48 110.87,138.64 111.12,138.9 111.26,138.9 111.38,138.78 111.56,138.78 111.74,138.96 111.74,139.14 111.62,139.25 111.62,139.43 112.33,140.14 112.33,140.68 112.99,141.34 v2(112.99,141.35) 113.25,141.61 113.25,143.17 112.92,143.5 112.92,143.74 110.89,145.77 110.89,145.92 110.15,146.65 110.15,146.99 109.92,147.22 109.63,147.22 109.21,147.63 v2(109.05,147.63)
  BOTTOM w0.102: v2(125.74,138.35) 125.65,138.26 UV1.G24 ; UV6.N3 107.75,135.65 107.63,135.77 107.63,135.95 107.75,136.07 108.77,136.07 109.04,136.34 110.47,136.34 110.6,136.47 110.6,136.62 110.49,136.73 v2(110.16,136.73) ; UV8.N3 110.61,148.72 109.91,148.02 109.52,148.02 109.14,147.63 v2(109.05,147.63)
MAA1: length 47.3
  TOP w0.102: v2(109.45,136.75) 109.26,136.94 109.05,136.94 108.77,136.66 108.12,136.66 108.03,136.57 UV5.P7 ; v2(109.78,147.62) 109.87,147.72 110.65,147.72 110.85,147.92 UV7.P7
  IN1 w0.127: v2(109.78,147.62) 109.62,147.62 109.2,148.04 108.9,148.04 108.2,147.34 108.2,145.48 106.43,143.71 v2(106.43,143.15) 106.43,139.76 v2(109.45,136.75)
  IN2 w0.102: v2(126.88,138.35) 126.46,138.77 126.3,138.77 126.2,138.87 125.12,138.87 124.76,139.23 124.76,140.04 124.21,140.59 121.14,140.59 120.87,140.32 120.81,140.32
  IN2 w0.249: 120.81,140.32 118.04,140.32 117.12,139.4 112.74,139.4 111.21,140.93 111.21,140.99 110.94,141.26 110.4,141.26 110.18,141.48 109.24,141.48 109.14,141.58 107.91,141.58 107.5,142 107.06,142 106.43,142.62 v2(106.43,143.15)
  BOTTOM w0.102: UV8.P7 108.67,147.23 109.2,147.23 109.6,147.62 v2(109.78,147.62) ; UV6.P7 111.08,136.45 110.39,137.14 110.01,137.14 109.61,136.75 v2(109.45,136.75) ; v2(126.88,138.35) 127.25,138.72 UV1.J23
MAA2: length 45.5
  TOP w0.102: UV5.P3 111.23,136.43 111.1,136.31 110.79,136.31 110.66,136.43 110.66,136.99 110.54,137.12 109.96,137.12 109.86,137.22 109.86,137.41 109.99,137.53 v2(110.08,137.53) ; 120.81,136.71 120.91,136.71 121,136.8 121,137.67 121.24,137.91 122.3,137.91 122.42,137.78 122.42,137.37 122.17,137.12 122.17,136.7 122.3,136.57 122.8,136.57 122.93,136.7 122.93,137.23 123.06,137.36 123.85,137.36 124.02,137.54 124.02,138.02 124.15,138.15 124.49,138.15 124.86,137.77 124.86,137.47 124.98,137.35 126.65,137.35 126.78,137.23 v2(126.78,137.02) ; UV7.P3 108.06,148 108.4,148 108.57,147.83 108.57,147.1 108.83,146.83 v2(109.13,146.83)
  TOP w0.203: v2(112.42,141.51) 112.42,141.27 114.27,139.42 115.67,139.42 117.64,137.45 118.23,137.45 118.36,137.33 118.36,136.94 118.5,136.8 119.17,136.8 119.31,136.94 119.31,137.36 119.41,137.45 120,137.45 120.12,137.33 120.12,136.84 120.25,136.71 120.81,136.71
  IN1 w0.127: v2(109.13,146.83) 109.54,146.42 110.07,146.42 110.66,145.82 110.66,145.54 112.59,143.6 112.59,143.36 112.72,143.24 112.72,141.82 v2(112.42,141.51) 112.42,141.31 112,140.89 112,140.14 111.33,139.47 111.33,139.43 110.55,138.65 110.55,137.82 110.27,137.53 v2(110.08,137.53)
  BOTTOM w0.102: UV6.P3 108.04,136.45 108.21,136.28 108.68,136.28 109.05,136.64 109.05,136.97 109.23,137.15 109.7,137.15 v2(110.08,137.53) ; v2(109.13,146.83) 109.51,147.22 109.99,147.22 110.69,147.92 UV8.P3 ; v2(126.78,137.02) 126.78,137.35 UV1.H24
MAA3: length 50.3
  TOP w0.102: v2(109.45,138.35) 109.82,138.72 110.31,138.72 110.64,138.39 110.64,137.3 111.12,136.83 111.4,136.83 111.64,136.59 111.64,136.23 112.03,135.84 UV5.N2 ; UV7.N2 107.55,148.35 107.55,147.79 107.79,147.55 108.07,147.55 108.35,147.27 108.35,147.03 109.05,146.33 v2(109.05,146.03)
  IN1 w0.127: v2(109.45,138.35) 109.14,138.35 107.45,140.04 v2(107.45,141.28) 107.45,144.08 108.66,145.29 108.66,145.64 v2(109.05,146.03)
  IN2 w0.102: v2(127.54,138.29) 127.14,137.89 125.66,137.89 124.62,138.92 121.98,138.92 121.12,139.78 120.94,139.78 120.9,139.83 120.81,139.83
  IN2 w0.249: 120.81,139.83 118.19,139.83 117.31,138.95 112.51,138.95 111.11,140.34 110.54,140.34 110.46,140.42 107.34,140.42 107.21,140.55 107.21,141.16 107.34,141.28 v2(107.45,141.28)
  BOTTOM w0.102: UV6.N2 107.23,135.88 107.64,136.29 107.64,136.64 107.87,136.87 108.58,136.87 109.02,137.3 109.02,137.92 v2(109.45,138.35) ; v2(109.05,146.03) 109.2,146.03 109.58,146.42 109.89,146.42 110.97,147.5 111.34,147.5 111.57,147.73 111.57,148.31 UV8.N2 ; v2(127.54,138.29) 127.25,138 UV1.J24
MAA4: length 48.1
  TOP w0.102: v2(109.45,137.55) 109.37,137.55 108.69,136.87 107.8,136.87 107.38,136.45 UV5.P8 ; 120.81,135.76 122.58,135.76 123.41,136.59 124,136.59 124.09,136.51 124.62,136.51 124.81,136.32 125.52,136.32 v2(126.09,136.89) ; v2(109.76,146.82) 109.91,146.82 110.61,147.52 111.58,147.52 UV7.P8
  TOP w0.203: v2(107,142.75) 107,142.61 107.68,141.93 109.09,141.93 109.19,141.83 110.42,141.83 110.64,141.61 111.51,141.61 v1(112.83,140.29) 114.05,139.08 115.53,139.08 118.84,135.76 120.81,135.76
  IN1 w0.127: v2(109.76,146.82) 109.7,146.82 109.29,147.23 108.96,147.23 108.43,146.69 108.43,145.38 107.14,144.09 107.14,143.24 107,143.1 v2(107,142.75) 107,139.99 v2(109.45,137.55)
  BOTTOM w0.102: v2(109.76,146.82) 109.67,146.82 109.29,146.44 108.96,146.44 108.66,146.75 108.66,146.96 108.1,147.52 107.58,147.52 UV8.P8 ; UV1.H26 126.45,136.53 v2(126.09,136.89) ; v2(109.45,137.55) 109.54,137.55 109.92,137.93 110.23,137.93 110.47,137.69 110.47,137.41 111.04,136.85 111.63,136.85 UV6.P8
MAA5: length 49.9
  TOP w0.102: v2(109.05,144.36) 107.58,145.82 107.58,147.31 107.18,147.71 UV7.P2 ; v2(109.97,139.91) 110.21,139.91 111.55,138.57 111.55,138.24 111.6,138.18 111.6,137 112.03,136.58 UV5.P2 ; v2(126.87,136.04) 126.87,135.38 126.68,135.19 125.39,135.19 125.07,134.87 121.2,134.87 120.81,135.26
  TOP w0.203: v2(108.31,141.12) 108.31,141.26 108.58,141.53 v1(108.82,141.53) 110.09,141.53 110.36,141.26 111.31,141.26 113.83,138.73 115.37,138.73 118.84,135.27 120.81,135.27 120.81,135.26
  IN1 w0.127: 108.29,141.12 108.29,140.47 109.2,139.56 109.62,139.56 v2(109.97,139.91) ; 108.29,141.12 v2(108.31,141.12) ; 108.29,141.12 108.3,141.13 108.3,142.58 107.94,142.94 107.94,143.93 108.37,144.36 v2(109.05,144.36)
  BOTTOM w0.102: UV8.P2 111.98,147.71 111.58,147.3 111.58,146.96 111.3,146.69 110.95,146.69 110.56,146.3 110.56,145.46 109.92,144.83 109.6,144.83 109.13,144.36 v2(109.05,144.36) ; v2(126.87,136.04) 127.25,136.42 UV1.J26 ; v2(109.97,139.91) 109.97,139.91 109.97,139.88 109.63,139.54 109.31,139.54 109.05,139.29 109.05,138.97 108.61,138.53 108.61,138.06 108.17,137.63 107.84,137.63 107.63,137.42 107.63,137.04 107.45,136.85 106.99,136.85 106.89,136.75 106.89,136.51 106.95,136.45 UV6.P2
MAA6: length 48.8
  TOP w0.102: v2(109.45,139.15) 109.45,138.92 108.2,137.67 106.93,137.67 106.79,137.53 106.79,137.37 106.92,137.25 UV5.R8 ; v2(109.76,145.21) 109.76,145.49 109.89,145.62 110.71,145.62 110.81,145.72 110.81,146.53 110.98,146.7 112.25,146.7 112.38,146.82 112.38,147 112.25,147.12 UV7.R8
  IN1 w0.127: v2(109.45,139.15) 109.45,138.93 109.28,138.76 109.09,138.76 107.87,139.98 107.87,142.38 v2(107.88,142.39) 107.88,142.63 107.68,142.83 107.68,143.98 108.46,144.76 109.8,144.76 109.93,144.89 109.93,145.08 109.8,145.21 v2(109.76,145.21)
  IN2 w0.102: 120.81,140.77 120.91,140.77 120.99,140.85 124.23,140.85 124.96,140.12 124.96,139.32 125.2,139.07 126.16,139.07 v2(126.53,139.45)
  IN2 w0.249: 120.81,140.77 117.03,140.77 116.67,140.41 115.5,140.41 115.45,140.36 114.71,140.36 114.71,140.36 112.4,140.36 111.15,141.61 110.66,141.61 110.28,142 108.27,142 v2(107.88,142.39)
  BOTTOM w0.102: v2(126.53,139.45) 126.45,139.53 UV1.H21 ; UV6.R8 112.03,137.53 111.88,137.67 111.07,137.67 110.85,137.89 110.85,138.56 110.55,138.86 110.55,139.29 110.32,139.52 110,139.52 109.63,139.15 v2(109.45,139.15) ; UV8.R8 107.57,146.73 108.11,146.73 108.38,146.47 108.38,145.27 108.89,144.76 109.23,144.76 109.67,145.21 v2(109.76,145.21)
MAA7: length 53.1
  TOP w0.102: v2(110.75,140.8) 111.35,140.8 112.18,139.98 112.18,139.25 112.3,139.12 112.94,139.12 113.06,139 113.06,138.83 112.94,138.71 112.3,138.71 112.18,138.59 112.18,138.44 112.44,138.17 112.44,136.97 112.32,136.85 112.15,136.85 112.03,136.97 UV5.R2 ; v2(110.64,143.35) 110.62,143.34 109.74,143.34 109.37,142.97 108.49,142.97 108.05,143.42 v1(108.05,143.86) 108.05,144.5 106.79,145.76 106.79,146.73 UV7.R2
  IN1 w0.127: v2(110.64,143.35) 110.64,142.81 110.76,142.68 111.27,142.68 111.4,142.55 111.4,142.22 111.27,142.1 v2(110.89,142.1) 110.74,141.95 110.74,140.81 v2(110.75,140.8)
  IN2 w0.102: 120.81,141.22 121.17,141.22 121.28,141.34 121.28,141.47 121.4,141.59 121.57,141.59 121.69,141.47 121.69,141.17 121.81,141.05 121.98,141.05 122.1,141.17 122.1,141.68 122.21,141.8 122.38,141.8 122.5,141.68 122.5,141.25 122.63,141.12 124.25,141.12 124.47,140.9 124.61,140.9 124.83,141.12 125,141.12 125.12,141 125.12,140.84 124.9,140.62 124.9,140.47 125.31,140.06 125.31,140.05 125.47,139.89 127.17,139.89 127.29,140.01 127.29,140.17 127.17,140.29 126.29,140.29 126.17,140.42 v2(126.17,140.72)
  IN2 w0.249: 120.81,141.22 116.76,141.22 116.4,140.86 115.32,140.86 115.26,140.81 114.89,140.81 114.89,140.81 112.59,140.81 112.43,140.96 112.29,140.96 111.91,141.35 111.91,141.52 111.33,142.1 v2(110.89,142.1)
  BOTTOM w0.102: v2(110.75,140.8) 110.92,140.8 111.04,140.68 111.04,140.47 110.92,140.34 109.21,140.34 107.64,138.77 107.64,137.83 107.47,137.67 106.88,137.67 106.8,137.59 106.8,137.36 106.92,137.25 UV6.R2 ; UV1.G21 125.96,140.07 126.17,140.28 v2(126.17,140.72) ; UV8.R2 112.35,146.75 112.35,146.01 111.18,144.85 111.18,143.9 v2(110.64,143.35)
