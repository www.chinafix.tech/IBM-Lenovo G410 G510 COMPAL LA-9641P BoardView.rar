# Allegro board IBM-Lenovo G410 G510 COMPAL LA-9641P BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PM_DRAM_PWRGD: length 97.7
  TOP w0.089: v2(137.41,95.07) 136.85,95.63 133.35,95.63 132.35,94.62 132.18,94.62 131.77,94.22 131.77,94.03 132.01,93.79 132.01,93.43 132.09,93.35 U4.H3
  TOP w0.102: R29.2 88.86,90.72 R133.1 90.16,91.59 90.26,91.5 U1.2 94.07,91.5 v2(94.51,91.93)
  IN1 w0.127: v2(142.37,109.41) 142.3,109.48 130.77,109.48 130.07,108.78 112.86,108.78 v2(112.63,109.01)
  BOTTOM w0.102: v2(94.51,91.93) 94.51,92.19 93.28,93.42 93.28,96.96 v1(92.95,97.29) 92.95,98.89 95.13,101.08 95.13,103.92 100.22,109.01 v2(112.63,109.01) ; v2(142.37,109.41) 143.33,108.45 143.33,96.96 141.96,95.59 141.96,95.43 141.37,94.84 139.07,94.84 138.59,94.36 137.61,94.36 137.41,94.56 v2(137.41,95.07)
PM_SLP_S3#: length 62.3
  TOP w0.089: U4.H1 132.1,94.13 133.43,95.45 136.78,95.45 137.04,95.19 137.04,94.93 137.38,94.59 137.79,94.59 137.96,94.76
  TOP w0.102: U31.6 v2(178.1,78.56) ; 137.96,94.76 v2(137.98,94.78)
  IN1 w0.127: v2(137.98,94.78) 138.51,94.78 139.54,93.75 144.66,93.75 147.28,91.13 159.29,91.13 160.54,89.89 v2(177.75,89.89)
  BOTTOM w0.102: v2(177.75,89.89) 178.48,89.15 v1(178.48,87.47) 178.48,86.83 178.29,86.64 178.29,78.75 v2(178.1,78.56)
PM_SLP_S4#: length 54.3
  TOP w0.089: U4.C6 134.8,91.76 135.02,91.98 135.76,91.98 136.28,92.5 136.28,93.52 136.67,93.91 v2(136.96,93.91)
  TOP w0.102: v2(173.83,76.35) 174.39,75.79 U31.127
  IN1 w0.127: v2(136.96,93.91) 137.32,93.91 139.06,92.17 145,92.17 147.5,89.67 151.7,89.67 151.94,89.43 157.12,89.43 157.72,88.83 166.02,88.83 169.06,85.8 v2(170.66,85.8)
  BOTTOM w0.102: v2(173.83,76.35) 172.44,77.75 172.44,77.98 v1(172.1,78.31) 171.1,79.31 170.97,79.31 169.96,80.32 169.96,85.1 v2(170.66,85.8)
PM_SLP_S5#: length 90.7
  TOP w0.102: v2(175.18,80.97) 175.18,81.4 175.53,81.76 U31.14 ; v2(127.78,91.95) 127.42,91.6 U4.Y7
  IN1 w0.089: v2(127.78,91.95) 128.12,92.29 128.12,92.55 130.35,94.79
  IN1 w0.127: v2(170.61,109.97) 169.93,109.29 165.59,109.29 165.15,109.74 165.15,110.4 164.69,110.86 153.64,110.86 149.67,106.88 136.1,106.88 131.22,102 131.22,95.66 130.35,94.79
  BOTTOM w0.102: v2(175.18,80.97) 175.18,82.22 174.58,82.81 174.58,83.95 174.29,84.24 174.29,85.25 173.83,85.71 173.83,87.55 174.85,88.57 174.85,90.47 175.48,91.1 175.48,95.28 175.71,95.51 175.71,99.34 v1(174.58,100.47) 173.12,101.93 173.12,107.24 170.61,109.75 v2(170.61,109.97)
PM_SYS_PWRGD_BUF: length 30.1
  TOP w0.102: U1.4 90.09,92.15 R133.2 88.82,91.6 R36.1 88.8,91.58 R30.2 87.9,90.7 R35.1 87.06,90.69 86.28,89.9 v1(80.61,89.9) 78.43,89.9 v2(78.02,90.31)
  IN1 w0.089: v2(78.02,90.31) 64.92,90.31 v2(64.03,89.42)
  BOTTOM w0.089: v2(64.03,89.42) 63.54,88.94 63.52,88.94 JCPU1.AC10
PROCHOT: length 56.6
  TOP w0.102: v2(162.64,61.94) 162.63,61.95 v1(162.63,64.44) Q37.2 162.63,71.09 162.12,71.59 162.12,72.58 162.3,72.76 164.21,72.76 164.79,73.34 U31.103
  TOP w0.254: v2(180.81,61.43) 180.81,61.43 PR216.1 ; v2(183.62,76.74) 183.05,77.31 183.05,79.77 PR233.1
  IN1 w0.127: v2(183.62,76.74) 183.62,76.46 182.76,75.6 182.76,74.07 179.04,70.35 179.04,63.2 v2(180.81,61.43)
  IN2 w0.127: v2(180.81,61.43) 180.53,61.15 163.43,61.15 v2(162.64,61.94)
PS_0: length 3.6
  BOTTOM w0.254: v2(146.67,126.75) 146.59,126.75 146.24,127.1 146.24,127.72 146.16,127.8 146.16,128.03 146.24,128.1 146.24,128.42 146.18,128.47 146.18,128.79 146.27,128.88 146.27,129.65 UV1.AM34
  vias: v1(145.97,126.5)
PS_1: length 9.8
  TOP w0.102: v2(140.44,131.87) v1(140.44,131.28) 140.44,130.99 139.24,129.78 138.89,129.78 137.97,128.86 137.97,128.42 137.84,128.29 CV29.1 RV29.1 RV22.2
  BOTTOM w0.102: UV1.AD31 140.05,132.27 v2(140.44,131.87)
PS_2: length 12.6
  TOP w0.102: v1(151.47,134.88) CV27.1 RV28.1 RV21.2 150.89,131.93 v2(150.88,131.94)
  IN1 w0.102: v2(150.88,131.94) 150.71,131.76 146.3,131.76 145.79,132.28 145.1,132.28 144.9,132.47 v2(142.88,132.47)
  BOTTOM w0.102: UV1.AG31 142.68,132.27 v2(142.88,132.47)
PS_3: length 12.4
  TOP w0.102: v2(139.24,131.13) 139.24,130.89 138.82,130.47 138.82,129.99 138.42,129.6 137.57,129.6 137.13,130.03 136.74,130.03 136.64,129.93 135.86,129.93 v1(134.76,128.83) 134.24,128.32 134.24,126.82 134.88,126.19 CV26.1 RV27.1 RV20.2
  BOTTOM w0.102: UV1.AD33 139.7,130.67 v2(139.24,131.13)
PSI#_VGA: length 7.4
  TOP w0.102: PR834.2 192.08,138.07 192.89,138.07 193.17,137.79 v1(193.44,137.79)
  TOP w0.203: PR833.2 191.37,136.47 190.67,136.47 190.28,136.86 PU801.2
  TOP w0.254: PR833.2 191.59,136.69 PR834.2 190.86,137.58 190.84,137.61 v2(190.88,137.61)
  BOTTOM w0.254: v2(190.88,137.61) 190.86,137.61 189.95,136.69 PR835.2
PWR_LED#: length 136.6
  TOP w0.102: v1(159.23,78.51) 159.58,78.16 U31.92 161.71,78.16 161.87,78.32 162.94,78.32 v2(163.35,77.9) ; LED1.1 v2(140.64,1.6) ; JLED1.6 179.88,45.25 v2(179.6,45.53)
  BOTTOM w0.102: v2(163.35,77.9) 163.37,77.89 163.37,73.39 166.49,70.27 166.49,58.28 168.5,56.27 174.59,56.27 177.65,53.21 177.65,47.07 179.2,45.53 v2(179.6,45.53) 180.13,44.99 180.92,44.99 182.9,43.01 182.9,33.77 182.94,33.74 182.94,4.62 181.95,3.64 181.58,3.64 163.3,3.64 160.62,0.96 150.52,0.96 149.89,1.6 v2(140.64,1.6)
QSA0: length 27.4
  TOP w0.109: v2(120.35,130.1) 120.15,129.89 119.95,129.89 119.21,129.15 119.21,127.38 v4(117.99,126.16) 115.11,123.29 114.46,123.29 114.39,123.36 114.39,123.51 114.15,123.75 113.65,123.75 113.42,123.51 113.42,123.13 113.31,123.02 112.98,123.02 112.87,123.13 112.87,123.5 112.64,123.73 112.14,123.73 111.9,123.5 111.9,123.13 111.8,123.02 111.47,123.02 111.36,123.13 111.36,123.49 111.11,123.74 110.64,123.74 110.39,123.49 110.39,123.13 110.28,123.02 109.93,123.02 109.78,123.17 109.78,127.73 109.53,127.98 109.05,127.98 108.8,127.73 108.8,127.52 108.73,127.44 108.23,127.44 UV5.C7
  BOTTOM w0.102: UV1.C34 123.06,130.07 122.7,130.43 122.31,130.43 122.16,130.29 121.42,130.29 121.41,130.29 121.39,130.29
  BOTTOM w0.109: 121.39,130.29 121.04,130.29 120.85,130.1 v2(120.35,130.1)
QSA1: length 32.3
  BOTTOM w0.102: UV1.D29 123.65,133.95 123.76,133.84 123.83,133.82 123.88,133.82 123.99,133.93 123.99,134.22 123.84,134.36 123.79,134.42 123.52,134.42 123.46,134.36 123.02,134.36 122.96,134.43 122.75,134.43 122.47,134.15 121.9,134.15
  BOTTOM w0.109: 121.9,134.15 121.12,134.15 118.11,131.14 118.11,123.45 117.67,123 117.41,123 117.38,122.98 116.82,122.98 116.8,123 116.58,123 116.47,122.89 116.47,122.04 116.24,121.8 115.74,121.8 115.51,122.04 115.51,122.87 115.38,123 115.09,123 114.96,122.87 114.96,122.04 114.73,121.8 v4(113.96,121.8) 112.99,121.8 110.12,124.68 110.12,126.15 109.99,126.28 109.99,127.02 110.32,127.35 111.12,127.35 111.23,127.46 UV6.C7
QSA2: length 34.8
  TOP w0.109: v2(110.69,129.43) 110.69,129.43 110.59,129.53 110.59,129.69 110.71,129.82 111.1,129.82 111.23,129.94 UV5.F3
  IN2 w0.14: v2(110.69,129.43) 110.46,129.66 110.36,129.66 110.13,129.43 110.13,127.99 110.26,127.86 111.11,127.86 111.35,127.62 113.51,127.62 113.72,127.84 114.86,127.84 115.19,128.17 115.19,129.04 115.46,129.32 119.5,129.32 119.63,129.44 119.63,130.01 119.5,130.13 115.88,130.13 115.6,130.41 115.6,131.12 115.88,131.39 120.84,131.39 120.96,131.52 120.96,135.53 120.82,135.67 120.82,136.05 v2(120.62,136.25)
  BOTTOM w0.102: 120.81,136.45 120.82,136.45 120.82,136.68 121.13,136.99 122.63,136.99 122.69,136.94 122.97,136.94 123.07,137.04 123.4,137.04 123.67,136.78 123.83,136.78 123.97,136.92 123.97,137.2 123.86,137.31 123.69,137.31 UV1.D25
  BOTTOM w0.109: 120.81,136.45 v2(120.62,136.25)
QSA3: length 34.5
  IN1 w0.14: v2(121.89,140.14) 121.64,139.88 121.64,138.29 120.18,136.84 120.18,135.87 120.31,135.73 120.97,135.73 121.26,135.45 121.26,134.74 120.92,134.4 119.54,134.4 119.36,134.22 119.36,133.84 119.66,133.53 120.79,133.53 121.06,133.26 121.06,132.43 120.79,132.15 119.5,132.15 119.13,131.78 119.13,131.58 119.34,131.37 119.34,130.98 118.88,130.52 118.49,130.52 118.28,130.73 118.12,130.73 116.42,129.03 114.97,127.58 113.9,127.58 113.69,127.37 109.83,127.37 109.52,127.68 109.52,129.51 108.94,130.08 108.64,130.08 108.42,129.87 v2(108.42,129.65)
  BOTTOM w0.102: v2(121.89,140.14) 121.78,140.14 121.66,140.26 121.66,140.62 121.87,140.83 122.14,140.83 122.21,140.75 122.67,140.75 122.75,140.83 122.92,140.83 123.05,140.71 123.45,140.71 123.82,141.07 123.82,141.2 123.9,141.27 UV1.E20 ; v2(108.42,129.65) 108.03,130.04 UV6.F3
QSA4: length 31.6
  TOP w0.102: UV7.F3 107.98,154.43 v2(108.49,154.94)
  IN1 w0.14: v2(108.49,154.94) 108.49,154.81 108.64,154.66 109.16,154.66 109.28,154.78 109.28,155.84 109.68,156.25 114.16,156.25 114.26,156.34 114.26,156.97 114.53,157.25 115.19,157.25 115.47,156.97 115.47,156.34 115.6,156.2 116.27,156.2 116.69,156.63 117.13,156.63 117.69,156.07 117.69,155.62 117.38,155.32 117.38,155.07 120.7,151.75 120.7,150.87 120.26,150.44 119.32,150.44 119.22,150.33 119.22,149.71 119.36,149.57 119.9,149.57 120.2,149.26 120.2,146.77 120.34,146.63 121.09,146.63 121.42,146.3 121.42,145.89 v2(121.6,145.71)
  BOTTOM w0.102: UV1.E16 123.82,144.7 123.46,144.7 123.24,144.93 122.73,144.93 122.68,144.98 121.72,144.98 121.6,145.1 v2(121.6,145.71)
QSA5: length 28.9
  TOP w0.109: v2(121.21,148.53) 121,148.75 121,148.91 120.76,149.14 119.19,149.14 118.65,149.68 118.65,156.35 v4(117.54,157.46) 115.31,159.69 111.79,159.69 111.3,159.2 111.01,159.2 109.35,157.55 109.35,156.45 109.6,156.2 110.11,156.2 110.37,156.45 110.37,156.79 110.49,156.92 110.99,156.92 UV7.C7
  BOTTOM w0.102: v2(121.21,148.53) 121.08,148.4 121.08,148.23 121.16,148.14 121.49,148.14 121.62,148.01 122.01,148.01 122.18,148.18 122.71,148.18 122.73,148.17 122.98,148.17 122.99,148.18 122.99,148.18 123.07,148.25 123.44,148.25 123.54,148.16 123.76,148.16 123.93,147.99 123.93,147.79 UV1.E12
QSA6: length 32.1
  IN2 w0.102: v2(127.63,149.87) 127.63,149.3 127.8,149.12 127.8,148.71 127.54,148.45 124.27,148.45 123.28,149.43 123.28,150.89 121.84,152.33 121.54,152.33 121.52,152.31 121.51,152.31 ; v2(110.79,154.7) 110.79,154.51 110.71,154.43 110.51,154.43 110.37,154.57 110.05,154.57 109.86,154.76 109.86,155.27 109.88,155.29 109.88,155.31
  IN2 w0.14: 121.51,152.31 121.24,152.31 120.99,152.07 119.94,152.07 119.39,152.62 119.2,152.62 118.69,152.11 118.28,152.11 117.83,152.55 117.83,152.96 118.34,153.47 118.34,153.67 118.05,153.96 117.85,153.96 117.25,153.36 116.86,153.36 116.39,153.83 116.39,154.22 117,154.82 117,155.01 116.63,155.38 116.31,155.38 115.72,154.78 114.28,154.78 113.9,155.17 113.9,156.06 113.77,156.19 110.15,156.19 109.88,155.92 109.88,155.31
  BOTTOM w0.102: v2(110.79,154.7) 111.16,154.32 UV8.F3 ; v2(127.63,149.87) 127.25,149.5 UV1.J10
QSA7: length 27.4
  BOTTOM w0.076: 121.65,152.27 121.69,152.22 121.93,152.22 121.98,152.16 121.99,152.17 122.11,152.05 122.11,152.05 arc(122.26,151.96) 122.44,151.93 122.59,151.93 arc(122.62,151.93) 122.64,151.95 122.67,151.97 arc(122.72,152) 122.77,152.01 122.93,152.01 arc(122.97,152.01) 123.01,152 123.27,151.82 123.27,151.44 123.38,151.34 123.44,151.34 123.45,151.34 123.51,151.28 123.69,151.28 123.83,151.42 123.83,151.55 123.71,151.67 UV1.D7
  BOTTOM w0.102: 120.81,153.1 120.83,153.08 120.84,153.08 121.65,152.27
  BOTTOM w0.109: 120.81,153.1 120.56,153.35 119.81,153.35 119.56,153.6 119.56,154.06 119.81,154.31 120.16,154.31 120.29,154.44 120.29,154.73 120.16,154.86 119.61,154.86 119.03,154.28 118.6,154.28 118.31,154.57 118.31,155.14 118.69,155.52 118.69,155.62 v4(116.48,157.83) 116.26,158.05 115.43,158.05 115.17,158.31 115.17,159.85 114.88,160.15 111.64,160.15 109.97,158.48 109.97,156.86 109.75,156.64 108.78,156.64 108.56,156.86 108.56,156.95 108.48,157.03 108.17,157.03 107.98,156.84 UV8.C7
QSA#0: length 27.2
  TOP w0.109: UV5.B7 107.91,126.85 107.83,126.92 107.83,127.14 107.92,127.23 108.81,127.23 109.01,127.43 109.01,127.64 109.14,127.77 109.44,127.77 109.57,127.64 109.57,123.08 109.84,122.81 110.37,122.81 110.6,123.04 110.6,123.4 110.73,123.53 111.02,123.53 111.15,123.4 111.15,123.04 111.38,122.81 111.88,122.81 112.12,123.04 112.12,123.41 112.2,123.5 112.57,123.5 112.66,123.41 112.66,123.04 112.89,122.81 113.4,122.81 113.63,123.04 113.63,123.43 113.74,123.54 114.07,123.54 114.18,123.43 114.18,123.28 114.37,123.08 115.2,123.08 117.92,125.8 117.95,125.8 118.35,126.19 118.35,126.23 119.42,127.3 119.42,129.06 120.04,129.68 120.19,129.68 v2(120.35,129.52)
  BOTTOM w0.102: UV1.A34 122.32,129.94 121.97,129.94 121.83,130.08 121.41,130.08 121.41,130.08 121.39,130.08
  BOTTOM w0.109: 121.39,130.08 121.13,130.08 121.06,130.01 120.94,129.89 120.73,129.89 v2(120.35,129.52)
QSA#1: length 32.2
  BOTTOM w0.102: 121.9,134.36 121.92,134.36 121.93,134.35 121.99,134.35 121.99,134.35 122.39,134.35 122.67,134.63 123.04,134.63 123.1,134.57 123.38,134.57 123.43,134.62 123.87,134.62 124.05,134.45 124.19,134.3 124.19,133.85 123.92,133.58 123.92,133.4 UV1.E30
  BOTTOM w0.109: UV6.B7 111.23,127.03 111.12,127.14 110.41,127.14 110.2,126.94 110.2,126.37 110.33,126.24 110.33,124.76 113.08,122.01 113.63,122.01 113.66,122.04 114.25,122.04 114.27,122.01 114.64,122.01 114.75,122.12 114.75,122.96 115,123.21 115.47,123.21 115.72,122.96 115.72,122.12 115.83,122.01 116.15,122.01 116.26,122.12 116.26,122.98 116.49,123.21 v4(117.1,123.21) 117.58,123.21 117.9,123.54 117.9,131.22 121.04,134.36 121.9,134.36
QSA#2: length 34.8
  TOP w0.109: v2(110.72,130.23) 111.23,130.74 UV5.G3
  IN2 w0.14: v2(110.72,130.23) 110.41,129.92 110.26,129.92 109.88,129.54 109.88,127.89 110.15,127.61 111,127.61 111.24,127.37 113.61,127.37 113.83,127.58 114.96,127.58 115.44,128.06 115.44,128.94 115.57,129.06 119.61,129.06 119.88,129.34 119.88,130.11 119.61,130.39 115.98,130.39 115.86,130.52 115.86,131.01 115.98,131.14 120.94,131.14 121.22,131.41 121.22,135.63 121.08,135.77 121.08,136.13 v2(121.2,136.25)
  BOTTOM w0.102: UV1.E26 123.95,136.57 123.58,136.57 123.32,136.84 123.15,136.84 123.05,136.74 122.6,136.74 122.55,136.79 121.21,136.79 121.02,136.6 121.02,136.43 v2(121.2,136.25)
QSA#3: length 34.2
  IN1 w0.14: v2(108.42,130.42) 108.5,130.34 109.05,130.34 109.77,129.61 109.77,127.78 109.94,127.62 113.58,127.62 113.79,127.83 114.86,127.83 116.24,129.21 118.01,130.98 118.38,130.98 118.59,130.78 118.77,130.78 119.09,131.09 119.09,131.27 118.88,131.48 118.88,131.89 119.4,132.41 120.68,132.41 120.81,132.53 120.81,133.15 120.68,133.28 119.56,133.28 119.1,133.73 119.1,134.32 119.44,134.66 120.81,134.66 121,134.85 121,135.35 120.87,135.48 120.21,135.48 119.93,135.76 119.93,136.94 121.38,138.4 121.38,140.01 v2(121.26,140.14)
  BOTTOM w0.102: v2(108.42,130.42) 108.34,130.34 108.19,130.34 108.03,130.5 UV6.G3 ; v2(121.26,140.14) 121.46,140.34 121.46,140.7 121.79,141.03 122.22,141.03 122.3,140.95 122.59,140.95 122.67,141.04 123.01,141.04 123.13,140.91 123.37,140.91 123.62,141.16 123.62,141.31 123.57,141.36 123.34,141.36 UV1.C20
QSA#4: length 31.2
  TOP w0.102: UV7.G3 108.04,153.58 108.57,153.58 108.72,153.72 108.72,153.91 v2(108.49,154.14)
  IN1 w0.14: v2(108.49,154.14) 108.76,154.41 109.26,154.41 109.53,154.68 109.53,155.73 109.79,155.99 114.27,155.99 114.51,156.24 114.51,156.87 114.64,156.99 115.08,156.99 115.21,156.87 115.21,156.24 115.5,155.95 116.37,155.95 116.8,156.37 117.03,156.37 117.43,155.97 117.43,155.73 117.13,155.42 117.13,154.96 120.44,151.65 120.44,150.98 120.15,150.69 119.22,150.69 118.96,150.43 118.96,149.61 119.26,149.31 119.79,149.31 119.95,149.15 119.95,146.67 120.24,146.38 120.98,146.38 121.17,146.2 121.17,145.84 v2(121.03,145.71)
  BOTTOM w0.102: UV1.C16 123.25,144.62 123.15,144.73 122.64,144.73 122.59,144.78 121.64,144.78 121.4,145.02 121.4,145.34 v2(121.03,145.71)
QSA#5: length 28.7
  TOP w0.109: v2(120.63,148.52) 120.78,148.67 120.78,148.82 120.68,148.93 119.1,148.93 118.44,149.59 118.44,156.27 117.63,157.08 117.59,157.08 117.17,157.5 117.17,157.53 115.23,159.48 111.88,159.48 111.39,158.99 111.1,158.99 109.57,157.46 109.57,156.54 109.69,156.41 110.03,156.41 110.15,156.54 110.15,156.88 110.4,157.13 111.05,157.13 111.18,157.26 UV7.B7
  BOTTOM w0.102: 120.81,148.33 120.87,148.27 120.87,148.15 121.08,147.94 121.41,147.94 121.54,147.81 122.09,147.81 122.26,147.98 122.63,147.98 122.64,147.96 123.06,147.96 123.08,147.98 123.08,147.98 123.15,148.05 123.35,148.05 123.45,147.95 123.68,147.95 123.73,147.9 123.73,147.63 123.64,147.54 123.38,147.54 UV1.C12
  BOTTOM w0.109: 120.81,148.33 v2(120.63,148.52)
QSA#6: length 32.4
  IN2 w0.102: 121.51,152.57 121.53,152.57 121.55,152.55 121.93,152.55 123.5,150.98 123.5,149.52 124.36,148.66 127.45,148.66 127.56,148.77 127.56,148.95 127.42,149.09 v2(126.85,149.09) ; 109.62,155.31 109.62,155.29 109.64,155.27 109.64,154.68 109.96,154.35 110.28,154.35 110.42,154.21 110.47,154.21 v2(110.79,153.9)
  IN2 w0.14: 109.62,155.31 109.62,156.02 110.05,156.45 113.88,156.45 114.15,156.17 114.15,155.27 114.39,155.04 115.61,155.04 116.21,155.64 116.73,155.64 117.25,155.12 117.25,154.71 116.65,154.11 116.65,153.93 116.96,153.62 117.14,153.62 117.74,154.22 118.15,154.22 118.6,153.77 118.6,153.36 118.09,152.86 118.09,152.66 118.39,152.36 118.58,152.36 119.09,152.87 119.5,152.87 120.05,152.32 120.89,152.32 121.13,152.57 121.51,152.57
  BOTTOM w0.102: UV8.G3 111.16,153.52 v2(110.79,153.9) ; v2(126.85,149.09) 127.25,148.69 UV1.J11
QSA#7: length 28
  BOTTOM w0.076: UV1.F8 124.14,151.78 123.8,152.13 123.17,152.13 arc(123.17,152.13) 123.16,152.13 123.08,152.16 arc(123,152.19) 122.93,152.19 122.77,152.19 arc(122.65,152.17) 122.55,152.11 122.44,152.11 arc(122.33,152.13) 122.23,152.18 122.22,152.2 122.22,152.22 122.13,152.31 122.12,152.31 122.11,152.32
  BOTTOM w0.102: 120.96,153.25 120.98,153.23 120.98,153.22 121.77,152.44 121.83,152.44 arc(121.98,152.41) 122.11,152.32
  BOTTOM w0.109: UV8.B7 107.98,157.35 108.09,157.24 108.57,157.24 108.77,157.04 108.77,156.95 108.87,156.85 109.66,156.85 109.76,156.95 109.76,158.56 111.56,160.36 114.97,160.36 115.39,159.94 115.39,158.43 115.56,158.26 116.35,158.26 116.42,158.19 116.45,158.19 116.84,157.8 116.84,157.77 118.9,155.71 118.9,155.43 118.52,155.05 118.52,154.66 118.69,154.49 118.91,154.49 v4(119.26,154.84) 119.49,155.07 120.25,155.07 120.5,154.82 120.5,154.35 120.25,154.1 119.9,154.1 119.77,153.98 119.77,153.69 119.9,153.56 120.65,153.56 120.96,153.25
QSB0: length 31
  TOP w0.109: v2(123.79,152.97) 123.98,152.97 124.11,152.84 124.11,152.36 123.98,152.23 123.5,152.23 123.27,152.46 123.27,154.35 123.79,154.87 123.79,156.54 123.9,156.65 124.3,156.65 124.55,156.9 124.55,157.37 124.3,157.62 123.9,157.62 123.82,157.71 123.82,158.08 123.9,158.17 124.34,158.17 124.59,158.42 124.59,158.88 124.34,159.13 123.9,159.13 123.79,159.24 123.79,162.08 123.54,162.33 122.91,162.33 122.68,162.11 122.68,161.79 122.55,161.66 122.26,161.66 122.13,161.79 122.13,162.19 121.86,162.46 121.05,162.46 119.39,164.12 119.39,166.67 121.06,168.35 123.79,168.35 124.04,168.6 124.04,169.13 123.79,169.38 123.69,169.38 123.58,169.49 123.58,169.78 UV9.C7
  BOTTOM w0.102: v2(123.79,152.97) 124.21,152.97 124.51,152.67 UV1.F6
QSB1: length 31.4
  BOTTOM w0.109: UV10.C7 123.57,166.96 123.57,167.88 123.17,168.28 120.98,168.28 120.33,167.63 120.33,161.89 120.56,161.65 123.45,161.65 123.58,161.53 123.58,161.12 123.45,160.99 122.1,160.99 122.08,161.02 121.52,161.02 121.5,160.99 120.84,160.99 120.61,160.76 120.61,160.26 120.84,160.03 121.42,160.03 121.53,159.92 121.53,159.27 121.76,159.04 122.26,159.04 122.49,159.27 122.49,159.88 122.62,160 122.94,160 123.07,159.88 123.07,159.14 123.28,158.94 v4(124.14,158.94) 124.58,158.94 126.39,157.13 127.31,157.13 127.44,157 127.44,156.26 127.65,156.06 127.65,154.91 127.76,154.8 127.76,154.73 128,154.49 128.21,154.49 128.25,154.45 UV1.K3
QSB2: length 34.8
  TOP w0.109: UV9.F3 126.1,166.77 v2(125.58,167.29)
  IN2 w0.14: v2(130.68,156.57) 130.43,156.32 129.48,156.32 129.09,156.72 126.6,156.72 125.41,157.91 125.41,158.28 125.51,158.38 125.82,158.38 126.09,158.66 126.09,159.44 125.82,159.71 123.46,159.71 123.34,159.84 123.34,160.41 123.46,160.54 125.82,160.54 126.09,160.81 126.09,161.47 125.82,161.74 123.31,161.74 123.18,161.87 123.18,162.32 123.31,162.44 125.32,162.44 125.57,162.69 125.57,163.4 125.32,163.65 123.63,163.65 123.44,163.84 123.44,167.64 123.63,167.83 125.61,167.83 125.83,167.61 125.83,167.5 125.62,167.29 v2(125.58,167.29)
  BOTTOM w0.102: v2(130.68,156.57) 130.68,156.47 130.98,156.17 131.19,156.17 131.53,155.83 131.53,155.47 131.77,155.22 131.77,154.88 131.45,154.56 UV1.P3
QSB3: length 32.5
  IN1 w0.14: v2(125.74,169.56) 126.17,169.14 126.17,168.81 125.87,168.51 124.34,168.51 123.49,167.65 123.49,165.2 123.49,165.2 123.41,165.13 123.41,164.42 123.32,164.32 123.04,164.32 122.78,164.06 122.78,163.25 123.07,162.96 124.05,162.96 124.18,162.84 124.18,162.39 124.05,162.26 123.07,162.26 122.78,161.98 122.78,160.74 125.99,157.53 133.48,157.53 134.02,156.99 134.02,156.34 134.5,155.86 135.22,155.86 v2(135.32,155.76)
  BOTTOM w0.102: v2(125.74,169.56) 126.15,169.97 UV10.F3 ; UV1.V5 134.65,153.52 135.36,154.23 135.47,154.23 135.78,154.54 135.78,154.81 135.73,154.87 135.73,155.62 135.59,155.76 v2(135.32,155.76)
QSB4: length 38.5
  IN1 w0.14: v2(139.12,156.68) 139.12,156.63 139.29,156.46 139.45,156.46 139.57,156.58 139.57,156.94 139.43,157.08 139.43,157.63 141.04,159.24 151.37,159.24 153.46,161.33 153.46,162.56 153.85,162.95 154.88,162.95 155.01,163.07 155.01,163.52 154.88,163.64 154.07,163.64 153.68,164.04 153.68,165.15 153.94,165.41 153.94,165.87 153.36,166.45 153.36,166.98 153.74,167.36 154.24,167.36 154.83,166.76 155,166.76 155.32,167.08 155.32,167.45 154.71,168.06 153.23,168.06 153.11,168.17 151.86,168.17 151.72,168.03 151.72,167.32 v2(151.88,167.16)
  BOTTOM w0.102: UV11.F3 151.44,166.83 151.44,167.01 151.64,167.22 151.82,167.22 v2(151.88,167.16) ; v2(139.12,156.68) 139.12,156.56 138.91,156.35 138.49,156.35 138.21,156.06 138.21,154.99 138.12,154.9 138.12,154.45 138.25,154.32 138.25,153.98 138.34,153.9 138.34,153.55 138.25,153.47 UV1.AB5
QSB5: length 32.1
  BOTTOM w0.102: 142.83,156.53 142.81,156.51 142.81,156.51 142.77,156.46 142.77,156.29 142.77,156.29 142.77,155.19 UV1.AH1
  BOTTOM w0.109: UV11.C7 153.9,170.04 154.01,170.14 154.22,170.14 154.31,170.05 154.31,169.78 154.19,169.66 154.19,168.99 154.51,168.67 156.27,168.67 158.09,166.85 158.09,162.73 153.65,158.29 153.27,158.29 153.06,158.07 153.06,157.79 153,157.73 152.51,157.73 152.4,157.84 152.4,158.19 152.15,158.44 v4(151.95,158.44) 151.68,158.44 151.43,158.19 151.43,157.84 151.32,157.73 150.99,157.73 150.88,157.84 150.88,158.21 150.65,158.44 150.15,158.44 149.92,158.21 149.92,157.84 149.81,157.73 145.3,157.73 145.17,157.6 144.93,157.6 144.9,157.63 144.15,157.63 144.13,157.6 143.9,157.6 142.83,156.53
QSB6: length 33.2
  TOP w0.102: UV12.F3 151.5,169.9 151.97,169.44 v2(151.97,169.21)
  IN2 w0.102: 144.82,154.89 144.75,154.89 144.6,154.73 144.36,154.49 144.36,153.86 144.63,153.58 144.63,153.21 144.96,152.88 144.96,151.53 144.46,151.03 144.24,151.03 144.06,150.85 v2(144.06,150.69)
  IN2 w0.14: 144.82,154.89 145.12,154.89 145.31,155.08 145.75,155.08 145.8,155.03 145.99,155.03 146.13,154.88 146.13,154.63 146.41,154.35 147.09,154.35 147.37,154.63 147.37,154.91 147.48,155.03 149.17,155.03 149.82,155.68 150.02,155.68 150.11,155.59 150.24,155.45 150.62,155.45 150.77,155.6 151.1,155.93 151.1,156.31 150.87,156.53 150.87,156.73 151.21,157.07 151.41,157.07 151.94,156.53 152.33,156.53 152.79,157 152.79,157.39 152.26,157.92 152.26,158.12 152.56,158.42 153.29,158.42 154.21,159.34 154.21,167.19 152.84,168.56 152.12,168.56 151.8,168.88 151.8,169.04 v2(151.97,169.21)
  BOTTOM w0.102: UV1.AJ9 143.87,150.69 v2(144.06,150.69)
QSB7: length 32.3
  TOP w0.109: v2(145.28,153.38) 145.61,153.38 146.14,153.92 146.14,156.09 145.59,156.64 145.59,158.97 145.67,159.05 146.18,159.05 146.29,158.94 v4(146.29,157.83) 146.29,157.18 146.54,156.93 147.01,156.93 147.26,157.18 147.26,158.94 147.37,159.05 153.67,159.05 157.14,162.52 157.14,166.37 155.61,167.91 154.52,167.91 154.09,167.48 154.09,166.95 UV12.C7
  BOTTOM w0.102: v2(145.28,153.38) 145.76,153.38 UV1.AM5
QSB#0: length 31.5
  TOP w0.109: UV9.B7 123.22,169.97 123.37,169.82 123.37,169.41 123.61,169.17 123.71,169.17 123.83,169.04 123.83,168.69 123.71,168.56 120.98,168.56 119.18,166.76 119.18,164.03 120.96,162.24 121.78,162.24 121.92,162.1 121.92,161.7 122.17,161.45 122.64,161.45 122.89,161.7 122.89,162.02 122.99,162.12 123.46,162.12 123.58,162 123.58,159.15 123.82,158.92 124.25,158.92 124.38,158.79 124.38,158.5 124.25,158.38 123.82,158.38 123.58,158.14 123.58,157.64 123.82,157.41 124.21,157.41 124.34,157.28 124.34,156.99 124.21,156.86 123.82,156.86 123.58,156.63 123.58,154.96 123.06,154.44 123.06,152.37 123.43,152 v1(124.63,152) 125.2,151.44 v2(125.2,151.44)
  BOTTOM w0.102: UV1.G7 125.63,151.87 v2(125.2,151.44)
QSB#1: length 31.1
  BOTTOM w0.109: UV1.K1 128.35,154.98 128.35,154.8 128.26,154.7 128.09,154.7 127.97,154.82 127.97,154.89 127.86,155 127.86,156.14 127.66,156.35 127.66,157.08 127.4,157.34 126.48,157.34 124.67,159.15 124.44,159.15 124.42,159.17 123.86,159.17 123.84,159.15 123.36,159.15 123.28,159.23 123.28,159.96 123.03,160.22 122.53,160.22 122.28,159.96 122.28,159.36 122.17,159.25 121.85,159.25 121.74,159.36 121.74,160 121.5,160.24 120.93,160.24 120.82,160.35 120.82,160.67 120.93,160.78 v4(121.8,160.78) 123.54,160.78 123.79,161.03 123.79,161.61 123.54,161.87 120.65,161.87 120.54,161.97 120.54,167.54 121.07,168.07 123.08,168.07 123.36,167.79 123.36,166.7 123.25,166.58 123.15,166.58 UV10.B7
QSB#2: length 34.5
  TOP w0.109: UV9.G3 126.86,166.77 v2(126.35,167.28)
  IN2 w0.14: v2(130.68,155.93) 130.54,156.07 129.38,156.07 128.98,156.46 126.5,156.46 125.15,157.8 125.15,158.39 125.4,158.64 125.71,158.64 125.84,158.76 125.84,159.33 125.71,159.46 123.36,159.46 123.08,159.73 123.08,160.52 123.36,160.79 125.71,160.79 125.84,160.92 125.84,161.36 125.71,161.49 123.21,161.49 122.93,161.77 122.93,162.42 123.21,162.7 125.22,162.7 125.32,162.8 125.32,163.29 125.22,163.39 123.52,163.39 123.18,163.73 123.18,167.74 123.52,168.08 125.72,168.08 126.08,167.72 126.08,167.55 v2(126.35,167.28)
  BOTTOM w0.102: UV1.P1 131.45,155.25 131.26,155.45 131.26,155.81 131.1,155.97 130.71,155.97 v2(130.68,155.93)
QSB#3: length 32.4
  IN1 w0.14: v2(126.54,169.57) 126.42,169.46 126.42,168.7 125.97,168.25 124.45,168.25 123.74,167.55 123.74,165.1 123.67,165.02 123.67,164.31 123.43,164.07 123.15,164.07 123.03,163.95 123.03,163.36 123.17,163.22 124.15,163.22 124.43,162.94 124.43,162.29 124.15,162.01 123.17,162.01 123.03,161.87 123.03,160.85 126.1,157.78 133.59,157.78 134.27,157.1 134.27,156.45 134.6,156.12 135.11,156.12 v2(135.33,156.33)
  BOTTOM w0.102: UV1.W4 135.45,153.92 135.99,154.45 135.99,154.9 135.94,154.95 135.94,155.71 135.69,155.95 135.69,156.03 135.84,156.17 135.84,156.35 135.68,156.51 135.5,156.51 v2(135.33,156.33) ; v2(126.54,169.57) 126.94,169.97 UV10.G3
QSB#4: length 38.3
  IN1 w0.14: v2(151.08,167.16) 151.47,167.55 151.47,168.14 151.76,168.42 153.22,168.42 153.33,168.31 154.81,168.31 155.57,167.55 155.57,166.97 155.1,166.51 154.73,166.51 154.13,167.1 153.85,167.1 153.61,166.87 153.61,166.56 154.2,165.97 154.2,165.31 153.93,165.04 153.93,164.14 154.18,163.9 154.99,163.9 155.26,163.62 155.26,162.97 154.99,162.69 153.96,162.69 153.72,162.45 153.72,161.22 151.48,158.99 141.14,158.99 139.68,157.53 139.68,157.19 139.82,157.05 139.82,156.47 139.56,156.21 139.31,156.21 v2(139.14,156.03)
  BOTTOM w0.102: v2(151.08,167.16) 150.7,166.79 UV11.G3 ; UV1.AC4 138.45,154.07 138.45,154.4 138.32,154.53 138.32,154.81 138.41,154.9 138.41,155.98 138.58,156.14 139.02,156.14 v2(139.14,156.03)
QSB#5: length 32.4
  BOTTOM w0.102: 142.98,156.38 142.98,154.91 142.85,154.78 142.85,154.46 UV1.AH3
  BOTTOM w0.109: UV11.B7 154.53,169.79 154.53,169.69 154.4,169.57 154.4,169.08 154.6,168.88 156.36,168.88 158.3,166.93 158.3,162.64 153.74,158.08 153.36,158.08 153.27,157.99 153.27,157.7 153.08,157.52 152.42,157.52 152.19,157.75 152.19,158.1 152.08,158.2 151.75,158.2 151.64,158.1 151.64,157.75 151.41,157.52 150.91,157.52 150.67,157.75 150.67,158.12 150.56,158.23 150.24,158.23 150.13,158.12 150.13,157.75 149.89,157.52 145.39,157.52 145.26,157.39 v4(144.53,157.39) 143.99,157.39 142.98,156.38
QSB#6: length 33
  TOP w0.102: UV12.G3 150.85,169.97 151.4,169.42 151.4,169.26 v2(151.39,169.25)
  IN2 w0.102: v2(144.07,151.48) 144.07,151.29 144.13,151.24 144.37,151.24 144.75,151.62 144.75,152.79 144.42,153.12 144.42,153.49 144.14,153.77 144.14,154.58 144.44,154.89 144.66,155.1 144.7,155.1 144.72,155.12 144.78,155.12 144.8,155.14 144.82,155.14
  IN2 w0.14: v2(151.39,169.25) 151.54,169.1 151.54,168.78 152.01,168.31 152.73,168.31 153.96,167.09 153.96,159.45 153.18,158.67 152.46,158.67 152.01,158.22 152.01,157.81 152.54,157.28 152.54,157.1 152.22,156.79 152.05,156.79 151.51,157.32 151.11,157.32 150.62,156.83 150.62,156.42 150.84,156.2 150.84,156.04 150.58,155.77 150.53,155.72 150.34,155.72 150.29,155.77 150.13,155.93 149.72,155.93 149.07,155.28 147.38,155.28 147.11,155.01 147.11,154.73 146.98,154.61 146.51,154.61 146.39,154.73 146.39,154.99 146.1,155.28 145.91,155.28 145.86,155.33 145.2,155.33 145.01,155.14 144.82,155.14
  BOTTOM w0.102: v2(144.07,151.48) 143.67,151.07 UV1.AJ8
QSB#7: length 32.1
  TOP w0.109: UV12.B7 154.53,166.6 154.43,166.6 154.3,166.72 154.3,167.4 154.6,167.7 155.52,167.7 156.93,166.29 156.93,162.61 153.59,159.26 147.28,159.26 147.05,159.03 147.05,157.27 146.92,157.14 146.63,157.14 146.5,157.27 146.5,157.53 146.52,157.55 146.52,158.11 146.5,158.13 146.5,159.03 146.27,159.26 145.58,159.26 145.38,159.06 145.38,156.55 145.93,156 145.93,154.05 145.77,153.88 v2(145.54,153.88)
  BOTTOM w0.102: v2(145.54,153.88) 146.1,153.88 146.21,154 146.21,154.16 146.1,154.27 UV1.AM3
RASA0#: length 33.9
  TOP w0.102: v2(110.05,132.04) 110.19,132.17 110.96,132.17 UV5.J3 ; 120.81,138.8 120.94,138.92 124.6,138.92 125.55,137.96 127.05,137.96 127.23,137.79 128.5,137.79 128.66,137.94 128.66,138.92 128.53,139.05 128.12,139.05 128,138.92 128,138.38 v2(128.12,138.25)
  TOP w0.203: 120.81,138.8 120.42,138.41 118.24,138.41 117.81,138.83 v1(117.81,139.18) 117.81,139.49 117.36,139.94 v2(116.98,139.94)
  IN1 w0.102: v2(110.05,132.04) 110.34,132.04 110.49,131.88 110.49,131.73 110.59,131.63 110.8,131.63 110.9,131.73 110.9,131.88 112.22,133.2 112.75,133.2 112.86,133.3 112.86,133.51 112.96,133.61 113.16,133.61 113.26,133.51 113.26,133.3 113.36,133.2 113.69,133.2
  IN1 w0.127: v2(116.98,139.94) 116.89,139.85 116.89,136.35 113.74,133.2 113.69,133.2
  BOTTOM w0.102: UV6.J3 108.52,132.45 108.81,132.15 108.81,132.08 109.29,131.6 109.61,131.6 v2(110.05,132.04) ; v2(128.12,138.25) 128.15,138.27 128.15,138.77 UV1.K23
RASA1#: length 34
  TOP w0.102: v2(127.72,141.86) 127.62,141.86 127.25,142.24 126.98,142.24 126.56,142.66 125.27,142.66 124.47,143.46 120.83,143.46 120.81,143.47 ; UV7.J3 108.16,151.92 108.54,152.3 108.54,152.41 108.41,152.54 108.41,152.66 108.64,152.89 108.88,152.89 109.07,152.7 v2(109.07,152.39)
  TOP w0.203: v2(118.17,143.82) 118.17,144.18 118.26,144.28 118.85,144.28 118.98,144.15 v1(118.98,143.86) 118.98,143.62 119.11,143.49 119.6,143.49 119.81,143.7 119.81,144.13 119.93,144.26 120.4,144.26 120.53,144.13 120.53,143.62 120.66,143.49 120.79,143.49 120.81,143.47
  IN1 w0.127: v2(109.07,152.39) 109.44,152.02 110.62,152.02 112.3,150.34 113.78,150.34 115.44,148.68 115.44,147.76 116.1,147.1 116.1,146.35 116.36,146.09 116.54,146.09 116.82,146.37 117,146.37 117.18,146.19 117.18,146.01 116.9,145.73 116.9,145.55 117.08,145.37 117.26,145.37 117.54,145.65 117.71,145.65 117.89,145.47 117.89,145.29 117.62,145.01 117.62,144.83 118.17,144.28 v2(118.17,143.82)
  BOTTOM w0.102: v2(127.72,141.86) 128.05,142.2 UV1.K19 ; v2(109.07,152.39) 109.48,152.79 110.15,152.79 111.02,151.92 UV8.J3
RASB0#: length 36.7
  TOP w0.102: 135.2,157.31 135.2,156.74 134.93,156.48 134.93,154.36 134.61,154.04 v1(134.61,153.76) 134.61,152.96 134.3,152.64 133.19,152.64 132.85,152.3 132.85,149.84 132.74,149.73 v2(132.09,149.73) ; UV9.J3 127.93,167.41 127.64,167.41 127.39,167.66 127.39,167.8 127.66,168.07 128,168.07 v2(128.11,167.96)
  TOP w0.203: 135.2,157.31 135.2,157.97 135.64,158.42 135.64,158.6 134.92,159.32 134.92,159.5 135.32,159.89 135.5,159.89 136.24,159.15 136.4,159.15 136.79,159.54 136.79,159.69 136.44,160.04 136.04,160.44 136.04,160.61 136.43,161.01 136.62,161.01 136.92,160.71 v2(137.09,160.71)
  IN1 w0.102: 129.54,164.61 129.54,166.27 128.11,167.71 v2(128.11,167.96)
  IN1 w0.127: 129.54,164.61 131.55,162.6 133.56,162.6 135.44,160.71 v2(137.09,160.71)
  BOTTOM w0.102: v2(128.11,167.96) 127.73,168.34 127.73,168.7 128.2,169.18 128.27,169.18 128.57,169.48 UV10.J3 ; UV1.T10 132.35,149.47 v2(132.09,149.73)
RASB1#: length 38.1
  TOP w0.102: v2(149.57,168.88) 149.57,169.9 149.44,170.02 149.16,170.02 UV12.J3 ; v2(135.65,150.29) v1(136.23,150.29) 136.44,150.5 136.44,153.13 137.9,154.59 137.9,157.31
  TOP w0.203: 137.9,157.31 137.9,157.84 138.03,157.97 138.03,158.31 138.25,158.54 138.6,158.54 139.5,159.44 139.5,159.81 139.66,159.97 140.03,159.97 140.36,160.29 140.36,160.59 140.22,160.72 140.02,160.72 139.91,160.84 139.91,161.41 140.03,161.54 140.25,161.54 140.36,161.64 140.36,162.46 140.24,162.57 140.06,162.57 139.69,162.2 v2(139.63,162.2)
  IN1 w0.127: v2(149.57,168.88) 149.2,168.51 149.2,168.05 147.45,166.31 147.45,165.84 146.53,164.92 146.53,164.07 145.16,162.7 144.34,162.7 144.25,162.6 144.25,162.22 144.17,162.14 143.82,162.14 143.74,162.22 143.74,162.56 143.64,162.66 143.16,162.66 143.06,162.56 143.06,162.2 142.96,162.1 142.64,162.1 142.54,162.2 142.54,162.54 142.44,162.65 141.92,162.65 141.82,162.54 141.82,162.22 141.74,162.14 141.39,162.14 141.31,162.22 141.31,162.38 141.23,162.46 140.89,162.46 140.8,162.37 140.8,162.22 140.72,162.14 140.36,162.14 140.29,162.21 140.29,162.37 140.22,162.45 139.87,162.45 v2(139.63,162.2)
  BOTTOM w0.102: UV11.J3 149.1,167.23 149.97,168.1 149.97,168.47 v2(149.57,168.88) ; v2(135.65,150.29) 136.25,149.69 UV1.Y10
RBIAS_VGA: length 2.9
  TOP w0.203: v2(190.9,136.94) 190.58,137.26 PU801.3
  BOTTOM w0.254: v2(190.9,136.94) 190.39,136.44 190.39,136.23 PR836.1
RED: length 14.8
  IN2 w0.127: v2(11.44,117.28) 11.44,115.75 11.18,115.49 7.67,115.49 6.24,114.07 JCRT1.1
  BOTTOM w0.102: v2(11.44,117.28) 11.53,117.19 12.26,117.19 13.32,116.14 U10.3 13.32,113.41 13.95,112.78 C525.1 13.96,112.74 L30.2
REMOTE1+: length 2.6
  TOP w0.254: U9.2 150.2,72.17 150.27,72.25 150.72,72.25 C587.1 150.91,72.06 RV16.1
REMOTE1-: length 2.6
  TOP w0.254: U9.3 150.12,72.82 150.18,72.76 150.66,72.76 C587.2 151.75,72.99 RV17.1
RI#: length 6
  TOP w0.102: U4.N4 130.34,92.79 v2(130.57,92.56)
  BOTTOM w0.102: RP10.8 131.32,96.48 v1(130.92,96.09) 130.74,95.9 130.74,92.74 v2(130.57,92.56)
RTN_VGA: length 6.3
  TOP w0.203: PR860.2 188.66,142.91 v2(188.66,142.26) 188.66,141.85 188.22,141.42 PU801.13
  BOTTOM w0.254: PC863.2 188.66,142.87 v2(188.66,142.26) 188.34,141.93 PR861.2 188.34,141.14 PC862.2
S3_1.35V: length 4.4
  TOP w0.102: PR502.2 27.52,8.89 v1(27.19,9.23)
  TOP w0.203: PC503.1 29.86,8.34 PU501.7
  TOP w0.254: PC503.1 28.34,8.91 PR502.2
S5_1.35V: length 4.1
  TOP w0.102: v1(27.13,7.88) 27.24,7.99 PR505.2
  TOP w0.203: PC508.1 29.3,7.94 PU501.8
  TOP w0.254: PR505.2 PC508.1
SATA_ACT#: length 2.3
  TOP w0.102: U4.AP3 121.53,92.79 v2(121.28,92.54)
  BOTTOM w0.102: v2(121.28,92.54) 120.85,92.54 120.57,92.82 120.57,92.83 120.08,93.32 R108.2
SATA_COMP: length 4.3
  TOP w0.102: U4.AY5 119.03,92.16 119.03,91.47 v2(118.91,91.35)
  BOTTOM w0.089: 118.55,91.37 118.9,91.37 v2(118.91,91.35) ; v1(117.67,89.21) 117.67,89.77 118.21,90.31 R107.1
  BOTTOM w0.102: 118.55,91.37 R107.1
SATA_DTX_C_PRX_N4: length 53.9
  TOP w0.089: U4.BD13 117.25,88.9 117.33,88.82 117.33,88.67 117.23,88.57 117,88.57 116.77,88.8 116.48,88.8 116.17,89.1 116.17,90.46 115.96,90.68 115.64,90.68 v2(115.45,90.48)
  IN2 w0.127: v2(115.45,90.48) 115.53,90.56 115.96,90.56 116.21,90.81 116.21,92.29 115.08,93.42 115.08,95.28 118.03,98.23 120.36,98.23 120.76,98.63 120.76,99.03 121.12,99.39 125.41,99.39 126.04,100.02 127.73,100.02 131.4,103.7 146.98,103.7 147.19,103.48 147.19,103.27 v2(146.95,103.03)
  BOTTOM w0.102: C596.1 147.53,109.75 147.63,109.75 147.71,109.67 147.71,109.12 147.28,108.69 147.28,103.36 v2(146.95,103.03)
SATA_DTX_C_PRX_N5: length 145.1
  TOP w0.089: U4.BC14 117.47,88.35 116.97,88.35 116.8,88.19 116.43,88.19 115.63,88.98 v2(115.34,88.98)
  IN2 w0.127: v2(192.37,50.41) 192.56,50.59 192.81,50.59 193.16,50.95 193.16,60.51 194,61.35 194,78.38 195.55,79.93 195.55,83.05 178.97,99.62 161.09,99.62 155.35,105.36 150.2,105.36 148.29,107.27 127.81,107.27 124.6,104.06 118.92,104.06 115.11,100.25 114.37,100.25 113.4,99.28 113.4,93.35 114.24,92.5 114.24,89.85 115.11,88.98 v2(115.34,88.98)
  BOTTOM w0.102: R403.1 191.82,50.41 v2(192.37,50.41) 192.4,50.44 192.82,50.44 C614.1
SATA_DTX_C_PRX_P4: length 53.9
  TOP w0.089: U4.BB13 117.59,88.88 117.28,89.19 117.01,89.19 116.82,89 116.56,89 116.38,89.19 116.38,90.55 116.05,90.88 115.64,90.88 v2(115.45,91.07)
  IN2 w0.127: v2(115.45,91.07) 115.7,90.81 115.85,90.81 115.96,90.92 115.96,92.18 114.83,93.31 114.83,95.39 117.92,98.48 120.25,98.48 120.5,98.73 120.5,99.14 121.01,99.64 125.31,99.64 125.94,100.27 127.62,100.27 131.3,103.95 147.08,103.95 147.45,103.58 147.45,103.12 v2(147.54,103.03)
  BOTTOM w0.102: v2(147.54,103.03) 147.5,103.07 147.5,108.6 147.92,109.03 147.92,109.19 C597.1
SATA_DTX_C_PRX_P5: length 145.9
  TOP w0.089: v2(115.35,89.83) 115.18,89.83 115.04,89.7 115.04,89.46 115.15,89.35 115.55,89.35 116.51,88.39 116.6,88.39 U4.BE14
  IN2 w0.127: v2(115.35,89.83) 115.49,89.83 115.6,89.72 115.6,89.54 115.46,89.41 115.05,89.41 114.5,89.96 114.5,92.61 113.65,93.45 113.65,99.17 114.47,100 115.22,100 119.02,103.8 124.7,103.8 127.92,107.02 148.18,107.02 150.1,105.1 155.25,105.1 160.98,99.37 178.87,99.37 195.3,82.94 195.3,80.04 193.75,78.49 193.75,61.46 192.91,60.62 192.91,51.06 192.7,50.85 192.51,50.85 v2(192.37,50.99)
  BOTTOM w0.102: C613.1 193.29,50.89 193.29,50.77 193.21,50.7 192.66,50.7 v2(192.37,50.99) 192.07,50.7 191.4,50.7 191.35,50.75 191.35,50.86 R404.1
SATA_DTX_PRX_N4: length 11.6
  BOTTOM w0.102: C596.2 147.62,110.75 147.62,117.03 148.6,118.01 148.6,119.59 148.07,120.12 JHDD1.5
SATA_DTX_PRX_N5_14: length 8
  BOTTOM w0.102: JODD1.5 200.22,48.69 198.28,48.69 v4(196.7,50.27) 196.34,50.63 195.49,50.63 195.47,50.62 194.76,50.62 194.75,50.63 194.39,50.63 C614.2
SATA_DTX_PRX_N5_15: length 7.7
  TOP w0.102: JODD2.5 184.53,51.15 184.9,51.52 185.24,51.52 v2(185.43,51.34)
  BOTTOM w0.102: v2(185.43,51.34) 185.62,51.53 186.24,51.53 187.23,50.54 v4(188.28,50.54) 190.44,50.54 R403.2
SATA_DTX_PRX_P4: length 11.6
  BOTTOM w0.102: C597.2 147.84,110.73 147.84,116.94 148.81,117.92 148.81,119.54 149.34,120.07 JHDD1.6
SATA_DTX_PRX_P5_14: length 8
  BOTTOM w0.102: JODD1.6 200.25,48.9 198.37,48.9 197.05,50.23 197.05,50.24 196.67,50.62 196.65,50.62 196.43,50.85 v4(195.09,50.85) 194.25,50.85 C613.2
SATA_DTX_PRX_P5_15: length 7.7
  TOP w0.102: JODD2.6 184.55,52.15 184.96,51.74 185.24,51.74 v2(185.43,51.92)
  BOTTOM w0.102: R404.2 190.33,50.76 188.59,50.76 188.58,50.77 188.01,50.77 187.99,50.76 187.32,50.76 186.33,51.74 185.6,51.74 v2(185.43,51.92)
SATA_PTX_C_DRX_N4: length 48.8
  TOP w0.102: v2(119.59,88.53) 119.81,88.3 U4.AV15
  IN2 w0.089: v2(119.59,88.53) 119.41,88.7 119.41,89.66 117.54,91.53 117.28,91.53 116.77,92.05 116.77,94.76 116.79,94.78 116.79,94.79
  IN2 w0.127: 116.79,94.79 116.79,95.68 118.42,97.31 121.15,97.31 122.34,98.5 123.66,98.5 123.89,98.27 125.59,98.27 126.22,98.9 128.45,98.9 132.31,102.77 144.11,102.77 144.58,102.3 145.64,102.3 146.01,102.66 146.01,102.89 v2(146.18,103.06)
  BOTTOM w0.102: v2(146.18,103.06) 145.99,103.24 145.99,109.14 C114.2
SATA_PTX_C_DRX_N5: length 132.5
  TOP w0.089: 121.6,88.17 v2(121.89,88.45)
  TOP w0.102: U4.AP15 121.6,88.17
  IN2 w0.089: v2(121.89,88.45) 121.85,88.41 121.71,88.41 121.65,88.48 121.65,88.67 119.98,90.34 119.98,92.18 120.58,92.78 120.58,94.75 120.6,94.77 120.6,94.79
  IN2 w0.127: v2(192.4,47.93) 192.59,47.74 192.87,47.74 193.02,47.89 193.02,48.49 191.48,50.04 191.48,60.92 192.82,62.26 192.82,84.16 186.21,90.76 181.81,95.17 178.51,95.17 176.65,97.04 158.88,97.04 156.94,98.98 151.43,98.98 149,101.41 144.21,101.41 143.75,101.87 135.88,101.87 135.03,101.03 132.26,101.03 130.53,99.29 130.09,99.29 128.82,98.02 126.59,98.02 125.96,97.38 122.48,97.38 120.6,95.5 120.6,94.79
  BOTTOM w0.102: C615.1 193.1,48.11 193.4,47.81 193.4,47.72 193.33,47.65 192.68,47.65 v2(192.4,47.93) 192.09,47.62 191.52,47.62 191.46,47.69 191.46,47.81 R402.1
SATA_PTX_C_DRX_P4: length 48.8
  TOP w0.089: v2(119,88.54) 119.21,88.33 U4.AW15
  IN2 w0.089: v2(119,88.54) 119.2,88.73 119.2,89.57 117.45,91.32 117.19,91.32 116.55,91.96 116.55,94.76 116.53,94.78 116.53,94.79
  IN2 w0.127: v2(145.59,103.06) 145.75,102.9 145.75,102.77 145.53,102.55 144.69,102.55 144.22,103.02 132.2,103.02 128.34,99.16 126.12,99.16 125.48,98.52 124,98.52 123.77,98.75 122.24,98.75 121.05,97.57 118.31,97.57 116.53,95.79 116.53,94.79
  BOTTOM w0.102: v2(145.59,103.06) 145.78,103.24 145.78,108.99 C116.2
SATA_PTX_C_DRX_P5: length 131.7
  TOP w0.089: 121,88.18 v2(121.28,88.46)
  TOP w0.102: U4.AR15 121,88.18
  IN2 w0.089: 120.35,94.79 120.35,94.77 120.37,94.75 120.37,92.87 119.76,92.27 119.76,90.25 121.28,88.73 v2(121.28,88.46)
  IN2 w0.127: v2(192.4,47.35) 192.53,47.48 192.97,47.48 193.28,47.79 193.28,48.6 191.73,50.14 191.73,60.81 193.07,62.15 193.07,84.27 181.91,95.43 178.62,95.43 176.75,97.29 158.99,97.29 157.04,99.24 151.53,99.24 149.11,101.66 144.32,101.66 143.85,102.13 135.77,102.13 134.92,101.28 132.16,101.28 130.42,99.54 129.98,99.54 128.71,98.27 126.49,98.27 125.85,97.63 122.37,97.63 120.35,95.61 120.35,94.79
  BOTTOM w0.102: R401.1 191.93,47.35 v2(192.4,47.35) 192.45,47.39 192.86,47.39 C616.1
SATA_PTX_DRX_N4: length 11.6
  BOTTOM w0.102: JHDD1.3 145.53,120.07 145.01,119.55 145.01,119.08 145.96,118.13 145.96,110.68 C114.1
SATA_PTX_DRX_N5_14: length 8.3
  BOTTOM w0.102: C615.2 194.38,47.75 v4(195.1,47.75) 196.13,47.75 196.58,47.31 196.59,47.31 196.97,46.93 196.97,46.91 198.88,45.01 200.16,45.01 JODD1.3
SATA_PTX_DRX_N5_15: length 7.8
  TOP w0.102: JODD2.3 184.59,49.15 184.98,48.76 185.26,48.76 v2(185.45,48.94)
  BOTTOM w0.102: v2(185.45,48.94) 185.63,48.76 186.27,48.76 187.28,47.76 188.18,47.76 188.2,47.77 188.73,47.77 188.75,47.76 190.49,47.76 R402.2
SATA_PTX_DRX_P4: length 11.7
  BOTTOM w0.102: C116.1 145.74,110.75 145.74,118.04 144.79,118.99 144.79,119.48 144.26,120 JHDD1.2
SATA_PTX_DRX_P5_14: length 8.2
  BOTTOM w0.102: C616.2 194.38,47.53 194.74,47.53 194.75,47.52 195.47,47.52 195.49,47.53 196.04,47.53 v4(196.62,46.96) 198.79,44.79 200.31,44.79 JODD1.2
SATA_PTX_DRX_P5_15: length 7.8
  TOP w0.102: v2(185.45,48.36) 185.26,48.54 184.94,48.54 184.54,48.15 JODD2.2
  BOTTOM w0.102: R401.2 190.82,47.18 190.46,47.54 v4(188.46,47.54) 187.19,47.54 186.18,48.55 185.64,48.55 v2(185.45,48.36)
SDIO: length 3.3
  BOTTOM w0.203: PR906.1 22.15,125.24 v1(22.41,124.99) 22.69,124.71 PU901.3
  BOTTOM w0.254: PR906.1 22.14,125.97 PR905.2
SERIRQ: length 77.6
  TOP w0.102: U31.3 175.23,77.36 171.6,80.99 171.6,89.22 v2(171.75,89.37) ; v2(122.07,89.39) 122.49,89.81 U4.AL11
  IN2 w0.089: v2(122.07,89.39) 122.91,90.23 125.27,90.23 125.58,90.54 125.58,92.1 127.52,94.05 129.62,94.05 130.04,94.46 130.04,94.46 130.37,94.79
  IN2 w0.127: 130.37,94.79 130.9,95.32 130.9,96.5 133.43,99.03 136.08,99.03 136.43,98.68 137.14,98.68 138.28,99.82 139.53,99.82 139.92,99.43 147.44,99.43 150.08,96.78 154.27,96.78 155.49,95.56 155.8,95.56 161.45,89.91 171.2,89.91 v2(171.75,89.37)
  BOTTOM w0.102: R223.1 121.24,89.04 121.72,89.04 v2(122.07,89.39)
SLP_A#: length 7.2
  TOP w0.089: U4.F3 132.57,93.15 132.19,93.53 132.19,93.76 132.44,94.02 132.44,94.18 133.54,95.27 136.38,95.27 v2(136.61,95.04)
  BOTTOM w0.089: T22.1 136.34,94.78 136.35,94.79
  BOTTOM w0.102: 136.35,94.79 v2(136.61,95.04)
SLP_SUS: length 9.5
  TOP w0.102: Q118.2 v1(147.67,81.59) 147.67,80.58 147.95,80.3 Q124.1 150.49,80.3 150.73,80.06 150.73,77.9 150.94,77.69 R780.2
SLP_SUS#: length 71.1
  TOP w0.089: U4.F1 132.83,94.31 133.61,95.09 135.68,95.09 136.13,94.65 136.74,94.65 137.45,93.94 v2(137.93,93.94)
  TOP w0.102: R34.1 153.03,78.56 v2(152.84,78.37) ; v2(175.02,83.03) 175.09,82.96 U31.17
  IN1 w0.127: v2(175.02,83.03) 175.86,83.03 178.2,85.37 178.2,88.5 177.81,88.9 175.36,88.9 175.04,88.58 173.07,88.58 172.75,88.9 171.01,88.9 170.82,89.09 157.82,89.09 157.22,89.68 152.62,89.68 v2(152.38,89.92) 147.61,89.92 145.11,92.43 139.44,92.43 v2(137.93,93.94)
  BOTTOM w0.102: v2(152.84,78.37) 152.84,78.37 v1(152.84,80.25) 152.84,81.1 152.77,81.18 152.77,87.47 152.3,87.94 152.3,89.85 v2(152.38,89.92)
SM_INTRUDER#: length 3.5
  TOP w0.089: U4.A8 135.31,90.91 135.43,91.04 137.53,91.04 137.96,91.47
  TOP w0.102: 137.96,91.47 138.14,91.65 R96.2
SM_RCOMP0: length 9.7
  TOP w0.305: v2(52.04,81.41) 52.63,80.82 52.63,80.03 51.89,79.28 50.9,79.28 50.34,78.73 v1(50.34,75.56) R5.1
  BOTTOM w0.305: v2(52.04,81.41) 52.51,81.88 JCPU1.AP3
SM_RCOMP1: length 9
  TOP w0.305: v2(51.04,81.41) 51.04,81.21 v1(49.46,79.63) 48.48,78.65 R6.1
  BOTTOM w0.305: JCPU1.AR3 51.51,81.88 v2(51.04,81.41)
SM_RCOMP2: length 8.6
  TOP w0.305: v2(52.04,80.41) 51.83,80.41 51.26,79.84 50.46,79.84 49.39,78.77 v1(49.39,77.53) R7.1
  BOTTOM w0.305: JCPU1.AP2 52.51,80.88 v2(52.04,80.41)
SMB_CLK_S3: length 207.4
  TOP w0.102: v2(139.56,76.73) 139.52,76.7 139.52,74.81 139.88,74.45 140.99,74.45 141.4,74.85 141.82,74.85 v2(142.04,75.07)
  IN2 w0.127: v2(183.91,72.83) 183.79,72.95 180.63,72.95 180.03,72.35 176.12,72.35 175.67,71.9 174.02,71.9 173.46,71.35 164.28,71.35 163.48,72.15 161.67,72.15 160.73,71.21 157.68,71.21 153.23,66.76 151.59,66.76 142.76,75.6 141.72,75.6 141.47,75.35 141.47,75.05 141.59,74.93 141.9,74.93 v2(142.04,75.07) 142.16,74.95 142.57,74.95 143.12,74.39 143.12,72.71 141.9,71.49 140.11,71.49 129.13,60.5 v2(129.13,60.31)
  BOTTOM w0.102: R501.2 197.19,134.01 197.19,133.58 196.84,133.23 195.25,133.23 189.43,127.41 189.43,123.07 191.42,121.07 191.42,116.82 190.74,116.13 190.74,109.26 188.64,107.17 188.64,96.8 187.48,95.65 187.48,91.23 190.88,87.84 190.88,85.67 189.35,84.14 189.35,75.77 187.64,74.05 185.95,74.05 184.91,73 184.08,73 v2(183.91,72.83) ; RP16.7 142.12,74.99 v2(142.04,75.07) ; v2(129.13,60.31) 128.87,60.31 127.43,58.86 103.72,58.86 101,56.14 101,52.88 100.1,51.98 98.41,51.98 97.05,50.62 97.05,50.51 97.21,50.34 JDIMM1.202 97.21,48.23 97.07,48.09 97.07,47.23 98.45,45.86 98.45,39.77 97.01,38.33 97.01,37.7 97.21,37.5 JDIMM2.202 ; v2(139.56,76.73) 139.52,76.69 Q11.1
SMB_DATA_S3: length 203.4
  IN2 w0.127: v2(183.91,73.41) 183.77,73.28 180.49,73.28 179.89,72.68 175.98,72.68 175.53,72.23 173.89,72.23 173.33,71.68 164.42,71.68 163.62,72.48 161.53,72.48 160.59,71.54 157.54,71.54 153.1,67.09 151.73,67.09 142.89,75.93 141.59,75.93 141.14,75.49 141.14,74.91 141.46,74.6 141.93,74.6 v2(142.05,74.49) 142.18,74.62 142.43,74.62 142.79,74.26 142.79,72.84 141.77,71.82 139.97,71.82 128.88,60.72 v2(128.71,60.72)
  BOTTOM w0.102: v2(183.91,73.41) 184.08,73.23 184.81,73.23 185.86,74.28 187.54,74.28 189.12,75.86 189.12,84.24 190.65,85.76 190.65,87.74 187.26,91.13 187.26,95.74 188.41,96.9 188.41,107.26 190.51,109.36 190.51,116.23 191.19,116.91 191.19,120.98 189.2,122.97 189.2,127.51 195.16,133.46 196.74,133.46 196.96,133.68 196.96,134.12 R502.2 ; JDIMM2.200 96.61,37.49 96.78,37.66 96.78,38.43 98.22,39.86 98.22,45.76 98.15,45.83 96.84,47.13 96.84,48.09 96.61,48.32 JDIMM1.200 96.61,50.28 96.82,50.48 96.82,50.71 98.31,52.21 100,52.21 100.77,52.97 100.77,56.24 103.62,59.09 127.33,59.09 128.71,60.47 v2(128.71,60.72) ; RP16.6 v2(142.05,74.49) 141.87,74.66 140.95,74.66 140.82,74.53 Q11.4
SML1CLK: length 26.1
  TOP w0.089: 131.51,92.19 v2(131.69,92.02)
  TOP w0.102: v2(142.82,95.67) 143.15,95.67 143.33,95.84 Q130.6 ; U4.K6 131.51,92.19 ; v2(146.06,96.43) 146.44,96.8 147.25,96.8 147.32,96.74 147.34,96.72 RP17.5
  IN2 w0.089: 136.76,91.34 136.67,91.25 134.81,91.25 133.43,89.88 131.62,89.88 131.29,90.2 131.29,91.62 v2(131.69,92.02)
  IN2 w0.127: v2(146.06,96.43) 143.12,96.43 142.82,96.12 v2(142.82,95.67) 143.57,95.67 143.84,95.39 143.84,94.35 143.38,93.89 141.04,93.89 138.49,91.34 136.76,91.34
SML1DATA: length 26.8
  TOP w0.102: v2(145.14,95.66) 144.75,95.66 144.63,95.54 Q130.3 ; v2(130.66,90.12) 130.35,89.81 U4.N11 ; v2(146.03,97.01) 146.05,97.03 147.69,97.03 147.84,96.89 RP17.6
  IN2 w0.089: v2(130.66,90.12) 130.27,89.73 130.27,89.34 130.5,89.11 134.13,89.11 134.54,89.52 134.54,90.57 135.02,91.04 136.61,91.04 136.63,91.02 136.73,91.02 136.75,91.01 136.76,91.01
  IN2 w0.127: 136.76,91.01 138.62,91.01 141.18,93.56 143.52,93.56 144.17,94.21 144.17,95.48 144.35,95.66 v2(145.14,95.66) 145.95,95.66 146.48,96.19 146.48,96.69 146.16,97.01 v2(146.03,97.01)
SNB_0.95V: length 0.7
  BOTTOM w0.102: 172.87,125.37 v1(172.87,126.06)
SNB_1.5V:
  vias: v1(205.37,8.67)
SNUB1_VGA: length 0.8
  TOP w0.102: v1(172.03,148.05) 171.67,148.41 171.33,148.41
SNUB2_VGA: length 1.5
  TOP w0.102: PC811.1 169.57,133.72 v1(170.11,133.18)
SNUB_CPU1: length 0.8
  BOTTOM w0.102: 29.24,117.32 v1(29.24,118.08)
SNUB_CPU2: length 0.7
  BOTTOM w0.102: 36.79,95.77 v1(36.79,95.09)
SNUB_CPU3: length 0.9
  TOP w0.102: v1(16.3,97.2) 17.18,97.2
SPI_CLK_PCH: length 14.7
  TOP w0.102: v2(107.87,96.58) v3(107.87,97.34) 108.19,97.66 108.19,100.25 v2(108.76,100.82)
  BOTTOM w0.102: RP2.3 107.42,91.56 106.31,92.67 U8.6 106.31,95.02 v2(107.87,96.58) ; R240.1 108.97,100.82 v2(108.76,100.82)
SPI_CLK_PCH_R: length 48.1
  TOP w0.102: U4.AJ11 123.74,89.6 123.61,89.47 123.17,89.47 123.05,89.6 123.05,89.78 123.17,89.9 123.34,89.9 123.46,90.02 123.46,90.19 123.34,90.31 123.18,90.31 123.05,90.43 123.05,90.62 123.18,90.75 v2(123.25,90.75)
  BOTTOM w0.089: 123.1,94.79 123.1,94.77 123.23,94.64 123.39,94.64 123.52,94.51 123.52,94.32 123.39,94.19 123.1,94.19 122.97,94.07 122.97,93.88 123.1,93.75 123.6,93.75 123.72,93.63 123.72,93.46 123.6,93.34 123.18,93.34 123.07,93.23 123.07,93.08 123.18,92.97 123.89,92.97 124.02,92.85 124.02,92.68 123.89,92.55 123.59,92.55 123.48,92.45 123.48,92.29 123.59,92.18 123.74,92.18 123.87,92.05 123.87,90.44 123.74,90.31 122.95,90.31 122.82,90.44 122.82,90.89 122.95,91.01 123.13,91.01 123.25,90.89 v2(123.25,90.75)
  BOTTOM w0.102: R240.2 R237.1 110.46,102.5 110.33,102.63 109.52,102.63 109.4,102.75 109.4,102.98 109.52,103.11 110.34,103.11 110.46,103.24 110.46,104.05 110.59,104.18 110.84,104.18 110.97,104.05 110.97,103.54 111.09,103.42 111.35,103.42 111.48,103.54 111.48,104.11 111.6,104.24 v1(114.09,104.24) 116.93,104.24 117.03,104.14 117.03,103.82 117.13,103.72 117.33,103.72 117.43,103.82 117.43,104.14 117.54,104.24 117.74,104.24 117.84,104.14 117.84,103.82 117.94,103.72 118.14,103.72 118.25,103.82 118.25,104.14 118.35,104.24 118.55,104.24 118.65,104.14 118.65,103.82 118.75,103.72 118.96,103.72 119.06,103.82 119.06,104.14 119.16,104.24 119.36,104.24 119.47,104.14 119.47,103.73 119.59,103.6 119.77,103.6 119.9,103.73 119.9,104.11 120.02,104.24 120.21,104.24 120.34,104.11 120.34,103.82 120.47,103.69 122.02,103.69 122.74,102.97 123.65,102.97 123.77,102.85 123.77,102.68 123.65,102.56 122.77,102.56 122.65,102.44 122.65,102.27 122.77,102.15 123.33,102.15 123.45,102.03 123.45,101.87 123.33,101.75 122.77,101.75 122.65,101.63 122.65,101.46 122.77,101.34 122.94,101.34 123.06,101.22 123.06,101.05 122.94,100.93 122.77,100.93 122.65,100.82 122.65,100.66 122.77,100.54 122.87,100.54 122.99,100.42 122.99,100.26 122.87,100.14 122.78,100.14 122.65,100.01 122.65,99.77 122.78,99.65 122.87,99.65 122.96,99.57 122.96,97.36 123.41,96.9 123.41,95.46 123.1,95.15 123.1,94.79
