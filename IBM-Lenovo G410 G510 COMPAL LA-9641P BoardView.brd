# Allegro board IBM-Lenovo G410 G510 COMPAL LA-9641P BoardView.brd (continued)
## Nets (continued)
DDR_A_D56: JCPU1.E12 JDIMM1.181
DDR_A_D57: JCPU1.D12 JDIMM1.183
DDR_A_D58: JCPU1.B11 JDIMM1.191
DDR_A_D59: JCPU1.A11 JDIMM1.193
DDR_A_D60: JCPU1.E11 JDIMM1.180
DDR_A_D61: JCPU1.D11 JDIMM1.182
DDR_A_D62: JCPU1.B12 JDIMM1.192
DDR_A_D63: JCPU1.A12 JDIMM1.194
DDR_A_DQS0: JCPU1.AP14 JDIMM1.12
DDR_A_DQS1: JCPU1.AP9 JDIMM1.29
DDR_A_DQS2: JCPU1.AK8 JDIMM1.47
DDR_A_DQS3: JCPU1.AG3 JDIMM1.64
DDR_A_DQS4: JCPU1.H3 JDIMM1.137
DDR_A_DQS5: JCPU1.E3 JDIMM1.154
DDR_A_DQS6: JCPU1.C6 JDIMM1.171
DDR_A_DQS7: JCPU1.C12 JDIMM1.188
DDR_A_DQS#0: JCPU1.AP15 JDIMM1.10
DDR_A_DQS#1: JCPU1.AP8 JDIMM1.27
DDR_A_DQS#2: JCPU1.AJ8 JDIMM1.45
DDR_A_DQS#3: JCPU1.AF3 JDIMM1.62
DDR_A_DQS#4: JCPU1.J3 JDIMM1.135
DDR_A_DQS#5: JCPU1.E2 JDIMM1.152
DDR_A_DQS#6: JCPU1.C5 JDIMM1.169
DDR_A_DQS#7: JCPU1.C11 JDIMM1.186
DDR_A_MA0: JCPU1.V8 JDIMM1.98
DDR_A_MA1: JCPU1.AC6 JDIMM1.97
DDR_A_MA2: JCPU1.V9 JDIMM1.96
DDR_A_MA3: JCPU1.U9 JDIMM1.95
DDR_A_MA4: JCPU1.AC5 JDIMM1.92
DDR_A_MA5: JCPU1.AC4 JDIMM1.91
DDR_A_MA6: JCPU1.AD6 JDIMM1.90
DDR_A_MA7: JCPU1.AC3 JDIMM1.86
DDR_A_MA8: JCPU1.AD5 JDIMM1.89
DDR_A_MA9: JCPU1.AC2 JDIMM1.85
DDR_A_MA10: JCPU1.V6 JDIMM1.107
DDR_A_MA11: JCPU1.AC1 JDIMM1.84
DDR_A_MA12: JCPU1.AD4 JDIMM1.83
DDR_A_MA13: JCPU1.V7 JDIMM1.119
DDR_A_MA14: JCPU1.AD3 JDIMM1.80
DDR_A_MA15: JCPU1.AD2 JDIMM1.78
DDR_A_RAS#: JCPU1.U6 JDIMM1.110
DDR_A_WE#: JCPU1.U7 JDIMM1.113
DDR_B_BS0: JCPU1.R7 JDIMM2.109
DDR_B_BS1: JCPU1.P8 JDIMM2.108
DDR_B_BS2: JCPU1.AA9 JDIMM2.79
DDR_B_CAS#: JCPU1.P7 JDIMM2.115
DDR_B_D0: JCPU1.AR18 JDIMM2.5
DDR_B_D1: JCPU1.AT18 JDIMM2.7
DDR_B_D2: JCPU1.AM17 JDIMM2.15
DDR_B_D3: JCPU1.AM18 JDIMM2.17
DDR_B_D4: JCPU1.AR17 JDIMM2.4
DDR_B_D5: JCPU1.AT17 JDIMM2.6
DDR_B_D6: JCPU1.AN17 JDIMM2.16
DDR_B_D7: JCPU1.AN18 JDIMM2.18
DDR_B_D8: JCPU1.AT12 JDIMM2.21
DDR_B_D9: JCPU1.AR12 JDIMM2.23
DDR_B_D10: JCPU1.AN12 JDIMM2.33
DDR_B_D11: JCPU1.AM11 JDIMM2.35
DDR_B_D12: JCPU1.AT11 JDIMM2.22
DDR_B_D13: JCPU1.AR11 JDIMM2.24
DDR_B_D14: JCPU1.AM12 JDIMM2.34
DDR_B_D15: JCPU1.AN11 JDIMM2.36
DDR_B_D16: JCPU1.AR5 JDIMM2.39
DDR_B_D17: JCPU1.AR6 JDIMM2.41
DDR_B_D18: JCPU1.AM5 JDIMM2.51
DDR_B_D19: JCPU1.AM6 JDIMM2.53
DDR_B_D20: JCPU1.AT5 JDIMM2.40
DDR_B_D21: JCPU1.AT6 JDIMM2.42
DDR_B_D22: JCPU1.AN5 JDIMM2.50
DDR_B_D23: JCPU1.AN6 JDIMM2.52
DDR_B_D24: JCPU1.AJ4 JDIMM2.57
DDR_B_D25: JCPU1.AK4 JDIMM2.59
DDR_B_D26: JCPU1.AJ1 JDIMM2.67
DDR_B_D27: JCPU1.AJ2 JDIMM2.69
DDR_B_D28: JCPU1.AM1 JDIMM2.56
DDR_B_D29: JCPU1.AN1 JDIMM2.58
DDR_B_D30: JCPU1.AK2 JDIMM2.68
DDR_B_D31: JCPU1.AK1 JDIMM2.70
DDR_B_D32: JCPU1.L2 JDIMM2.129
DDR_B_D33: JCPU1.M2 JDIMM2.131
DDR_B_D34: JCPU1.L4 JDIMM2.141
DDR_B_D35: JCPU1.M4 JDIMM2.143
DDR_B_D36: JCPU1.L1 JDIMM2.130
DDR_B_D37: JCPU1.M1 JDIMM2.132
DDR_B_D38: JCPU1.L5 JDIMM2.140
DDR_B_D39: JCPU1.M5 JDIMM2.142
DDR_B_D40: JCPU1.G7 JDIMM2.147
DDR_B_D41: JCPU1.J8 JDIMM2.149
DDR_B_D42: JCPU1.G8 JDIMM2.157
DDR_B_D43: JCPU1.G9 JDIMM2.159
DDR_B_D44: JCPU1.J7 JDIMM2.146
DDR_B_D45: JCPU1.J9 JDIMM2.148
DDR_B_D46: JCPU1.G10 JDIMM2.158
DDR_B_D47: JCPU1.J10 JDIMM2.160
DDR_B_D48: JCPU1.A8 JDIMM2.163
DDR_B_D49: JCPU1.B8 JDIMM2.165
DDR_B_D50: JCPU1.A9 JDIMM2.175
DDR_B_D51: JCPU1.B9 JDIMM2.177
DDR_B_D52: JCPU1.D8 JDIMM2.164
DDR_B_D53: JCPU1.E8 JDIMM2.166
DDR_B_D54: JCPU1.D9 JDIMM2.174
DDR_B_D55: JCPU1.E9 JDIMM2.176
DDR_B_D56: JCPU1.E15 JDIMM2.181
DDR_B_D57: JCPU1.D15 JDIMM2.183
DDR_B_D58: JCPU1.A15 JDIMM2.191
DDR_B_D59: JCPU1.B15 JDIMM2.193
DDR_B_D60: JCPU1.E14 JDIMM2.180
DDR_B_D61: JCPU1.D14 JDIMM2.182
DDR_B_D62: JCPU1.A14 JDIMM2.192
DDR_B_D63: JCPU1.B14 JDIMM2.194
DDR_B_DQS0: JCPU1.AP17 JDIMM2.12
DDR_B_DQS1: JCPU1.AP12 JDIMM2.29
DDR_B_DQS2: JCPU1.AP6 JDIMM2.47
DDR_B_DQS3: JCPU1.AK3 JDIMM2.64
DDR_B_DQS4: JCPU1.M3 JDIMM2.137
DDR_B_DQS5: JCPU1.H8 JDIMM2.154
DDR_B_DQS6: JCPU1.C9 JDIMM2.171
DDR_B_DQS7: JCPU1.C15 JDIMM2.188
DDR_B_DQS#0: JCPU1.AP18 JDIMM2.10
DDR_B_DQS#1: JCPU1.AP11 JDIMM2.27
DDR_B_DQS#2: JCPU1.AP5 JDIMM2.45
DDR_B_DQS#3: JCPU1.AJ3 JDIMM2.62
DDR_B_DQS#4: JCPU1.L3 JDIMM2.135
DDR_B_DQS#5: JCPU1.H9 JDIMM2.152
DDR_B_DQS#6: JCPU1.C8 JDIMM2.169
DDR_B_DQS#7: JCPU1.C14 JDIMM2.186
DDR_B_MA0: JCPU1.R8 JDIMM2.98
DDR_B_MA1: JCPU1.Y5 JDIMM2.97
DDR_B_MA2: JCPU1.Y10 JDIMM2.96
DDR_B_MA3: JCPU1.AA5 JDIMM2.95
DDR_B_MA4: JCPU1.Y7 JDIMM2.92
DDR_B_MA5: JCPU1.AA6 JDIMM2.91
DDR_B_MA6: JCPU1.Y6 JDIMM2.90
DDR_B_MA7: JCPU1.AA7 JDIMM2.86
DDR_B_MA8: JCPU1.Y8 JDIMM2.89
DDR_B_MA9: JCPU1.AA10 JDIMM2.85
DDR_B_MA10: JCPU1.R9 JDIMM2.107
DDR_B_MA11: JCPU1.Y9 JDIMM2.84
DDR_B_MA12: JCPU1.AF7 JDIMM2.83
DDR_B_MA13: JCPU1.P9 JDIMM2.119
DDR_B_MA14: JCPU1.AA8 JDIMM2.80
DDR_B_MA15: JCPU1.AG7 JDIMM2.78
DDR_B_RAS#: JCPU1.R6 JDIMM2.110
DDR_B_WE#: JCPU1.P6 JDIMM2.113
DDR_CKE0_DIMMA: JCPU1.AD9 JDIMM1.73
DDR_CKE1_DIMMA: JCPU1.AC9 JDIMM1.74
DDR_CKE2_DIMMB: JCPU1.AF10 JDIMM2.73
DDR_CKE3_DIMMB: JCPU1.AG10 JDIMM2.74
DDR_CS0_DIMMA#: JCPU1.M7 JDIMM1.114
DDR_CS1_DIMMA#: JCPU1.L9 JDIMM1.121
DDR_CS2_DIMMB#: JCPU1.P4 JDIMM2.114
DDR_CS3_DIMMB#: JCPU1.R2 JDIMM2.121
DGPU_HOLD_RST#: R167.2 R168.2 U4.A12 UV2.2
DGPU_PWR_EN: PD601.1 PR612.1 PR626.2 PR813.1 QV6.2 QV9.2 RP13.8 U4.C12 U31.123
DGPU_PWR_EN#: QV1.2 QV2.2 QV7.2 QV9.1 RV35.2
DGPU_PWROK: PR832.1 R259.2 U4.C14
DH_1.05VSP: PQ701.4 PU701.11
DH_CHG: PQ309.4 PR326.2
DH_CHG-1: PR326.1 PU301.18
DISCHG_G: PQ312.4 PR321.2 PR322.1
DISCHG_G-1: PQ311.1 PR321.1
DL_1.05VSP: PQ702.4 PU701.10
DL_CHG: PQ310.4 PU301.15
DMI_CRX_PTX_N0: JCPU1.D21 U4.BD21
DMI_CRX_PTX_N1: JCPU1.C21 U4.BE20
DMI_CRX_PTX_N2: JCPU1.B21 U4.BD17
DMI_CRX_PTX_N3: JCPU1.A21 U4.BE18
DMI_CRX_PTX_P0: JCPU1.D20 U4.BB21
DMI_CRX_PTX_P1: JCPU1.C20 U4.BC20
DMI_CRX_PTX_P2: JCPU1.B20 U4.BB17
DMI_CRX_PTX_P3: JCPU1.A20 U4.BC18
DMI_CTX_PRX_N0: JCPU1.D18 U4.AW22
DMI_CTX_PRX_N1: JCPU1.C17 U4.AR20
DMI_CTX_PRX_N2: JCPU1.B17 U4.AP17
DMI_CTX_PRX_N3: JCPU1.A17 U4.AV20
DMI_CTX_PRX_P0: JCPU1.D17 U4.AY22
DMI_CTX_PRX_P1: JCPU1.C18 U4.AP20
DMI_CTX_PRX_P2: JCPU1.B18 U4.AR17
DMI_CTX_PRX_P3: JCPU1.A18 U4.AW20
DMI_RCOMP: R135.2 U4.AY17
DPRSLPVR_VGA-1: PR816.2 PR818.2 PR819.2 PU801.39
DPWROK_EC: R149.2 U31.71
DQMA0: UV1.A32 UV5.D3
DQMA1: UV1.C32 UV6.D3
DQMA2: UV1.D23 UV5.E7
DQMA3: UV1.E22 UV6.E7
DQMA4: UV1.C14 UV7.E7
DQMA5: UV1.A14 UV7.D3
DQMA6: UV1.E10 UV8.E7
DQMA7: UV1.D9 UV8.D3
DQMB0: UV1.H3 UV9.D3
DQMB1: UV1.H1 UV10.D3
DQMB2: UV1.T3 UV9.E7
DQMB3: UV1.T5 UV10.E7
DQMB4: UV1.AE4 UV11.E7
DQMB5: UV1.AF5 UV11.D3
DQMB6: UV1.AK6 UV12.E7
DQMB7: UV1.AK5 UV12.D3
DRAM_RST#: RV53.1 UV5.T2 UV6.T2 UV7.T2 UV8.T2 UV9.T2 UV10.T2 UV11.T2 UV12.T2
DRAM_RST#_R: RV54.2 RV57.2 UV1.AH11
DRON: PR935.2 PU901.21
DS3_EN: Q120.2 Q124.2 R34.2 R38.2 R781.1
DSWODVREN: R134.2 R143.1 U4.C8
EC_FAN_PWM: JFAN1.3 U31.26
EC_LID_OUT#: R253.2 U4.AB11 U31.101
EC_MUTE#: R593.1 U31.83 UA1.39
EC_ON: PR407.2 U31.112
EC_RSMRST#: R139.2 R312.1 U4.J2 U31.100
EC_RST#: C661.2 R590.2 U31.37
EC_RX: JP3.3 R506.1 U31.31
EC_SCI#: R261.2 U4.G15 U31.20
EC_SMB_CK1: PR204.2 PU301.9 R600.2 U31.77
EC_SMB_CK2: Q130.1 QV3.6 RP17.8 U9.8 U31.79 UT2.9
EC_SMB_DA1: PR201.2 PU301.8 R604.2 U31.78
EC_SMB_DA2: Q130.4 QV3.3 RP17.7 U9.7 U31.80 UT2.10
EC_SMCA: JBATT1.3 JBATT2.3 PR204.1
EC_SMDA: JBATT1.4 JBATT2.4 PR201.1
EC_SMI#: R247.2 U4.Y1 U31.15
EC_SPI_CLK: RP2.6 U31.126
EC_SPI_CS#: RP2.5 U31.128
EC_SPI_SI: RP2.7 U31.120
EC_SPI_SO: RP2.8 U31.119
EC_TACH: JFAN1.2 R605.2 U31.28
EC_TS_ON#: R722.1 R5581.1 U31.97
EC_TX: JP3.2 R505.1 U31.30
EC_VGA_EN: PR820.1 U31.18
ECAGND: C656.2 C659.2 L45.2 PQ206.3 PQ207.3 PQ208.3 PR225.1 PR228.2 U31.69
EDID_CLK: JLVDS1.20 RT10.1 UT2.29
EDID_DATA: JLVDS1.19 RT9.1 UT2.28
EDP_COMP: JCPU1.E24 R60.2
EDP_CPU_AUX: C190.1 JCPU1.N27
EDP_CPU_AUX#: C191.1 JCPU1.M27
EDP_CPU_AUX#_R: C191.2 UT2.1
EDP_CPU_AUX_R: C190.2 UT2.2
EDP_CPU_LANE_N0: C193.1 JCPU1.P35
EDP_CPU_LANE_N0_R: C193.2 UT2.6
EDP_CPU_LANE_N1: JCPU1.N34
EDP_CPU_LANE_P0: C192.1 JCPU1.R35
EDP_CPU_LANE_P0_R: C192.2 UT2.5
EDP_CPU_LANE_P1: JCPU1.P34
EDP_HPD#: JCPU1.P27 Q6.1 RC1.1
EN_VCORE2: PR935.1 PU902.3
ENBKL: R438.2 U31.76 UT2.17
ENLDO_3V5V: PC407.1 PR402.2 PR403.1 PR411.1 PR412.2 PR415.1
ENLDO_3V5V_1: PC419.1 PR412.1 PU402.3
EXT_MIC: CA41.1 CA42.1 CA44.1 MIC1.1 RA23.2
FB1_VGA: PC874.1 PR842.2
FB2_VGA: PC848.2 PR846.1
FB_VGA: PC847.2 PR842.1 PR843.1 PR846.2 PR849.1 PU801.8
FDI_CSYNC: JCPU1.H29 U4.AL39
FDI_CTX_PRX_N0: JCPU1.P33 U4.AJ35
FDI_CTX_PRX_N1: JCPU1.N32 U4.AL35
FDI_CTX_PRX_P0: JCPU1.R33 U4.AJ36
FDI_CTX_PRX_P1: JCPU1.P32 U4.AL36
FDI_INT: JCPU1.J29 U4.AL40
FDI_RCOMP: R145.1 U4.AR44
GATEA20: RP15.8 U4.AN10 U31.1
GENLK_CLK: T1.1(TP-1) UV1.AD29
GENLK_VSYNC: T2.1(TP-1) UV1.AC29
GPIO_28_FDO: RV26.2 RV31.2 UV1.AK32
GPU_GPIO0: PR818.1 PR834.1 UV1.AH20
GPU_GPIO5: DV1.2 RV5.2 UV1.AH17
GPU_IMON: PC849.1 PR844.1 PR847.2 PU801.18 U31.64
GPU_RST#: RV4.1 UV1.AA30 UV2.4
GPU_VID0: PR806.1 PR812.1 PU801.31
GPU_VID1: PR805.1 PR811.1 PU801.32 UV1.AM13
GPU_VID2: PR804.1 PR810.1 PU801.33 UV1.AL13
GPU_VID3: PR803.1 PR809.1 PU801.34 UV1.AG32
GPU_VID4: PR802.1 PR808.1 PU801.35 UV1.AG33
GPU_VID5: PR801.1 PR807.1 PU801.36 UV1.AJ17
GPU_VID6: PR814.1 PU801.37
GREEN: C526.1 JCRT1.2 L31.2 U10.4
H_CATERR#: JCPU1.AN32 T31.1(TP-1)
H_CPU_RSVD: JCPU1.G26 R66.2
H_CPU_SVIDALRT#: JCPU1.AM28 R83.2
H_CPU_TESTLO: JCPU1.W34 R64.2
H_CPUPWRGD: C536.1 JCPU1.AL34 R15.2 U4.AV3
H_DRAMRST#: JCPU1.AN3 R46.1
H_PECI: JCPU1.AR27 R255.2 R669.2
H_PM_SYNC: R10.1 U4.AY3
H_PM_SYNC_R: JCPU1.AT28 R10.2
H_PROCHOT#: C493.1 PQ101.3 PQ101.6 PQ201.1 PR915.1 Q37.1 R8.2 R9.1
H_PROCHOT#_R: JCPU1.AM30 R9.2
H_THRMTRIP#: JCPU1.AM35 R262.2
HDA_BIT_CLK: RP12.1 U4.B25
HDA_BITCLK_AUDIO: RA21.2 RP12.8 UA1.5
HDA_RST#: RP12.3 U4.C24
HDA_RST_AUDIO#: CA11.1 RA15.2 RP12.6 UA1.9
HDA_SDIN0: RA9.1 U4.L22
HDA_SDOUT_AUDIO: RP12.5 UA1.4
HDA_SPKR: CA45.1 R102.2 U4.AL10
HDA_SYNC: R100.1 RP12.2 U4.A22
HDA_SYNC_AUDIO: RP12.7 UA1.8
HDD_DET#: RP15.4 U4.AT1
HDMI_CLK+_CK: C47.1 L35.1
HDMI_CLK+_CONN: D28.4 D28.7 JHDMI1.10 L35.2 RP5.7
HDMI_CLK-_CK: C46.1 L35.4
HDMI_CLK-_CONN: D28.5 D28.6 JHDMI1.12 L35.3 RP5.8
HDMI_DET: D32.4 D32.7 JHDMI1.19 Q93.1 R488.2
HDMI_TX0+_CK: C45.1 L36.1
HDMI_TX0+_CONN: D29.1 D29.9 JHDMI1.7 L36.2 RP6.5
HDMI_TX0-_CK: C44.1 L36.4
HDMI_TX0-_CONN: D29.2 D29.8 JHDMI1.9 L36.3 RP6.6
HDMI_TX1+_CK: C43.1 L37.1
HDMI_TX1+_CONN: D28.1 D28.9 JHDMI1.4 L37.2 RP5.5
HDMI_TX1-_CK: C42.1 L37.4
HDMI_TX1-_CONN: D28.2 D28.8 JHDMI1.6 L37.3 RP5.6
HDMI_TX2+_CK: C41.1 L38.1
HDMI_TX2+_CONN: D29.4 D29.7 JHDMI1.1 L38.2 RP6.7
HDMI_TX2-_CK: C48.1 L38.4
HDMI_TX2-_CONN: D29.5 D29.6 JHDMI1.3 L38.3 RP6.8
HDMICLK_NB: Q63.1 RP21.4 U4.R40
HDMICLK_R: D32.1 D32.9 JHDMI1.15 Q63.6 RP21.2
HDMIDAT_NB: Q63.4 RP21.3 U4.R39
HDMIDAT_R: D32.2 D32.8 JHDMI1.16 Q63.3 RP21.1
HG1: PQ901.4 PU901.11
HG2: PQ903.4 PU902.8
HG3: PQ905.4 PU901.18
HGNDA: CA27.2 CA31.1 DA1.3 JHP1.3 UA1.25
HGNDB: CA28.2 CA32.1 DA1.2 JHP1.4 UA1.26
HP_L: CA36.2 RA13.1 RA20.2 UA1.22
HP_R: CA46.2 RA14.1 RA19.2 UA1.23
HPOUT_L: CA34.1 DA2.2 JHP1.1 RA13.2
HPOUT_R: CA33.1 DA2.3 JHP1.2 RA14.2
HSYNC: T4.1(TP-1) UV1.AC36
ILMT_0.95V: PR609.1 PR618.2 PU604.3
ILMT_1.5V: PR604.2 PR605.1 PU601.3
IMVP_IMON: PC908.1 PR912.2 PU901.29 U31.73
INTEL_BT_OFF#: R405.1 RP15.7 U4.AN6
INVT_PWM: JLVDS1.8 R441.2
ISEN1_VGA: PC875.1 PR857.2 PR864.2 PU801.11
ISEN2_VGA: PC850.1 PR828.2 PR863.1 PR864.1 PU801.10
ISEN3_VGA: PC871.2 PU801.9
ISUM-_VGA: PC864.2 PR862.1 PU801.14
JSENSE: RA5.1 RA6.1 RA7.1 RA8.1 UA1.38
JTAG_TCK: UV1.AK23
JTAG_TDI: UV1.AN23
JTAG_TDO: UV1.AM24
JTAG_TMS: UV1.AL24
JTAG_TRSTB: UV1.AM23
JVGA_HS: R412.1 U10.16
JVGA_HS_R: C412.1 JCRT1.13 R412.2
JVGA_VS: R411.1 U10.14
JVGA_VS_R: C411.1 JCRT1.14 R411.2
KBRST#: RP15.9 U4.AT6 U31.2
KSI0: JKB1.12 JKB2.13 U31.55
KSI1: JKB1.1 JKB2.24 U31.56
KSI2: JKB1.8 JKB2.17 U31.57
KSI3: JKB1.9 JKB2.16 U31.58
KSI4: JKB1.5 JKB2.20 U31.59
KSI5: JKB1.6 JKB2.19 U31.60
KSI6: JKB1.3 JKB2.22 U31.61
KSI7: JKB1.2 JKB2.23 U31.62
KSO0: JKB1.7 JKB2.18 U31.39
KSO1: JKB1.11 JKB2.14 U31.40
KSO2: JKB1.13 JKB2.12 U31.41
KSO3: JKB1.18 JKB2.7 U31.42
KSO4: JKB1.14 JKB2.11 U31.43
KSO5: JKB1.10 JKB2.15 U31.44
KSO6: JKB1.17 JKB2.8 U31.45
KSO7: JKB1.15 JKB2.10 U31.46
KSO8: JKB1.16 JKB2.9 U31.47
KSO9: JKB1.4 JKB2.21 U31.48
KSO10: JKB1.23 JKB2.2 U31.49
KSO11: JKB1.22 JKB2.3 U31.50
KSO12: JKB1.19 JKB2.6 U31.51
KSO13: JKB1.20 JKB2.5 U31.52
KSO14: JKB1.21 JKB2.4 U31.53
KSO15: JKB1.24 JKB2.1 U31.54
KSO16: JKB1.25 U31.81
KSO17: JKB1.26 U31.82
LAN_PWR_ON#: RL3.2 U31.89
LAN_RBIAS: RL8.1 UL1.10
LAN_WAKE#: R606.1 RL7.1 U31.29
LAN_XTALI: CL28.1 UL1.8 YL1.1
LAN_XTALO: CL29.1 UL1.7 YL1.3
LF1_VGA: PL803.2 PR856.1 PR857.1
LF2_VGA: PL802.2 PR827.1 PR828.1
LG1: PQ902.4 PU901.13
LG2: PQ904.4 PU902.5
LG3: PQ906.4 PU901.16
LG_1.35V: PQ502.4 PU501.15
LGATE1_VGA: PQ802.4 PU801.23
LGATE2_VGA: PQ801.4 PU801.26
LID_SW#: JLED1.4 JPWRB1.2 R601.2 U31.115
LPC_AD0: U4.A20 U31.10
LPC_AD1: U4.C20 U31.8
LPC_AD2: U4.A18 U31.7
LPC_AD3: U4.C18 U31.5
LPC_FRAME#: U4.B21 U31.4
LVDS_A0: JLVDS1.17 UT2.25
LVDS_A0#: JLVDS1.18 UT2.26
LVDS_A1: JLVDS1.15 UT2.23
LVDS_A1#: JLVDS1.16 UT2.24
LVDS_A2: JLVDS1.13 UT2.21
LVDS_A2#: JLVDS1.14 UT2.22
LVDS_ACLK: JLVDS1.10 UT2.19
LVDS_ACLK#: JLVDS1.11 UT2.20
LX_0.95V: PC632.2 PL605.1 PR610.1 PU604.10
LX_1.5V: PC602.2 PL601.1 PR603.1 PU601.10
LX_1.05VSP: PC707.2 PL701.1 PQ701.1 PQ701.2 PQ701.3 PQ702.5 PQ702.6 PQ702.7 PQ702.8 PR714.1 PU701.12
LX_1.35V: PC512.2 PL501.2 PQ501.1 PQ501.2 PQ501.3 PQ502.5 PR515.1 PU501.16
LX_3V: PC402.2 PL402.1 PR404.1 PU401.10
LX_5V: PC421.2 PL404.1 PR406.1 PU402.10
LX_CHG: PC317.1 PL302.1 PQ309.1 PQ309.2 PQ309.3 PQ310.5 PQ310.6 PQ310.7 PQ310.8 PR323.1 PU301.19
M_CLK_DDR0: JCPU1.V4 JDIMM1.101
M_CLK_DDR1: JCPU1.V3 JDIMM1.102
M_CLK_DDR2: JCPU1.AA4 JDIMM2.101
M_CLK_DDR3: JCPU1.AA3 JDIMM2.102
M_CLK_DDR#0: JCPU1.U4 JDIMM1.103
M_CLK_DDR#1: JCPU1.U3 JDIMM1.104
M_CLK_DDR#2: JCPU1.Y4 JDIMM2.103
M_CLK_DDR#3: JCPU1.Y3 JDIMM2.104
M_ODT0: JCPU1.M8 JDIMM1.116
M_ODT1: JCPU1.L7 JDIMM1.120
M_ODT2: JCPU1.R4 JDIMM2.116
M_ODT3: JCPU1.R3 JDIMM2.120
MAA0: UV1.G24 UV5.N3 UV6.N3 UV7.N3 UV8.N3
MAA1: UV1.J23 UV5.P7 UV6.P7 UV7.P7 UV8.P7
MAA2: UV1.H24 UV5.P3 UV6.P3 UV7.P3 UV8.P3
MAA3: UV1.J24 UV5.N2 UV6.N2 UV7.N2 UV8.N2
MAA4: UV1.H26 UV5.P8 UV6.P8 UV7.P8 UV8.P8
MAA5: UV1.J26 UV5.P2 UV6.P2 UV7.P2 UV8.P2
MAA6: UV1.H21 UV5.R8 UV6.R8 UV7.R8 UV8.R8
MAA7: UV1.G21 UV5.R2 UV6.R2 UV7.R2 UV8.R2
MAA8: UV1.H19 UV5.T8 UV6.T8 UV7.T8 UV8.T8
MAA9: UV1.H20 UV5.R3 UV6.R3 UV7.R3 UV8.R3
MAA10: UV1.L13 UV5.L7 UV6.L7 UV7.L7 UV8.L7
MAA11: UV1.G16 UV5.R7 UV6.R7 UV7.R7 UV8.R7
MAA12: UV1.J16 UV5.N7 UV6.N7 UV7.N7 UV8.N7
MAA13: UV1.H23 UV5.T3 UV6.T3 UV7.T3 UV8.T3
MAA14: UV1.J19 UV5.T7 UV6.T7 UV7.T7 UV8.T7
MAA15: UV1.M21 UV5.M7 UV6.M7 UV7.M7 UV8.M7
MAB0: UV1.P8 UV9.N3 UV10.N3 UV11.N3 UV12.N3
MAB1: UV1.T9 UV9.P7 UV10.P7 UV11.P7 UV12.P7
MAB2: UV1.P9 UV9.P3 UV10.P3 UV11.P3 UV12.P3
MAB3: UV1.N7 UV9.N2 UV10.N2 UV11.N2 UV12.N2
MAB4: UV1.N8 UV9.P8 UV10.P8 UV11.P8 UV12.P8
MAB5: UV1.N9 UV9.P2 UV10.P2 UV11.P2 UV12.P2
MAB6: UV1.U9 UV9.R8 UV10.R8 UV11.R8 UV12.R8
MAB7: UV1.U8 UV9.R2 UV10.R2 UV11.R2 UV12.R2
MAB8: UV1.Y9 UV9.T8 UV10.T8 UV11.T8 UV12.T8
MAB9: UV1.W9 UV9.R3 UV10.R3 UV11.R3 UV12.R3
MAB10: UV1.AC8 UV9.L7 UV10.L7 UV11.L7 UV12.L7
MAB11: UV1.AC9 UV9.R7 UV10.R7 UV11.R7 UV12.R7
MAB12: UV1.AA7 UV9.N7 UV10.N7 UV11.N7 UV12.N7
MAB13: UV1.T8 UV9.T3 UV10.T3 UV11.T3 UV12.T3
MAB14: UV1.W8 UV9.T7 UV10.T7 UV11.T7 UV12.T7
MAB15: UV1.U12 UV9.M7 UV10.M7 UV11.M7 UV12.M7
MAINPWON: PR408.2 U31.104
MCT: DLL1.2 JLAN1.4 JLAN1.5 JLAN1.7 JLAN1.8 RL14.1 TL1.11 TL1.14
MDA0: UV1.C37 UV5.D7
MDA1: UV1.C35 UV5.C8
MDA2: UV1.A35 UV5.B8
MDA3: UV1.E34 UV5.A7
MDA4: UV1.G32 UV5.A2
MDA5: UV1.D33 UV5.C3
MDA6: UV1.F32 UV5.C2
MDA7: UV1.E32 UV5.A3
MDA8: UV1.D31 UV6.A3
MDA9: UV1.F30 UV6.A2
MDA10: UV1.C30 UV6.C3
MDA11: UV1.A30 UV6.C2
MDA12: UV1.F28 UV6.D7
MDA13: UV1.C28 UV6.A7
MDA14: UV1.A28 UV6.C8
MDA15: UV1.E28 UV6.B8
MDA16: UV1.D27 UV5.H7
MDA17: UV1.F26 UV5.H8
MDA18: UV1.C26 UV5.F8
MDA19: UV1.A26 UV5.F7
MDA20: UV1.F24 UV5.G2
MDA21: UV1.C24 UV5.H3
MDA22: UV1.A24 UV5.F2
MDA23: UV1.E24 UV5.E3
MDA24: UV1.C22 UV6.E3
MDA25: UV1.A22 UV6.H3
MDA26: UV1.F22 UV6.G2
MDA27: UV1.D21 UV6.F2
MDA28: UV1.A20 UV6.H8
MDA29: UV1.F20 UV6.F8
MDA30: UV1.D19 UV6.F7
MDA31: UV1.E18 UV6.H7
MDA32: UV1.C18 UV7.H7
MDA33: UV1.A18 UV7.H8
MDA34: UV1.F18 UV7.F8
MDA35: UV1.D17 UV7.H3
MDA36: UV1.A16 UV7.F7
MDA37: UV1.F16 UV7.G2
MDA38: UV1.D15 UV7.E3
MDA39: UV1.E14 UV7.F2
MDA40: UV1.F14 UV7.C8
MDA41: UV1.D13 UV7.B8
MDA42: UV1.F12 UV7.D7
MDA43: UV1.A12 UV7.A7
MDA44: UV1.D11 UV7.C3
MDA45: UV1.F10 UV7.A2
MDA46: UV1.A10 UV7.C2
MDA47: UV1.C10 UV7.A3
MDA48: UV1.G13 UV8.F2
MDA49: UV1.H13 UV8.E3
MDA50: UV1.J13 UV8.H3
MDA51: UV1.H11 UV8.F7
MDA52: UV1.G10 UV8.F8
MDA53: UV1.G8 UV8.H8
MDA54: UV1.K9 UV8.H7
MDA55: UV1.K10 UV8.G2
MDA56: UV1.G9 UV8.C2
MDA57: UV1.A8 UV8.C3
MDA58: UV1.C8 UV8.A3
MDA59: UV1.E8 UV8.A2
MDA60: UV1.A6 UV8.D7
MDA61: UV1.C6 UV8.A7
MDA62: UV1.E6 UV8.B8
MDA63: UV1.A5 UV8.C8
MDB0: UV1.C5 UV9.D7
MDB1: UV1.C3 UV9.C8
MDB2: UV1.E3 UV9.B8
MDB3: UV1.E1 UV9.A7
MDB4: UV1.F1 UV9.C3
MDB5: UV1.F3 UV9.A3
MDB6: UV1.F5 UV9.C2
MDB7: UV1.G4 UV9.A2
MDB8: UV1.H5 UV10.A3
MDB9: UV1.H6 UV10.A2
MDB10: UV1.J4 UV10.C3
MDB11: UV1.K6 UV10.C2
MDB12: UV1.K5 UV10.A7
MDB13: UV1.L4 UV10.B8
MDB14: UV1.M6 UV10.C8
MDB15: UV1.M1 UV10.D7
MDB16: UV1.M3 UV9.F8
MDB17: UV1.M5 UV9.H8
MDB18: UV1.N4 UV9.H7
MDB19: UV1.P6 UV9.E3
MDB20: UV1.P5 UV9.F7
MDB21: UV1.R4 UV9.G2
MDB22: UV1.T6 UV9.F2
MDB23: UV1.T1 UV9.H3
MDB24: UV1.U4 UV10.F2
MDB25: UV1.V6 UV10.G2
MDB26: UV1.V1 UV10.E3
MDB27: UV1.V3 UV10.H3
MDB28: UV1.Y6 UV10.H8
MDB29: UV1.Y1 UV10.F8
MDB30: UV1.Y3 UV10.F7
MDB31: UV1.Y5 UV10.H7
MDB32: UV1.AA4 UV11.H3
MDB33: UV1.AB6 UV11.E3
MDB34: UV1.AB1 UV11.G2
MDB35: UV1.AB3 UV11.F2
MDB36: UV1.AD6 UV11.H8
MDB37: UV1.AD1 UV11.F7
MDB38: UV1.AD3 UV11.H7
MDB39: UV1.AD5 UV11.F8
MDB40: UV1.AF1 UV11.A2
MDB41: UV1.AF3 UV11.C3
MDB42: UV1.AF6 UV11.A3
MDB43: UV1.AG4 UV11.C2
MDB44: UV1.AH5 UV11.D7
MDB45: UV1.AH6 UV11.A7
MDB46: UV1.AJ4 UV11.B8
MDB47: UV1.AK3 UV11.C8
MDB48: UV1.AF8 UV12.H7
MDB49: UV1.AF9 UV12.H8
MDB50: UV1.AG8 UV12.F7
MDB51: UV1.AG7 UV12.F8
MDB52: UV1.AK9 UV12.G2
MDB53: UV1.AL7 UV12.H3
MDB54: UV1.AM8 UV12.F2
MDB55: UV1.AM7 UV12.E3
MDB56: UV1.AK1 UV12.D7
MDB57: UV1.AL4 UV12.A7
MDB58: UV1.AM6 UV12.B8
MDB59: UV1.AM1 UV12.C3
MDB60: UV1.AN4 UV12.A3
MDB61: UV1.AP3 UV12.A2
MDB62: UV1.AP1 UV12.C2
MDB63: UV1.AP5 UV12.C8
MDI0+: DL1.4 TL1.1 UL1.11
MDI0-: DL1.3 TL1.2 UL1.12
MDI1+: DL1.1 TL1.7 UL1.14
MDI1-: DL1.6 TL1.8 UL1.15
MDO0+: JLAN1.1 TL1.16
MDO0-: JLAN1.2 TL1.15
MDO1+: JLAN1.3 TL1.10
MDO1-: JLAN1.6 TL1.9
ME_FLASH: R105.1 RP12.4 U4.A24 U31.99
MECH#1: TV12.1(TP-1) UV1.A39
MECH#2: TV13.1(TP-1) UV1.AW1
MECH#3: TV14.1(TP-1) UV1.AW39
MIC_IN: CA41.2 UA1.36
MICB_L: RA17.1 UA1.32
MICB_R: RA18.1 UA1.33
MIIC_SCL: RT4.1 UT2.31
MIIC_SDA: RT12.2 UT2.30
NC11: JCRT1.11 T66.1(TP-1)
NOKIA_MIC: RA12.1 UA1.31
NOVO#: D26.2 R628.2 R642.1 R643.1 U31.34
NOVO_BTN#: D24.3 D26.1 JPWRB1.3 R628.1
NTC_V: PH201.1 PR226.2 U31.109
NTC_VGA: PH802.1 PR853.2
NUVOTON_VTT: R595.1 U31.117
ODD_DA#: JODD1.11 JODD2.10 R555.2 U31.19
ODD_DETECT#: JODD1.8 JODD2.7 R710.2
ODD_EN: Q100.2 U4.C16
ODTA0: UV1.J21 UV5.K1 UV6.K1
ODTA1: UV1.G19 UV7.K1 UV8.K1
ODTB0: UV1.T7 UV9.K1 UV10.K1
ODTB1: UV1.W7 UV11.K1 UV12.K1
ON/OFF: D24.2 D26.3 J11.2 J12.2 JPWRB1.4 R701.1 U31.114
P2: PC302.1 PQ301.1 PQ301.2 PQ301.3 PQ302.1 PQ302.2 PQ302.3 PQ304.3 PR304.1 PR319.2
P2-1: PC301.1 PC302.2 PQ301.4 PQ302.4 PQ304.1 PR304.2 PR305.1 PR306.1
P2-2: PQ307.3 PR305.2
P3: PC301.2 PQ302.5 PQ302.6 PQ302.7 PQ302.8 PR301.1
PACIN: PQ308.1 PQ313.2 PR303.1 PR310.2 PR312.1 PR314.1
PBTN_OUT#: U4.K1 U31.106
PC_BEEP: RA492.2 UA1.10
PCH_BT_ON#: JWLN1.5 RP15.1 U4.BB4
PCH_CLK_BIASREF: R214.1 U4.AN44
PCH_DPWROK: R139.1 R149.1 U4.L13
PCH_ENBKL: U4.K36
PCH_ENVDD: U4.G36
PCH_GPI011: R216.2 U4.N7
PCH_GPIO0: RP15.2 U4.AT8
PCH_GPIO1: R248.2 U4.F13
PCH_GPIO2: RP13.7 U4.G17
PCH_GPIO3: RP13.9 U4.F17
PCH_GPIO4: RP13.4 U4.L15
PCH_GPIO5: RP13.3 U4.M15
PCH_GPIO6: R249.2 U4.A14
PCH_GPIO12: R252.2 U4.K13
PCH_GPIO13: R106.2 U4.C22
PCH_GPIO16: R280.1 U4.AN2
PCH_GPIO18: R184.1 U4.AF1
PCH_GPIO24: R273.2 U4.Y10
PCH_GPIO26: RP9.5 U4.V3
PCH_GPIO27: R266.2 R267.2 U4.R11
PCH_GPIO28: R256.2 R260.2 U4.AD11
PCH_GPIO33: R101.2 R104.2 U4.B17
PCH_GPIO35: R265.2 U4.AP1
PCH_GPIO36: R271.2 R275.1 U4.AT3
PCH_GPIO37: R270.2 R274.1 U4.AK1
PCH_GPIO38: R278.2 R283.1 U4.AT7
PCH_GPIO39: R268.2 U4.AM3
PCH_GPIO44: RP9.6 U4.AA2
PCH_GPIO45: RP9.7 U4.AE4
PCH_GPIO46: RP9.8 U4.Y3
PCH_GPIO48: RP15.6 U4.AN4
PCH_GPIO49: R281.1 U4.AK3
PCH_GPIO52: RP13.2 U4.B13
PCH_GPIO53: T21.1(TP-1) U4.A10
PCH_GPIO56: R191.2 U4.U4
PCH_GPIO57: R272.2 U4.U12
PCH_GPIO60: R221.2 U4.N8
PCH_GPIO67: R277.1 R282.2 U4.F39
PCH_GPIO69: R276.1 R279.2 U4.D13
PCH_GPIO70: R287.1 R289.2 U4.G13
PCH_GPIO71: R286.1 R288.2 U4.H15
PCH_GPIO72: RP10.7 U4.K7
PCH_GPIO73: R181.1 U4.AB1
PCH_HOT#: R222.2 U4.H6
PCH_INTVRMEN: R97.2 U4.G10
PCH_JTAG_TCK: R110.1 U4.AB3
PCH_JTAG_TDI: R121.2 R124.1 U4.AE2
PCH_JTAG_TDO: R119.2 R122.1 U4.AD3
PCH_JTAG_TMS: R123.1 R311.2 U4.AD1
PCH_PCIE_RCOMP: R244.2 U4.BD29
PCH_PECI_R: R255.1 U4.AY1
PCH_PWM: U4.N36 UT2.16
PCH_PWR_EN: R38.1 U31.107
PCH_PWROK: R608.1 U4.AB7 U4.F10 U6.2 U31.32
PCH_RTCRST#: C115.1 CLRP3.1 R99.2 U4.D9
PCH_RTCX1: R95.1 R689.1 U4.B5
PCH_RTCX2: C112.1 R95.2 U4.B4 Y1.2
PCH_SMBCLK: Q11.6 RP16.5 U4.R10
PCH_SMBDATA: Q11.3 RP16.8 U4.U11
PCH_SML0CLK: R226.1 U4.U8
PCH_SML0DATA: R227.1 U4.R7
PCH_SRTCRST#: C113.2 CLRP2.2 R98.2 U4.B9
PCH_TD_IREF: R228.1 U4.AY43
PCH_THRMTRIP#_R: R258.1 R262.1 U4.AV1
PCH_WL_OFF#: JWLN1.20 R158.1 R176.1 U4.AL6
PCI_PIRQA#: RP1.8 U4.H20
PCI_PIRQB#: RP1.7 U4.L20
PCI_PIRQC#: RP1.6 U4.K17
PCI_PIRQD#: RP1.5 U4.M20
PCI_PME#: U4.AD10
PCIE_CRX_C_GTX_N0: CV2.1 UV1.Y32
PCIE_CRX_C_GTX_N1: CV4.1 UV1.W32
PCIE_CRX_C_GTX_N2: CV6.1 UV1.U32
PCIE_CRX_C_GTX_N3: CV8.1 UV1.U29
PCIE_CRX_C_GTX_N4: CV10.1 UV1.T32
PCIE_CRX_C_GTX_N5: CV12.1 UV1.T29
PCIE_CRX_C_GTX_N6: CV14.1 UV1.P32
PCIE_CRX_C_GTX_N7: CV16.1 UV1.P29
PCIE_CRX_C_GTX_P0: CV1.1 UV1.Y33
PCIE_CRX_C_GTX_P1: CV3.1 UV1.W33
PCIE_CRX_C_GTX_P2: CV5.1 UV1.U33
PCIE_CRX_C_GTX_P3: CV7.1 UV1.U30
PCIE_CRX_C_GTX_P4: CV9.1 UV1.T33
PCIE_CRX_C_GTX_P5: CV11.1 UV1.T30
PCIE_CRX_C_GTX_P6: CV13.1 UV1.P33
PCIE_CRX_C_GTX_P7: CV15.1 UV1.P30
PCIE_CRX_GTX_N0: CV2.2 JCPU1.E32
PCIE_CRX_GTX_N1: CV4.2 JCPU1.E33
PCIE_CRX_GTX_N2: CV6.2 JCPU1.D34
PCIE_CRX_GTX_N3: CV8.2 JCPU1.E35
PCIE_CRX_GTX_N4: CV10.2 JCPU1.D30
PCIE_CRX_GTX_N5: CV12.2 JCPU1.E31
PCIE_CRX_GTX_N6: CV14.2 JCPU1.D28
PCIE_CRX_GTX_N7: CV16.2 JCPU1.E29
PCIE_CRX_GTX_P0: CV1.2 JCPU1.D32
PCIE_CRX_GTX_P1: CV3.2 JCPU1.F33
PCIE_CRX_GTX_P2: CV5.2 JCPU1.E34
PCIE_CRX_GTX_P3: CV7.2 JCPU1.F35
PCIE_CRX_GTX_P4: CV9.2 JCPU1.E30
PCIE_CRX_GTX_P5: CV11.2 JCPU1.F31
PCIE_CRX_GTX_P6: CV13.2 JCPU1.E28
PCIE_CRX_GTX_P7: CV15.2 JCPU1.F29
PCIE_CTX_GRX_C_N0: C16.1 JCPU1.A24
PCIE_CTX_GRX_C_N1: C15.1 JCPU1.B25
PCIE_CTX_GRX_C_N2: C14.1 JCPU1.A26
PCIE_CTX_GRX_C_N3: C13.1 JCPU1.B27
PCIE_CTX_GRX_C_N4: C12.1 JCPU1.A28
PCIE_CTX_GRX_C_N5: C11.1 JCPU1.B29
PCIE_CTX_GRX_C_N6: C10.1 JCPU1.A30
PCIE_CTX_GRX_C_N7: C9.1 JCPU1.B31
PCIE_CTX_GRX_C_P0: C32.1 JCPU1.B24
PCIE_CTX_GRX_C_P1: C31.1 JCPU1.C25
PCIE_CTX_GRX_C_P2: C30.1 JCPU1.B26
PCIE_CTX_GRX_C_P3: C29.1 JCPU1.C27
PCIE_CTX_GRX_C_P4: C28.1 JCPU1.B28
PCIE_CTX_GRX_C_P5: C27.1 JCPU1.C29
PCIE_CTX_GRX_C_P6: C26.1 JCPU1.B30
PCIE_CTX_GRX_C_P7: C25.1 JCPU1.C31
PCIE_CTX_GRX_N0: C16.2 UV1.Y37
PCIE_CTX_GRX_N1: C15.2 UV1.W36
PCIE_CTX_GRX_N2: C14.2 UV1.V37
PCIE_CTX_GRX_N3: C13.2 UV1.U36
PCIE_CTX_GRX_N4: C12.2 UV1.T37
PCIE_CTX_GRX_N5: C11.2 UV1.R36
PCIE_CTX_GRX_N6: C10.2 UV1.P37
PCIE_CTX_GRX_N7: C9.2 UV1.N36
PCIE_CTX_GRX_P0: C32.2 UV1.AA38
PCIE_CTX_GRX_P1: C31.2 UV1.Y35
PCIE_CTX_GRX_P2: C30.2 UV1.W38
PCIE_CTX_GRX_P3: C29.2 UV1.V35
PCIE_CTX_GRX_P4: C28.2 UV1.U38
PCIE_CTX_GRX_P5: C27.2 UV1.T35
PCIE_CTX_GRX_P6: C26.2 UV1.R38
PCIE_CTX_GRX_P7: C25.2 UV1.P35
PCIE_PRX_C_DTX_N3: CL9.2 UL1.29
PCIE_PRX_C_DTX_P3: CL11.2 UL1.30
PCIE_PRX_DTX_N2: JWLN1.23 U4.AT31
PCIE_PRX_DTX_N3: CL9.1 U4.AW33
PCIE_PRX_DTX_P2: JWLN1.25 U4.AR31
PCIE_PRX_DTX_P3: CL11.1 U4.AY33
PCIE_PTX_C_DRX_N2: C125.1 JWLN1.31
PCIE_PTX_C_DRX_N3: C122.1 UL1.36
PCIE_PTX_C_DRX_P2: C123.1 JWLN1.33
PCIE_PTX_C_DRX_P3: C124.1 UL1.35
PCIE_PTX_DRX_N2: C125.2 U4.BD33
PCIE_PTX_DRX_N3: C122.2 U4.BE34
PCIE_PTX_DRX_P2: C123.2 U4.BB33
PCIE_PTX_DRX_P3: C124.2 U4.BC34
PCIE_WAKE#: R41.1 RL6.1 RP10.6 U4.K3
PECI_KB9012: R669.1 U31.118
PEG_CLKREQ#_R: R177.2 R178.1 U4.AF6
PEG_RCOMP: JCPU1.E23 R1.2
PHASE1_VGA: PC858.2 PQ802.3 PU801.21
PHASE2_VGA: PC806.2 PQ801.3 PU801.28
PLT_RST#: C494.1 JWLN1.22 R156.1 RL4.2 U4.Y11 U31.13 UL1.2 UV2.1
PLUG_IN: JHP1.5 RA7.2 RA8.2
PM_CLKRUN#: R172.2 U4.AN7
PM_DRAM_PWRGD: R29.2 R133.1 U1.2 U4.H3
PM_SLP_S3#: U4.H1 U31.6
PM_SLP_S4#: U4.C6 U31.127
PM_SLP_S5#: U4.Y7 U31.14
PM_SYS_PWRGD_BUF: JCPU1.AC10 R30.2 R35.1 R36.1 R133.2 U1.4
PROCHOT: PR216.1 PR233.1 Q37.2 U31.103
PS_0: CV28.1 RV23.2 RV30.1 UV1.AM34
PS_1: CV29.1 RV22.2 RV29.1 UV1.AD31
PS_2: CV27.1 RV21.2 RV28.1 UV1.AG31
PS_3: CV26.1 RV20.2 RV27.1 UV1.AD33
PSI#_VGA: PR833.2 PR834.2 PR835.2 PU801.2
PWR_LED#: JLED1.6 LED1.1 U31.92
PX_EN: UV1.AL21
QSA0: UV1.C34 UV5.C7
QSA1: UV1.D29 UV6.C7
QSA2: UV1.D25 UV5.F3
QSA3: UV1.E20 UV6.F3
QSA4: UV1.E16 UV7.F3
QSA5: UV1.E12 UV7.C7
QSA6: UV1.J10 UV8.F3
QSA7: UV1.D7 UV8.C7
QSA#0: UV1.A34 UV5.B7
QSA#1: UV1.E30 UV6.B7
QSA#2: UV1.E26 UV5.G3
QSA#3: UV1.C20 UV6.G3
QSA#4: UV1.C16 UV7.G3
QSA#5: UV1.C12 UV7.B7
QSA#6: UV1.J11 UV8.G3
QSA#7: UV1.F8 UV8.B7
QSB0: UV1.F6 UV9.C7
QSB1: UV1.K3 UV10.C7
QSB2: UV1.P3 UV9.F3
QSB3: UV1.V5 UV10.F3
QSB4: UV1.AB5 UV11.F3
QSB5: UV1.AH1 UV11.C7
QSB6: UV1.AJ9 UV12.F3
QSB7: UV1.AM5 UV12.C7
QSB#0: UV1.G7 UV9.B7
QSB#1: UV1.K1 UV10.B7
QSB#2: UV1.P1 UV9.G3
QSB#3: UV1.W4 UV10.G3
QSB#4: UV1.AC4 UV11.G3
QSB#5: UV1.AH3 UV11.B7
QSB#6: UV1.AJ8 UV12.G3
QSB#7: UV1.AM3 UV12.B7
RASA0#: UV1.K23 UV5.J3 UV6.J3
RASA1#: UV1.K19 UV7.J3 UV8.J3
RASB0#: UV1.T10 UV9.J3 UV10.J3
RASB1#: UV1.Y10 UV11.J3 UV12.J3
RBIAS_VGA: PR836.1 PU801.3
RED: C525.1 JCRT1.1 L30.2 U10.3
REMOTE1+: C587.1 RV16.1 U9.2
REMOTE1-: C587.2 RV17.1 U9.3
RI#: RP10.8 U4.N4
RTN_VGA: PC862.2 PC863.2 PR860.2 PR861.2 PU801.13
S3_1.35V: PC503.1 PR502.2 PU501.7
S5_1.35V: PC508.1 PR505.2 PU501.8
SATA_ACT#: R108.2 U4.AP3
SATA_COMP: R107.1 U4.AY5
SATA_DTX_C_PRX_N4: C596.1 U4.BD13
SATA_DTX_C_PRX_N5: C614.1 R403.1 U4.BC14
SATA_DTX_C_PRX_P4: C597.1 U4.BB13
SATA_DTX_C_PRX_P5: C613.1 R404.1 U4.BE14
SATA_DTX_PRX_N4: C596.2 JHDD1.5
SATA_DTX_PRX_N5_14: C614.2 JODD1.5
SATA_DTX_PRX_N5_15: JODD2.5 R403.2
SATA_DTX_PRX_P4: C597.2 JHDD1.6
SATA_DTX_PRX_P5_14: C613.2 JODD1.6
SATA_DTX_PRX_P5_15: JODD2.6 R404.2
SATA_PTX_C_DRX_N4: C114.2 U4.AV15
SATA_PTX_C_DRX_N5: C615.1 R402.1 U4.AP15
SATA_PTX_C_DRX_P4: C116.2 U4.AW15
SATA_PTX_C_DRX_P5: C616.1 R401.1 U4.AR15
SATA_PTX_DRX_N4: C114.1 JHDD1.3
SATA_PTX_DRX_N5_14: C615.2 JODD1.3
SATA_PTX_DRX_N5_15: JODD2.3 R402.2
SATA_PTX_DRX_P4: C116.1 JHDD1.2
SATA_PTX_DRX_P5_14: C616.2 JODD1.2
SATA_PTX_DRX_P5_15: JODD2.2 R401.2
SDIO: PR905.2 PR906.1 PU901.3
SERIRQ: R223.1 U4.AL11 U31.3
SLP_A#: T22.1(TP-1) U4.F3
SLP_SUS: Q118.2 Q124.1 R780.2
SLP_SUS#: R34.1 U4.F1 U31.17
SM_INTRUDER#: R96.2 U4.A8
SM_RCOMP0: JCPU1.AP3 R5.1
SM_RCOMP1: JCPU1.AR3 R6.1
SM_RCOMP2: JCPU1.AP2 R7.1
SMB_CLK_S3: JDIMM1.202 JDIMM2.202 Q11.1 R501.2 RP16.7
SMB_DATA_S3: JDIMM1.200 JDIMM2.200 Q11.4 R502.2 RP16.6
SML1CLK: Q130.6 RP17.5 U4.K6
SML1DATA: Q130.3 RP17.6 U4.N11
SNB_0.95V: PC634.1 PR610.2
SNB_1.5V: PC601.1 PR603.2
SNUB1_VGA: PC865.1 PR855.2
SNUB2_VGA: PC811.1 PR826.2
SNUB_CPU1: PC922.1 PR937.2
SNUB_CPU2: PC930.1 PR940.2
SNUB_CPU3: PC940.1 PR943.2
SPI_CLK_PCH: R240.1 RP2.3 U8.6
SPI_CLK_PCH_R: R237.1 R240.2 U4.AJ11
SPI_CS#: RP2.4 U4.AJ7 U8.1
SPI_HOLD#: R245.1 U8.7
SPI_IO2: R229.2 R246.2 U4.AJ4
SPI_IO3: R230.2 R245.2 U4.AJ2
SPI_SB_CS1#: U4.AL7
SPI_SI: RP2.2 U4.AH1 U8.5
SPI_SO: RP2.1 U4.AH3 U8.2
SPI_WP#: R246.1 U8.3
SPK_L1-: LA3.1 UA1.14
SPK_L1-_CONN: CA39.1 DA3.3 JSPK1.3 LA3.2
SPK_L2+: LA4.1 UA1.12
SPK_L2+_CONN: CA38.1 DA3.1 JSPK1.4 LA4.2
SPK_R1-: LA1.1 UA1.15
SPK_R1-_CONN: CA43.1 DA3.6 JSPK1.1 LA1.2
SPK_R2+: LA2.1 UA1.17
SPK_R2+_CONN: CA40.1 DA3.4 JSPK1.2 LA2.2
SRN: PC305.1 PC306.2 PR317.2 PR324.3
SRP: PC306.1 PC309.1 PR318.2 PR324.2
SUS_STAT#: T20.1(TP-1) U4.U7
SUSACK#: R136.1 U31.70
SUSACK#_R: R136.2 R169.2 U4.R6
SUSCLK: C93.1 R740.1 U4.Y6 U31.122
SUSP: Q1.2 Q107.2 Q108.2 Q110.2 Q111.2 Q113.2 Q116.2 Q117.1 R652.1 R653.2
SUSP#: PR502.1 PR601.1 PR701.1 Q117.2 U31.116
SUSWARN#: R148.1 U31.72
SUSWARN#_R: R148.2 R169.1 RP10.5 U4.J4
SW1: PC915.2 PL902.1 PQ901.1 PQ901.2 PQ901.3 PQ902.5 PR937.1 PU901.12
SW1_VGA: PL803.1 PQ802.5 PQ802.6 PQ802.7 PR855.1
SW2: PC923.2 PL903.1 PQ903.1 PQ903.2 PQ903.3 PQ904.5 PR940.1 PU902.7
SW2_VGA: PL802.1 PQ801.5 PQ801.6 PQ801.7 PR826.1
SW3: PC913.2 PL904.1 PQ905.1 PQ905.2 PQ905.3 PQ906.5 PR943.1 PU901.17
SWN1: PL902.2 PR920.2 PR931.1
SWN2: PL903.2 PR919.2 PR930.1
SWN3: PL904.2 PR918.2 PR929.1
SYS_PWROK: R32.1 R157.1 U4.AD7 U6.4 U31.86
SYS_RST#: R138.1 U4.AM1
SYSON: C492.1 PR505.1 U31.95
TESTEN: RV18.2 RV19.2 UV1.AD28
THERM_D+: RV16.2 UV1.AF29
THERM_D-: RV17.2 UV1.AG29
THM_ALERT#: RV6.2 UV1.AG30
TL_ENVDD: R408.1 R553.1 U72.3 UT2.15
TL_HPD: R458.1 UT2.32
TL_INVT_PWM: R441.1 UT2.14
TMDS_B_CLK#_PCH: C46.2 JCPU1.U31
TMDS_B_CLK_PCH: C47.2 JCPU1.V31
TMDS_B_DATA0#_PCH: C44.2 JCPU1.U29
TMDS_B_DATA0_PCH: C45.2 JCPU1.V29
TMDS_B_DATA1#_PCH: C42.2 JCPU1.T30
TMDS_B_DATA1_PCH: C43.2 JCPU1.U30
TMDS_B_DATA2#_PCH: C48.2 JCPU1.T28
TMDS_B_DATA2_PCH: C41.2 JCPU1.U28
TMDS_B_HPD: Q93.3 R485.1 U4.K40
TP_1: JTP1.1 R619.1 SW7.1 SW7.2
TP_2: JTP1.2 SW5.1 SW5.2 SW6.1 SW6.2
TP_3: JTP1.3 R627.1 SW4.1 SW4.2
TP_CLK: D15.3 JTP1.5 R603.1 U31.87
TP_DATA: D15.2 JTP1.4 R598.1 U31.88
TS_RST#: JTS1.1 R722.2
TSENSE: PC912.2 PR942.1 PU901.8
TURBO_V: PR225.2 PR227.1 PR229.2 PR230.2 PR232.2 PR233.2 U31.102
U2DN1: D22.3 JUSB2.2 L51.2
U2DN2: D31.4 JUSB1.2 L55.2
U2DP1: D22.4 JUSB2.3 L51.3
U2DP2: D31.3 JUSB1.3 L55.3
U3RXDN1: D27.1 D27.9 JUSB2.5 L50.2
U3RXDN2: D30.1 D30.9 JUSB1.5 L54.2
U3RXDP1: D27.2 D27.8 JUSB2.6 L50.3
U3RXDP2: D30.2 D30.8 JUSB1.6 L54.3
U3TXDN1: D27.4 D27.7 JUSB2.8 L49.2
U3TXDN1_L: C849.2 L49.1
U3TXDN2: D30.4 D30.7 JUSB1.8 L53.2
U3TXDN2_L: C850.2 L53.1
U3TXDP1: D27.5 D27.6 JUSB2.9 L49.3
U3TXDP1_L: C847.2 L49.4
U3TXDP2: D30.5 D30.6 JUSB1.9 L53.3
U3TXDP2_L: C848.2 L53.4
UG_1.35V: PQ501.4 PU501.17
UGATE1_VGA: PQ802.2 PU801.20
UGATE2_VGA: PQ801.2 PU801.29
USB3_RX1_N: L50.1 U4.AR26
USB3_RX1_P: L50.4 U4.AP26
USB3_RX2_N: L54.1 U4.AW26
USB3_RX2_P: L54.4 U4.AV26
USB3_TX1_N: C849.1 U4.BE24
USB3_TX1_P: C847.1 U4.BD23
USB3_TX2_N: C850.1 U4.BD25
USB3_TX2_P: C848.1 U4.BC24
USB20_N0: L51.1 U4.B37
USB20_N1: L55.1 U4.A38
USB20_N2: JTS1.4 U4.A36
USB20_N3: L58.1 R684.2 U4.A34
USB20_N3_R: JLVDS1.28 L58.2 R684.1
USB20_N9: L66.4 R868.2 U4.A30
USB20_N9_C: D25.3 JUSB3.3 L66.3 R868.1
USB20_N10: JWLN1.36 U4.B29
USB20_N11: L67.1 R687.2 U4.A28
USB20_N11_R: JCR1.2 L67.2 R687.1
USB20_P0: L51.4 U4.D37
USB20_P1: L55.4 U4.C38
USB20_P2: JTS1.3 U4.C36
USB20_P3: L58.4 R688.2 U4.C34
USB20_P3_R: JLVDS1.27 L58.3 R688.1
USB20_P9: L66.1 R869.2 U4.C30
USB20_P9_C: D25.2 JUSB3.2 L66.2 R869.1
USB20_P10: JWLN1.38 U4.D29
USB20_P11: L67.4 R683.2 U4.C28
USB20_P11_R: JCR1.3 L67.3 R683.1
USB_OC0#: RP14.1 U4.P3 U35.5
USB_OC1#: RP14.6 U4.V1
USB_OC2#: RP14.7 U4.U2
USB_OC3#: RP14.9 U4.P1
USB_OC4#: RP14.4 U4.M3 U36.5
USB_OC5#: RP14.8 U4.T1
USB_OC6#: RP14.2 U4.N2
USB_OC7#: RP14.3 U4.M1
USB_ON#: R594.1 U31.84 U35.4 U36.4
USBRBIAS: R242.1 U4.K24 U4.K26
VGA_B: T26.1(TP-1) UV1.AF37
VGA_CLK: T27.1(TP-1) UV1.AM26
VGA_DAT: T28.1(TP-1) UV1.AN26
VGA_G: T25.1(TP-1) UV1.AE36
VGA_R: T24.1(TP-1) UV1.AD39
VGA_SMB_CK2: QV3.1 RV24.2 UV1.AJ23
VGA_SMB_DA2: QV3.4 RV25.2 UV1.AH23
VGATE: PR916.1 PU901.6 U6.1 U31.74
VL: PC202.1 PC430.1 PR202.2 PR210.2 PR212.2 PU201.8 PU402.7
VMB: PC201.1 PF201.2 PL201.1 PR203.2
VMB2: JBATT1.1 JBATT1.2 JBATT2.1 JBATT2.2 PF201.1
VR_ON: PR914.1 U31.121
VR_SVID_ALRT#: PU901.4 R81.2 R83.1
VR_SVID_CLK: JCPU1.AM29 PR910.1 PU901.5
VR_SVID_DAT: JCPU1.AL28 PR905.1 R87.1
VRON_VGA: PC805.2 PR813.2 PR820.2 PU801.38
VSEN_VGA: PC859.1 PC863.1 PC874.2 PR843.2 PR850.2 PR854.2 PU801.12
VSUM+_VGA: PC860.1 PC861.1 PR827.2 PR851.1 PR853.1 PR856.2 PR859.1 PU801.15
VSUM-_VGA: PC850.2 PC860.2 PC861.2 PC866.1 PC875.2 PH802.2 PR829.2 PR858.2 PR859.2 PR862.2
VSUM_VGA_N001: PC864.1 PR851.2
VSYNC: T6.1(TP-1) UV1.AC38
VW_VGA: PC873.1 PR841.1 PU801.6
WEA0#: UV1.K26 UV5.L3 UV6.L3
WEA1#: UV1.L15 UV7.L3 UV8.L3
WEB0#: UV1.N10 UV9.L3 UV10.L3
WEB1#: UV1.AB11 UV11.L3 UV12.L3
XDP_BPM#0: JCPU1.AR30
XDP_BPM#1: JCPU1.AN31
XDP_BPM#2: JCPU1.AN29
XDP_BPM#3: JCPU1.AP31
XDP_BPM#4: JCPU1.AP30
XDP_BPM#5: JCPU1.AN28
XDP_BPM#6: JCPU1.AP29
XDP_BPM#7: JCPU1.AP28
XDP_DBRESET#: C186.1 JCPU1.AP33 R11.2
XDP_PRDY#: JCPU1.AR29
XDP_PREQ#: JCPU1.AT29
XDP_TCLK: JCPU1.AM34 RP19.7
XDP_TDI: JCPU1.AM31
XDP_TDO: JCPU1.AL33 RP19.5
XDP_TMS: JCPU1.AN33
XDP_TRST#: JCPU1.AM33 RP19.6
XTAL25_IN: C119.1 R215.2 U4.AM43 Y2.1
XTAL25_OUT: C118.1 R215.1 U4.AL44 Y2.3
XTALIN: CV36.2 RV32.1 UV1.AV33 YV1.1
XTALOUT: CV37.2 RV32.2 UV1.AU34 YV1.3
N14438658: PR317.1 PU301.12
N14480890: PR315.2 PR316.1 PU301.10
N14491778: PQ303.1 PQ304.2
N14491788: PQ303.2 PQ307.6 PR302.2
N14491836: PQ305.1 PQ307.2 PQ307.5 PR303.2
N14492090: PD302.1 PD303.1 PQ311.2
N14492092: PC324.1 PD303.2 PQ313.1 PR325.1
N14534043: PC303.2 PR308.2 PR309.2 PU301.6
N14561712: PC317.2 PR320.2
N14568681: PC902.2 PC904.1 PR903.2 PR904.1 PU901.32
N14568937: PR902.1 PR903.1 PU901.33
N14568985: PC907.2 PR908.2 PU901.36
N14569027: PH901.1 PR901.2 PR911.1
N14569153: PC905.1 PR907.1 PU901.30
N14569169: PR914.2 PU901.1
N14569201: PR913.1 PU901.28
N14569343: PC987.1 PR915.2 PU901.2
N14569697: PC904.2 PR904.2 PU901.31
N14569701: PH902.2 PR923.2 PR942.2
N14569997: PR917.2 PU901.7
N14570301: PR921.1 PU901.9
N14570423: PC902.1 PR902.2
N14570565: PC906.2 PR909.2 PU901.34
N14598669: PC702.1 PR704.2 PU701.1
N14598673: PC703.2 PR704.1 PR705.2 PU701.2
N14598909: PC705.2 PC706.1 PR709.1
N14598941: PC706.2 PU701.5
N14599337: PC704.2 PR707.2 PU701.4
N14599537: PC709.1 PR714.2
N16190418: PR831.2 PR832.2 PU801.1
N16774791: JBATT1.5 JBATT2.5 PR206.1 PR207.1 PR209.1
N16791696: PC607.2 PR607.2 PR608.1 PU601.4
N16791716: PC637.1 PR601.2 PR613.2 PU601.1
N16791765: PC605.1 PU601.5
N16792189: PR506.1 PR507.2 PU501.6
N16792225: PR511.2 PU501.13
N16792229: PR509.2 PU501.9
N16792231: PC511.1 PR511.1 PR514.2 PU501.11
N16849024: PC635.2 PR611.2 PR615.1 PU604.4
N16849157: PC630.1 PU604.5
N16986054: PC105.2 PD105.1 PQ101.2 PR104.2
N16986060: PC106.1 PR107.1 PU101.7
N16987330: PQ206.1 PR230.1
N16987354: PQ208.1 PR229.1
N16987356: PQ207.1 PR232.1
N16989960: PR318.1 PU301.13
N16992568: PQ306.1 PR306.2
N16993177: PH201.2 PR228.1
N16993569: PC105.1 PR106.1 PU101.1
N16994095: PC106.2 PD104.1 PQ101.5 PR105.2
N16994577: PC107.1 PR108.1 PR109.2 PU101.2 PU101.5
N17005206: PD101.3 PR102.1
N17017158: PQ102.2 PQ102.3 PR110.2 PR111.1
N17017351: PQ102.6 PR103.2
N17041264: PC419.2 PR413.1
N17139623: PC435.2 PR414.1
N17139626: PC435.1 PR411.2 PU401.3
N17144944: PR415.2 PU401.7
N17242868: PC210.1 PD203.1 PQ209.2 PR208.2
N17242889: PC212.1 PU202.4
N17242951: PQ202.2 PQ202.3 PQ209.1 PR211.1
N17242953: PC208.1 PD201.1 PQ202.5 PR205.2
N17243007: PC207.1 PR202.1 PR213.2 PU201.2
N17243023: PC208.2 PR210.1 PU201.1
N17243100: PC209.1 PR203.1 PR217.2 PU201.6
N17243144: PC210.2 PR212.1 PU201.7
N17243787: PJ503.1 PU501.19
N17454478: C727.1 Q111.1 R647.2 R650.2 U39.4
N17967384: CL7.2 QL1.2 RL3.1
N18116330: Q113.1 R655.2
N19865382: CA5.1 CA6.1 RA1.2 RA2.2 UA1.24
N19867921: CA16.1 CA17.1 RA4.2 UA1.7
N19871308: CL31.1 TL1.3 TL1.6
N19871378: CL30.1 RL14.2
N19889959: CA37.2 CA45.2 RA22.1 RA492.1
N19913181: RL12.2 UL1.39
N20556954: TV15.1(TP-1) UV1.AG28
N23177764: Q107.1 R644.2
N23177889: Q108.1 R645.2
N23302468: JWLN1.49 R505.2 R507.2
N24504317: Q1.1 R35.2
N24517890: JCPU1.AC7 T12.1(TP-1)
N24518400: JCPU1.AG8 T13.1(TP-1)
N24564926: JCPU1.R27 T14.1(TP-1)
N24573387: JCPU1.H27 R88.1 R89.2
N24581358: JCPU1.AK33 T15.1(TP-1)
N24621013: C111.1 R689.2 Y1.1
N24629451: C120.2 R237.2
N24881149: Q6.2 R458.2
N25182664: CA27.1 RA12.2
N25182692: CA28.1 RA16.2
N25274724: CA36.1 RA17.2
N25274821: CA46.1 RA18.2
N25318268: JWLN1.30 R501.1
N25318300: JWLN1.32 R502.1
N25469058: Q95.1 RP5.1 RP5.2 RP5.3 RP5.4 RP6.1 RP6.2 RP6.3 RP6.4
N25473460: C1331.1 Q156.2 R5581.2
N25769445: R28.2 R32.2 U1.1
N25827471: R335.2 U9.4
N26062000: JWLN1.51 R405.2 R506.2
N26145701: C607.1 Q99.2 R675.2
N26145913: Q100.1 R568.2 R675.1
N26456136: JCPU1.AR32 T23.1(TP-1)
N26485616: C37.2 R45.1
N26486894: C39.2 R54.1
N26487339: C40.2 R59.1
N26542098: LED1.2 R623.2
N26542118: LED2.2 R764.2
N26555073: CA7.2 RA21.1
N26597830: LED6.2 R303.2
N26629490: RL6.2 RL7.2 RL9.2 UL1.3
N26736976: C781.1 Q120.1 Q121.2 R778.2
N26737023: Q118.1 R777.2
N26853750: C4.1 U72.4
N26857011: C6.1 U10.8
N27500400: T3.1(TP-1) UA1.1
N28570922: JLVDS1.6 R39.2
N28572861: JWLN1.1 R41.2
N29040315: R406.1 U31.98
N29503322: Q116.1 R659.2
N35039154: JFAN1.1 R581.1
N36335803: RV44.1 UV1.AM39
N36492944: CV42.2 RV34.1
N36493087: CV41.2 RV33.1
N36493316: CV42.1 UV1.AK10
N36493324: CV41.1 UV1.AL10
N36581302: RV12.2 UV1.AM17
N36581441: RV11.1 UV1.AB34
N36775625: RV3.1 UV1.Y29
N36775642: RV1.1 UV1.Y30
N36777317: RV2.1 UV1.AH16
N36816710: CV52.1 QV8.2 RV38.2
N36841309: RV47.2 UV1.M27
N38004471: CV100.1 RV48.2 RV53.2 RV54.1
N38105566: RV85.1 UV6.L8
N38105572: RV84.1 UV5.L8
N38105577: CV195.1 RV60.2 RV61.2
N38190157: RV86.1 UV7.L8
N38190161: RV87.1 UV8.L8
N38194049: CV196.1 RV66.2 RV69.2
N38198198: RV90.1 UV11.L8
N38198202: RV91.1 UV12.L8
N38199303: CV198.1 RV79.2 RV81.2
N38203425: RV89.1 UV10.L8
N38203429: RV88.1 UV9.L8
N38203433: CV197.1 RV72.2 RV73.2
N38212508: CV53.1 QV2.1 RV41.1 RV42.2 UV4.4
N38212553: QV1.1 RV39.1
N39986171: QV6.1 RV37.2 RV38.1
N39986251: QV7.1 RV36.2
N42328962: C520.1 Q83.2 R435.2
N48539214: C660.1 R589.2
N57698799: LED5.2 R765.2
N61785845: CA29.1 UA1.20
N61785847: CA29.2 UA1.19
N61785857: CA30.2 CA35.1 UA1.21
N61786084: CA26.2 UA1.11
N61786096: RA9.2 UA1.6
N62096303: JDIMM2.201 R93.2
N68070790: RT8.2 UT2.8
N293979640: PR711.1 PU701.6
N293979960: PR712.1 PU701.15

Pads without a net: D22 1 6; D31 1 6; D32 5 6; DL1 5; FD1 1; FD2 1; FD3 1; FD4 1; JCPU1 A2 A23 A32 A34 A35 AA1 AA2 AC8 AD8 AD10 AF9 AG9 AK27 AL13 AL16 AL25 AL26 AL27 AL29 AL30 AM2 AM26 AM27 AN20 AN25 AN26 AP21 AP23 AP24 AP25 AP26 AP32 AR1 AR23 AR24 AR33 AR35 AT1 AT2 AT23 AT35 B1 B23 B32 B33 B35 C23 C33 C35 D23 D24 E17 E18 E20 E21 F5 G6 G30 G32 G34 H30 H31 H32 H33 H34 H35 J27 J31 J33 J35 K6 K27 K28 K30 K32 K34 L8 L10 L27 L28 L29 L30 L31 L32 L33 L34 L35 M9 M10 M29 M31 M33 M35 N26 N28 N30 P1 P2 P3 P10 P28 P29 P30 P31 R1 R29 R31 T27 T32 T34 U1 U2 U10 U32 U33 U34 U35 V1 V2 V27 V33 V35 W28 W29 W30 W31 W32 Y1 Y2; JCRT1 4; JDIMM1 77 122 125 198; JDIMM2 77 122 125 198; JHDD1 18 20 21 22; JHDMI1 13 14; JLVDS1 3 4 5 25; JP3 5 6; JWLN1 3 8 10 12 14 16 17 19 42 44 45 46 47; PU301 3 4 11; PU401 2; PU402 2; PU501 10; PU603 5; PU604 2; PU701 16; PU801 4 5; RP13 1 6; RP19 1 8; RP22 1 8; RP23 1 8; TL1 4 5 12 13; U4 A32 A40 AA42 AA44 AB6 AB10 AB39 AB40 AD38 AD39 AE42 AE44 AF7 AF10 AF11 AF43 AF45 AH43 AH45 AJ10 AJ42 AJ44 AN38 AN39 AP29 AR13 AR29 AR33 AT13 AT33 AT39 AT40 AU42 AU44 AV10 AV17 AV29 AV36 AV43 AV45 AW8 AW10 AW13 AW17 AW29 AW31 AW36 AW38 AW44 AY8 AY13 AY31 AY38 AY45 B33 BA2 BA45 BB2 BB9 BB29 BB37 BC8 BC10 BC12 BC26 BC30 BC32 BC36 BC38 BC40 BC45 BD9 BD27 BD37 BD41 BD42 BE8 BE10 BE12 BE26 BE28 BE32 BE36 BE38 BE40 BE43 BE44 C26 C32 C40 D2 D21 D33 F8 F22 F24 F26 F31 F36 F38 F41 G5 G20 G22 G24 G26 G29 G31 H29 H39 H43 H45 J42 J44 K22 K31 K38 K43 K45 L31 L33 M33 N38 N40 R35 R36 Y38 Y39 Y43 Y45; U9 6; U31 36; UA1 37 40; UL1 17 18 20 21 23 24 25 26 28 38; UV1 AA29 AA31 AA32 AA33 AA34 AC10 AC30 AC31 AC32 AD30 AD32 AF30 AF31 AF32 AF33 AF35 AG12 AG21 AG22 AG36 AG38 AH12 AH15 AH18 AH24 AH26 AH35 AH37 AJ13 AJ14 AJ16 AJ19 AJ20 AJ21 AJ24 AJ26 AJ27 AJ30 AJ31 AJ36 AJ38 AK13 AK14 AK16 AK17 AK19 AK20 AK21 AK24 AK26 AK27 AK29 AK30 AK35 AK37 AL16 AL19 AL27 AL29 AL30 AL31 AL36 AM14 AM16 AM19 AM20 AM21 AM27 AM29 AM30 AN7 AN14 AN16 AN20 AN21 AN24 AN36 AP6 AP8 AP10 AP12 AP13 AP14 AP15 AP20 AP21 AP22 AP23 AP24 AP25 AP26 AP34 AP35 AP37 AR1 AR3 AR6 AR8 AR10 AR12 AR14 AR16 AR20 AR22 AR24 AR26 AR30 AR32 AR34 AR35 AR37 AT7 AT9 AT11 AT13 AT15 AT17 AT19 AT21 AT23 AT25 AT27 AT29 AT31 AT33 AU1 AU3 AU5 AU6 AU8 AU10 AU12 AU14 AU16 AU18 AU20 AU22 AU24 AU26 AU28 AU30 AU32 AU35 AU39 AV7 AV9 AV11 AV13 AV15 AV19 AV21 AV23 AV25 AV29 AV31 AW3 AW5 AW6 AW8 AW10 AW12 AW18 AW28 AW34 AW35 AW37 E37 F35 F37 G36 G38 H32 H33 H35 H37 J32 J33 J36 J38 K16 K27 K29 K30 K32 K33 K35 K37 L10 L27 L29 L30 L32 L33 L36 L38 M12 M20 M35 M37 N12 N29 N30 N32 N33 N38 U13 V12 V13 V28 W29 W30 Y31; UV5 J1 J9 L1 L9; UV6 J1 J9 L1 L9; UV7 J1 J9 L1 L9; UV8 J1 J9 L1 L9; UV9 J1 J9 L1 L9; UV10 J1 J9 L1 L9; UV11 J1 J9 L1 L9; UV12 J1 J9 L1 L9; Y2 2 4; YL1 2 4; YV1 2 4

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 741 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 4854 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 145 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 1091 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.95V_EN: length 5.5
  TOP w0.254: PR612.2 171.17,130.96 PC638.2 PR616.2 169.55,129.41 v1(169.72,129.25) 169.72,128.95 169.88,128.79 PU604.1
1.05V_EN: length 5.9
  TOP w0.254: PR702.2 98.68,30.81 99.52,31.65 99.52,31.71 PR701.2 99.52,31.72 PR706.2 99.53,32.69 PC701.1 99.98,33.63 v1(100.61,33.01) 100.9,32.71 PU701.14
1.05VS_EN: length 104.9
  TOP w0.203: U31.108 166.79,73.74
  TOP w0.254: v2(107.83,26.9) 107.11,26.17 100.34,26.17 98.68,27.83 PR702.1 ; 166.79,73.74 165.65,72.6 165.65,70.47 165.92,70.2 165.92,68.98 v1(166.58,68.32) 167.01,67.89 v2(167.01,66.65)
  IN1 w0.254: v2(107.83,26.9) 118.49,26.9 120.43,28.84 120.43,42.12 143.7,65.39 157.88,65.39 v2(158.9,66.41)
  IN2 w0.254: v2(158.9,66.41) 159.14,66.65 v2(167.01,66.65)
1.05VSP_B+:
  vias: v1(113.52,30.99)
1.35V_B+: length 34.5
  TOP w0.508: PR509.1 v2(28.39,6.35)
  IN2 w0.508: v2(28.39,6.35) 28.39,6.28 27.79,5.68 27.79,2.21 28.85,1.15 53.61,1.15 v4(55.86,3.4)
  vias: v1(57.88,2.79) v4(55.86,4.07) v4(56.54,4.09) v4(56.56,3.41)
1.35V_SN: length 1.1
  BOTTOM w0.102: 45.46,2.44 v1(45.46,1.38)
3V5V_EN: length 43.7
  TOP w0.254: v4(102.55,7.45) 102.82,7.71 103.16,7.71 PC431.1 103.58,9.04 PR409.1 103.58,9.04 PR408.1 104.55,9.92 PR407.1
  IN2 w0.254: v4(102.55,7.45) 101.99,6.88 95.1,6.88 93.35,5.13 87.8,5.13 86.53,6.39 81.5,6.39 77.92,2.8 v2(68.18,2.8)
  BOTTOM w0.102: v4(102.55,7.45) 102.55,7.46 v1(103,7.91)
  BOTTOM w0.254: PR410.1 v2(68.18,2.8) ; PU402.1 v4(102.55,7.45)
3V_SN: length 2.5
  TOP w0.102: PC415.1 68.71,12.66 67.72,13.65 66.97,13.65 v1(66.77,13.85)
3V_VIN:
  vias: v1(62.48,9.51) v4(62.11,8.91) v4(62.11,8.28) v4(62.81,8.91) v4(62.81,8.28) v4(63.51,8.91) v4(63.51,8.28)
3VALW_EN:
  vias: v1(68.41,5.65) v2(67.37,5.98) v2(67.97,5.97)
5V_SN: length 4.8
  TOP w0.102: PR406.2 102.71,5.89 v1(104.21,4.39)
  TOP w0.508: PR406.2 101.75,4.37 PC429.1
5V_VCC: length 1.7
  BOTTOM w0.102: v1(100.12,8.14) 100.44,7.82 v4(100.44,7.48)
  BOTTOM w0.254: PU402.5 100.75,7.16 v4(100.44,7.48)
5V_VIN:
  vias: v1(96.08,5.99) v2(97.07,5.28) v2(97.87,5.53) v2(98.48,5.53)
5VS_GATE: length 4.3
  BOTTOM w0.102: v1(134,1.82) R646.2
  BOTTOM w0.254: R646.2 133.99,2.98 R649.2 134.63,3.88 135.08,4.33 Q110.1
5VS_GATE_R: length 4.3
  BOTTOM w0.102: v1(130.43,2.03) U38.4
  BOTTOM w0.254: U38.4 131.44,3.55 131.81,3.91 C726.1 133.04,3.91 R649.1
+0.95VGS: length 24.4
  IN2 w0.508: v2(151.52,148.19) 151.44,148.11 151.44,147.72 151.75,147.42 151.75,146.01 149.07,143.33 149.07,137.63 149.23,137.48 v2(149.23,132.78)
  BOTTOM w0.254: v2(149.23,132.15) 149.14,132.06 148.18,132.06
  BOTTOM w0.305: UV1.N27 UV1.N28 ; UV1.T27 UV1.T28
  BOTTOM w0.508: LV6.1 152.13,151.19 151.39,150.46 151.39,148.96 151.46,148.89 151.46,148.87 151.52,148.8 v2(151.52,148.19)
  vias: v1(132.71,134.59) v2(126.21,133.57) v2(126.9,133.59) v2(129.68,134.08) v2(130.85,134.11) v2(132.06,134.11) v2(133.27,134.11) v4(155.6,126.97) v4(155.6,126.32) v4(156.28,126.97) v4(156.28,126.32) v4(156.95,126.97) v4(156.95,126.32) v4(157.61,126.98) v4(157.61,126.33)
+0.95VGSP: length 2.9
  TOP w0.254: PC635.1 PR611.1 167.15,130.25 166.92,130.48 166.22,130.48
  vias: v1(156.18,131.23) v4(160.42,131.2) v4(160.42,130.55) v4(161.09,131.2) v4(161.09,130.55) v4(161.77,131.2) v4(161.77,130.55) v4(162.43,131.22) v4(162.43,130.57)
+0.675VS: length 75
  IN1 w1.524: 97.2,36.12 96.44,35.35 96.44,31.54 93.77,28.88 52.05,28.88 39.22,16.05 34.28,16.05 33.22,14.98
  vias: v1(30.09,14.89) v2(97.61,43.14) v2(97.61,42.38) v2(98.04,56.13) v2(98.03,55.41) v2(98.37,36.67) v2(98.37,35.91) v2(98.65,48.91) v2(98.66,49.63) v4(29.85,13.82) v4(30.5,13.84) v4(31.14,13.84) v4(31.78,13.85)
+0.675VSP: length 1.9
  TOP w0.203: 33.84,11.06 33.84,10.7 33.14,10.01 PU501.2
  vias: v1(33.95,11.91)
+1.05V_+1.5V_RUN: length 29.9
  TOP w0.254: U4.BB44 118.2,76.02 v2(118.64,76.02) 118.64,76.65 118.99,77.01 U4.AW40 ; v2(124.22,80.81) 124.61,80.42 U4.AF34 ; v2(115.27,85.02) 116.48,85.02 U4.BE22 ; U4.AK28 123.18,83.01 v2(123.49,83.32) 123.49,83.4 123.18,83.71 U4.AK26 ; v2(121.29,90.13) 121.46,90.13 121.78,89.81 U4.AN11
  IN1 w0.508: 121.96,87.54 121.96,85.03 123.49,83.5 v2(123.49,83.32) ; v2(115.27,85.02) 116.83,86.59 116.83,89.71 117.25,90.13 v2(121.29,90.13) ; v2(118.64,76.02) 124.21,76.02 124.88,76.69 124.88,79.61
  vias: v1(123.73,78.56)
+1.5VGS: length 208
  TOP w0.102: v2(114.07,132.62) 114.07,132.63
  TOP w0.254: UV5.E9 106.39,129.25 v2(106.01,129.62) ; UV7.F1 106.38,154.35 v2(105.99,154.75) ; v2(128.94,165.57) 129.34,165.97 UV9.K2 ; UV5.H9 106.42,131.65 v2(105.99,131.22) ; UV9.D9 124.56,171.57 v2(124.16,171.17) ; UV12.R9 144.3,165.14 v2(143.93,164.76) ; UV5.C9 v2(105.87,127.65) ; v2(133.74,164.65) 133.74,164.77 133.37,165.15 UV9.R1 ; UV7.B2 UV7.C1 v2(105.65,156.72) ; v2(132.11,164.73) 132.11,164.82 UV9.N1 ; UV7.A8 111.98,158.61 v2(112.22,158.85) ; UV12.A8 155.79,165.97 v2(156.03,165.72) ; v2(113.25,148.36) 113.23,148.38 113.22,148.38 112.88,148.72 UV7.N9 ; UV7.K8 112.07,151.12 v2(112.41,150.78) ; v2(150.33,166.36) 150.33,166.39 150.7,166.76 UV12.G7 ; UV12.H2 149.8,170.77 149.58,170.54 v2(149.58,170.38) ; UV5.N9 106.39,135.65 v2(106.02,136.02) ; v2(127.34,170.37) 127.34,170.34 UV9.G7 ; UV5.B2 UV5.A1 112.82,126.05 112.3,125.52 v2(112.26,125.52) ; UV9.E9 125.37,171.61 v2(125.74,171.98) ; UV5.R9 106.42,137.25 v2(106.01,137.66) ; UV9.B2 UV9.C1 ; UV9.C1 UV9.D2 ; UV9.C1 123.77,165.16 v2(124.17,164.76) ; UV5.K8 107.23,133.25 v2(106.82,133.66) ; v2(125.78,164.76) 126.17,165.15 UV9.F1 ; UV9.N9 131.77,171.6 v2(132.14,171.98) ; v2(127.34,172) 127.77,171.57 UV9.H9 ; v2(150.33,164.79) 149.96,165.17 UV12.H9 ; UV5.H2 112.03,131.64 111.65,131.26 v2(111.63,131.26) ; UV9.K8 129.37,170.77 v2(129.78,171.17) ; UV12.C1 UV12.D2 ; UV12.C1 153.9,171.51 154.65,170.77 UV12.B2 ; UV12.C1 v2(153.9,172.13) ; UV5.F1 112.83,130.05 v2(113.22,129.66) ; v2(106.82,128.85) 106.79,128.82 106.79,128.82 106.43,128.45 UV5.D9 ; UV9.H2 127.77,165.9 127.44,165.57 v2(127.43,165.57) ; v2(148.73,171.16) 148.34,170.77 UV12.K2 ; v2(133.77,171.98) 133.37,171.57 UV9.R9 ; UV5.A8 v2(107.23,125.49) ; v2(106.78,153.07) 107.13,152.72 UV7.H2 ; v2(113.25,128.03) 112.97,127.76 112.94,127.76 UV5.C1 UV5.D2 ; UV7.C9 112.94,156.72 113.09,156.87 113.33,156.87 v2(113.34,156.86) 113.34,156.48 UV7.D9 ; UV9.C9 v2(123.77,172.13) ; UV7.G7 111.19,153.52 111.56,153.15 v2(111.59,153.15) ; UV7.R9 112.82,147.12 v2(113.19,146.75) ; v2(105.94,148.31) 105.97,148.31 UV7.N1 ; v2(106.8,158.73) 106.39,158.32 UV7.A1 ; v2(145.49,172.01) 145.49,171.98 UV12.N1 ; UV7.K2 107.18,151.15 v2(106.79,151.55) ; v2(151.9,164.77) UV12.E9 ; UV5.K2 112.03,133.2 v2(112.41,132.82) ; v2(107.62,131.22) 107.65,131.22 UV5.G7 ; v2(106.79,156.32) 106.79,156.32 UV7.D2 ; v2(144.7,171.19) 144.7,171.21 144.34,171.57 UV12.R1 ; UV12.F1 151.52,171.57 v2(151.93,171.98) ; UV12.N9 145.9,165.02 v2(145.58,164.7) ; UV12.C9 153.9,165.17 v2(153.51,165.57) 153.11,165.17 UV12.D9 ; UV9.A1 122.17,165.26 v2(121.63,165.8) ; v2(156.06,170.89) 156.06,171.03 155.52,171.57 UV12.A1 ; UV7.R1 106.38,147.14 v2(106.76,147.52) ; v2(147.9,165.57) UV12.K8 ; UV9.A8 v2(121.6,170.77)
  TOP w0.508: CV121.1 127.03,174.9 127.05,174.89 RV74.1 v2(127.93,174.24) ; 143.34,174.95 143.33,174.97 143.33,176.15 143.68,176.5 147.44,176.5 147.76,176.18 RV78.1 ; CV146.1 105.22,143.81 v2(105.22,144.79) ; v2(135.18,174.19) 135.18,174.38 135.69,174.89 CV188.1 ; v2(114.37,129.15) 114.96,129.73 CV106.1 ; CV60.1 114.79,137.03 114.75,136.99 ; CV158.1 135.86,172.84 135.86,173.89 v2(135.91,173.94) 136.16,174.19 136.55,174.19 137.04,174.68 CV124.1 ; CV122.1 103.63,130.69 v2(104.71,130.69) ; CV185.1 158.79,172.76 v2(158.8,172.77) ; CV120.1 103.6,140.09 v2(104.05,140.54) ; CV117.1 CV154.1 114.89,133.45 114.07,132.63 ; RV62.1 104.03,132.45 104.04,132.44 v2(104.75,132.44) ; CV129.1 103.58,149.14 104.56,149.14 104.93,148.76 104.93,147.42 v2(104.85,147.33) 103.57,147.33 CV132.1 ; v2(129.31,144.28) 129.28,144.31 CV71.1 ; CV159.1 v2(124.19,174.2) ; CV176.1 156.82,174.49 157.08,174.23 157.09,174.23 v2(157.12,174.2) ; v2(152.92,174.23) 153.27,174.58 CV191.1 ; v2(120.7,174.2) 120.72,174.22 120.72,174.89 CV171.1 ; v2(125.41,143.09) 125.41,143.13 RV49.1 ; v2(131.38,174.17) 131.54,174.33 CV170.1 ; v2(105.38,139.53) 105.3,139.61 CV139.1 ; CV138.1 103.43,145.44 103.79,145.44 v2(104.34,144.89) ; v2(151.14,174.25) 151.44,174.55 CV190.1 ; v2(118.7,171.56) 118.84,171.7 CV160.1 ; CV155.1 v2(122.45,174.17) ; v2(154.71,174.23) 155.03,174.55 CV178.1 ; RV68.1 103.58,154.68 v2(104.76,154.68) ; CV162.1 v2(120.03,174.21)
  IN2 w0.508: v2(142.72,149.72) 142.72,149.16 144.62,147.27 148.65,147.27 150.09,148.71 150.7,148.71 151.35,149.35 156.91,149.35 v2(156.92,149.37)
  BOTTOM w0.254: UV11.F1 v2(151.9,164.77) ; UV12.K2 148.34,170.77 v2(148.73,171.16) ; v2(144.7,171.19) 144.69,171.19 144.3,171.57 UV12.R1 ; v2(133.37,151.44) 133.49,151.44 133.85,151.8 ; UV7.N9 112.9,148.72 113.23,148.4 113.23,148.38 v2(113.25,148.36) ; UV5.K8 107.23,133.25 v2(106.82,133.66) ; UV6.A8 112.03,125.75 v2(112.26,125.52) ; UV6.E9 112.83,129.26 v2(113.22,129.66) ; v2(121.64,171.9) 121.97,171.57 UV10.A1 ; v2(113.19,146.75) 112.82,147.12 UV7.R9 ; v2(156.06,170.89) 155.95,170.77 UV11.A8 ; v2(125.78,164.76) 125.37,165.17 UV10.E9 ; UV8.G7 108.12,153.66 108.66,153.66 108.96,153.96 v2(109.13,153.96) ; v2(113.34,156.86) 113.06,156.86 112.92,156.72 UV7.C9 UV8.B2 ; UV5.K2 112.03,133.2 v2(112.41,132.82) ; v2(125.44,136.96) 125.65,136.75 UV1.G26 ; v2(143.93,164.76) 144.3,165.14 UV12.R9 ; UV9.R1 133.37,165.15 133.74,164.77 v2(133.74,164.65) ; v2(106.76,147.52) 106.76,147.51 106.38,147.12 UV7.R1 ; v2(147.9,165.57) UV12.K8 ; v2(152.7,166.37) 153.1,165.97 UV11.D2 ; UV7.K2 107.18,151.15 v2(106.79,151.55) ; v2(126.35,168.01) 126.35,168.01 126.83,167.53 126.83,166.9 UV10.G7 ; v2(140.42,149.2) 139.88,148.67 UV1.AD11 ; v2(126.32,146.62) 126.32,146.57 125.83,146.07 UV1.G14 ; UV6.D2 107.22,128.45 v2(106.82,128.85) ; UV10.D2 124.56,170.77 124.16,171.16 v2(124.16,171.17) ; UV9.K8 129.37,170.77 v2(129.78,171.17) ; UV12.C1 v2(153.9,172.13) ; UV11.G7 150.86,169.82 150.86,169.22 150.95,169.14 150.95,168.79 v2(151.21,168.53) ; UV1.J9 127.25,150.27 v2(126.85,149.87) 126.46,149.47 UV1.H10 ; UV10.F1 126.16,171.57 v2(125.74,171.98) ; UV11.A1 155.73,165.17 156.03,165.47 v2(156.03,165.72) ; UV6.H9 112.9,131.65 112.93,131.62 113.69,131.62 114.07,132 v2(114.07,132.62) ; UV5.C1 112.83,127.65 113.22,128.03 v2(113.25,128.03) 112.83,128.45 UV6.D9 ; UV11.B2 UV12.C9 153.89,165.18 153.89,165.19 v2(153.51,165.57) ; v2(105.87,127.65) UV5.C9 UV6.B2 ; UV12.N1 145.49,171.98 v2(145.49,172.01) ; UV7.N1 105.97,148.31 v2(105.94,148.31) ; v2(142.72,149.72) 142.62,149.72 142.38,149.47 UV1.AG10 ; v2(106.8,158.73) 106.94,158.59 106.95,158.59 107.18,158.36 UV8.A8 ; v2(107.62,131.22) 107.23,131.61 UV6.H2 ; v2(128.94,165.57) 129.34,165.97 UV9.K2 ; v2(112.22,158.85) 112.25,158.85 112.78,158.32 UV8.A1 ; UV7.K8 112.07,151.12 v2(112.41,150.78) ; UV6.F1 106.43,130.03 v2(106.01,129.62) ; v2(142.85,151.57) 143.15,151.57 UV1.AJ7 ; v2(105.96,153.18) 105.96,153.14 UV8.H9 ; v2(150.37,171.99) 150.32,171.99 UV11.H9 ; v2(145.58,164.7) 145.9,165.02 UV12.N9 ; v2(106.02,125.52) 106.43,125.92 UV6.A1 ; UV11.E9 152.3,171.6 v2(151.93,171.98) ; v2(109.89,130.19) 109.9,130.19 110.13,130.42 110.14,130.42 110.43,130.71 111.09,130.71 UV6.G7 ; v2(121.63,165.8) 121.79,165.97 UV10.A8 ; UV10.H9 127.77,165.24 v2(127.43,165.57) ; v2(150.33,166.36) 149.94,165.97 UV11.H2 ; UV8.H2 111.98,152.75 v2(111.59,153.15) ; v2(111.61,155.52) 111.61,155.53 111.98,155.9 UV8.D2 ; UV9.N1 132.11,164.82 v2(132.11,164.73) ; v2(127.34,170.37) 127.74,170.77 UV10.H2 ; UV10.B2 UV9.C9 v2(123.77,172.13) ; v2(125.41,147.86) 125.41,148.23 UV1.G11 ; UV9.C1 123.77,165.15 124.16,164.76 v2(124.17,164.76) 124.57,165.16 UV10.D9 ; UV7.C1 105.93,156.72 105.93,156.73 105.65,156.73 v2(105.65,156.72) ; UV5.R9 106.42,137.25 v2(106.01,137.66) ; UV5.N9 106.39,135.65 v2(106.02,136.02) ; v2(152.73,171.99) 153.1,171.61 UV11.D9 ; v2(105.99,154.75) 106.36,155.12 UV8.E9 ; UV8.D9 106.36,155.92 v2(105.99,155.55)
  BOTTOM w0.305: v2(125.59,140.74) 125.59,141.21 UV1.G20 ; v2(145.66,149.85) 145.25,150.26 UV1.AL9 UV1.AK8 ; UV1.AF7 141.58,151.87 v2(141.62,151.83) ; UV1.G29 125.65,134.35 v2(125.37,134.63) ; UV1.L26 128.85,136.62 v2(129.3,136.18) ; UV1.P7 131.05,151.47 130.91,151.47 v2(130.89,151.49) ; UV1.U7 133.85,151.8 ; UV1.Y7 136.53,152.15 v2(136.9,152.15) ; UV1.L21 129.2,140.32 v2(129.37,140.32) ; v2(139.2,152.23) 138.84,151.87 UV1.AC7 ; v2(128.55,151.47) 128.96,151.87 UV1.L7 ; v2(125.98,139.48) 125.98,139.21 125.65,138.89 UV1.G23 ; UV1.K8 128.05,151.07 UV1.J7 127.25,151.92 v2(126.85,152.33) ; v2(129.32,138.31) 128.96,138.67 UV1.L23
  BOTTOM w0.356: UV1.U11 133.85,148.61 v2(133.38,148.14)
  BOTTOM w0.381: UV1.Y11 135.85,148.65 136.28,148.22 v2(136.28,148.22) ; v2(129.31,144.28) 128.92,144.67 UV1.L16 ; v2(125.41,143.09) 125.41,143.43 UV1.G17
  BOTTOM w0.508: CV115.1 v2(158.8,172.77) ; CV159.1 v2(124.19,174.2) ; v2(104.74,156.46) 104.73,156.47 CV135.1 ; v2(104.75,132.44) 104.65,132.54 CV72.1 ; CV179.1 145.85,175.21 145.5,175.56 144.42,175.56 144.07,175.22 CV183.1 144.07,174.62 v2(143.61,174.15) ; v2(146.63,162.21) 146.3,161.88 RV80.1 ; CV184.1 120.02,174.19 v2(120.03,174.21) ; v2(104.76,153.77) 104.75,153.78 CV145.1 CV136.1 ; v2(105.38,139.53) 105.39,139.54 CV113.1 ; v2(118.7,171.56) 118.71,171.55 119.26,171.55 CV165.1 ; RV52.1 156.05,148.39 RV51.1 156.2,148.39 156.92,149.11 156.92,149.37 v2(156.92,149.37) ; v2(104.34,144.89) 103.79,145.44 103.4,145.44 CV116.1 ; CV167.1 v2(120.7,174.2) ; v2(104.73,127.03) CV107.1 103.61,126.14 CV109.1 ; CV75.1 140.62,171.55 141.56,172.49 v2(141.56,172.71) ; CV194.1 149.39,173.87 150.37,172.89 v2(150.37,171.99) ; CV164.1 114.91,150.3 114.89,150.28 ; CV186.1 v2(152.92,174.23) ; CV144.1 103.98,158.25 104,158.23 v2(104.77,158.23) ; v2(142.77,174.2) 142.98,174.42 142.98,174.69 CV192.1 ; RV63.1 v2(104.73,128.82) ; CV175.1 v2(154.71,174.23) ; CV155.1 v2(122.45,174.17) ; CV118.1 103.82,137.53 v2(104.92,137.53) ; CV177.1 157.4,174.48 v2(157.12,174.2) ; v2(104.91,134.45) CV119.1 ; CV108.1 103.63,140.12 v2(104.05,140.54) ; CV193.1 v2(151.14,174.25) ; CV112.1 114.2,152.98 v2(114.11,153.06) ; v2(104.3,146.49) RV67.1
  vias: v2(104.8,160.12) v2(105.19,159.67) v2(105.6,160.12) v2(113.17,154.73) v2(113.16,153.15) v2(113.24,136.04) v2(113.87,136.2) v2(114.35,147.63) v2(117.3,172.17) v2(117.7,171.71) v2(118.07,172.17) v2(122.68,123.42) v2(122.68,122.78) v2(123.31,123.42) v2(123.31,122.78) v2(123.95,123.42) v2(123.95,122.78) v2(123.96,124.67) v2(123.96,124.04) v2(124.59,124.67) v2(124.59,124.04) v2(124.58,123.42) v2(124.58,122.78) v2(128.53,148.18) v2(129.55,173.42) v2(130.33,148.42) v2(131.35,148.45) v2(158.66,170.72) v2(159.04,170.22) v2(159.42,169.73) v3(130.17,118.79)
